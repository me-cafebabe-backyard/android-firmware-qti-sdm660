tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
      tindex ezaxi:0xfc4cf980 %l 0x8310000 0x310000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
      tindex ezaxi:0xfc4cf980 %l 0x8310010 0x310010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
      tindex ezaxi:0xfc4cf980 %l 0x8310020 0x310020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
      tindex ezaxi:0xfc4cf980 %l 0x8310030 0x310030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
      tindex ezaxi:0xfc4cf980 %l 0x8310040 0x310040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
      tindex ezaxi:0xfc4cf980 %l 0x8310050 0x310050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_STATUS (at 0x11008)"
      tindex ezaxi:0xfc4cf980 %l 0x8310080 0x310080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0 (STATUS_DLL_NOT_LOCKED),1 (STATUS_DLL_LOCKED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
      tindex ezaxi:0xfc4cf980 %l 0x8310100 0x310100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
      tindex ezaxi:0xfc4cf980 %l 0x8310110 0x310110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
      tindex ezaxi:0xfc4cf980 %l 0x8310120 0x310120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
      tindex ezaxi:0xfc4cf980 %l 0x8310130 0x310130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
      tindex ezaxi:0xfc4cf980 %l 0x8310140 0x310140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
      tindex ezaxi:0xfc4cf980 %l 0x8310150 0x310150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
      tindex ezaxi:0xfc4cf980 %l 0x8310160 0x310160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
      tindex ezaxi:0xfc4cf980 %l 0x8310180 0x310180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
      tindex ezaxi:0xfc4cf980 %l 0x8310190 0x310190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
      tindex ezaxi:0xfc4cf980 %l 0x83101a0 0x3101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
      tindex ezaxi:0xfc4cf980 %l 0x83101b0 0x3101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
      tindex ezaxi:0xfc4cf980 %l 0x8310460 0x310460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
      tindex ezaxi:0xfc4cf980 %l 0x8310500 0x310500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0 (DLL_LOCK_CHECK_DISABLED_0),1 (DLL_LOCK_CHECK_DISABLED_1),2 (WAIT_FOR_DLL_LOCK),3 (WAIT_FOR_10_US)"
    tree.end
    tree "BCLK_GEN_MAIN_QM_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_QM_MODE (at 0x11051)"
      tindex ezaxi:0xfc4cf980 %l 0x8310510 0x310510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0 (QUIET_MODE_DISABLED),1 (QUIET_MODE_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8310d00 0x310d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8310d90 0x310d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
      tindex ezaxi:0xfc4cf980 %l 0x8310da0 0x310da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
      tindex ezaxi:0xfc4cf980 %l 0x8310db0 0x310db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8310e00 0x310e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8310e10 0x310e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8310e20 0x310e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8310e30 0x310e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8310e40 0x310e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_TRISTATE),1 (ATEST_1S_2T_3T),2 (ATEST_1T_2S_3T),3 (ATEST_1S_2S_3T),4 (ATEST_1T_2T_3S),5 (ATEST_1S_2T_3S),6 (ATEST_1T_2S_3S),7 (ATEST_1S_2S_3S)"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8310e50 0x310e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0 (USE_MAIN_CLK),1 (USE_ALT_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0 (ALT_CLK_DTEST1),1 (ALT_CLK_DTEST2),2 (ALT_CLK_DTEST3),3 (ALT_CLK_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BOOST"
  tree "BOOST"
    tree "BOOST_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_REVISION1 (at 0x1a000)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0000 0x3a0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BOOST_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_REVISION2 (at 0x1a001)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0010 0x3a0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BOOST_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_REVISION3 (at 0x1a002)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0020 0x3a0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BOOST_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_REVISION4 (at 0x1a003)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0030 0x3a0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BOOST_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_PERPH_TYPE (at 0x1a004)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0040 0x3a0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BOOST_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_PERPH_SUBTYPE (at 0x1a005)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0050 0x3a0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BOOST_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_STATUS1 (at 0x1a008)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0080 0x3a0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
    tree.end
    tree "BOOST_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_RT_STS (at 0x1a010)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0100 0x3a0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BOOST_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_SET_TYPE (at 0x1a011)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0110 0x3a0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BOOST_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_POLARITY_HIGH (at 0x1a012)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0120 0x3a0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BOOST_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_POLARITY_LOW (at 0x1a013)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0130 0x3a0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BOOST_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_LATCHED_CLR (at 0x1a014)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0140 0x3a0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "BOOST_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_EN_SET (at 0x1a015)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0150 0x3a0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BOOST_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_EN_CLR (at 0x1a016)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0160 0x3a0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BOOST_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_LATCHED_STS (at 0x1a018)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0180 0x3a0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BOOST_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_PENDING_STS (at 0x1a019)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0190 0x3a0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BOOST_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_MID_SEL (at 0x1a01a)"
      tindex ezaxi:0xfc4cf980 %l 0x83a01a0 0x3a01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BOOST_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_PRIORITY (at 0x1a01b)"
      tindex ezaxi:0xfc4cf980 %l 0x83a01b0 0x3a01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BOOST_OUTPUT_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_OUTPUT_VOLTAGE (at 0x1a041)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0410 0x3a0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "BOOST_BOOST_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BOOST_ENABLE (at 0x1a046)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0460 0x3a0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BOOST_ENABLE                             = " "0 (BOOST_DIS),1 (BOOST_EN)"
    tree.end
    tree "BOOST_CURRENT_LIMIT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_CURRENT_LIMIT (at 0x1a04a)"
      tindex ezaxi:0xfc4cf980 %l 0x83a04a0 0x3a04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SET_CURRENT_MAX                          = " "0 (ILIM_500MA),1 (ILIM_1000MA),2 (ILIM_1500MA),3 (ILIM_2000MA),4 (ILIM_2500MA),5 (ILIM_3000MA),6 (ILIM_3500MA),7 (ILIM_4000MA)"
    tree.end
    tree "BOOST_LOOP_COMP_CAP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_LOOP_COMP_CAP (at 0x1a050)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0500 0x3a0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOOP_COMP_CAP                            = " "0 (COMP_CAP_40PF),1 (COMP_CAP_60PF),2 (COMP_CAP_80PF),3 (COMP_CAP_100PF)"
    tree.end
    tree "BOOST_LOOP_COMP_RES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_LOOP_COMP_RES (at 0x1a051)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0510 0x3a0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOOP_COMP_RES                            = " "0 (COMP_RES_100K),1 (COMP_RES_200K),2 (COMP_RES_500K),3 (COMP_RES_600K)"
    tree.end
    tree "BOOST_SLOPE_COMP_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_SLOPE_COMP_CURRENT (at 0x1a052)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0520 0x3a0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP_CURRNET                       = " "0 (COMP_CURR_4P5UA),1 (COMP_CURR_4UA),2 (COMP_CURR_3P5UA),3 (COMP_CURR_3UA),4 (COMP_CURR_2P5UA),5 (COMP_CURR_2UA),6 (COMP_CURR_1P5UA),7 (COMP_CURR_1UA)"
    tree.end
    tree "BOOST_SLOPE_COMP_DOUBLER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_SLOPE_COMP_DOUBLER (at 0x1a053)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0530 0x3a0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLOPE_COMP_DOUBLER                       = " "0 (COMP_DOUBLER_DIS),1 (COMP_DOUBLER_EN)"
    tree.end
    tree "BOOST_IP_ZERO_DETECTOR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_IP_ZERO_DETECTOR (at 0x1a054)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0540 0x3a0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VOLTAGE_OFFSET                           = " "0 (VOFF_0MV),1 (VOFF_1P5MV),2 (VOFF_3MV),3 (VOFF_4P5MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_DETECT_ON                             = " "0 (IPZERODET_ZERO),1 (IPZERODET_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTOZERO_ON                              = " "0 (AUTOZERO_EN),1 (AUTO_ZERO_DIS)"
    tree.end
    tree "BOOST_RDSON_MNGMNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_RDSON_MNGMNT (at 0x1a055)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0550 0x3a0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PFET_SW_SIZE                             = " "0 (RDSON_HALF),1 (RDSON_FULLSIZE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NFET_SW_SIZE                             = " "0 (RDSON_TWOTHIRDS),1 (RDSON_FULLSIZE)"
    tree.end
    tree "BOOST_MAX_DUTY_CYCLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_MAX_DUTY_CYCLE (at 0x1a056)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0560 0x3a0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MAX_DUTY_CYCLE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_D_MODULATION                          = " "0 (DIS_D_MODULATION),1 (EN_D_MODULATION)"
    tree.end
    tree "BOOST_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_SEC_ACCESS (at 0x1a0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0d00 0x3a0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BOOST_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_PERPH_RESET_CTL1 (at 0x1a0d8)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0d80 0x3a0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BOOST_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_PERPH_RESET_CTL2 (at 0x1a0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0d90 0x3a0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BOOST_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_PERPH_RESET_CTL3 (at 0x1a0da)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0da0 0x3a0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BOOST_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_PERPH_RESET_CTL4 (at 0x1a0db)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0db0 0x3a0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BOOST_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_TEST1 (at 0x1a0e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0e00 0x3a0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BOOST_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_INT_TEST_VAL (at 0x1a0e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0e10 0x3a0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "BOOST_DTEST_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_DTEST_ACCESS (at 0x1a0e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0e20 0x3a0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_ACCESS                             = "
    tree.end
    tree "BOOST_ATEST_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_ATEST_ACCESS (at 0x1a0e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0e30 0x3a0e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_ACCESS                             = " "0 (NO_SIGNAL),1 (VC),2 (NFET_DSNS),3 (NFET_SSNS),4 (VINT7),5 (PVDD_DLOW),6 (PCDD_D0P25),7 (VREF_PS)"
    tree.end
    tree "BOOST_SW_FORCE_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_SW_FORCE_CTRL (at 0x1a0e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0e40 0x3a0e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFET_FORCE                            = " "0 (PFET_FORCE_DIS),1 (PFET_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_FORCE                               = " "0 (PFET_OFF),1 (PFET_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_NFET_FORCE                            = " "0 (NFET_FORCE_DIS),1 (NFET_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NFET_FORCE                               = " "0 (NFET_OFF),1 (NFET_ON)"
    tree.end
    tree "BOOST_PULSESKIP_THRES_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_PULSESKIP_THRES_SEL (at 0x1a0e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0e50 0x3a0e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULSESKIP_ENABLE                         = " "0 (PULSESKIP_ENB),1 (PULSESKIP_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PULSESKIP_THRES                          = " "0 (PULSESKIP_THRES_50MA),1 (PULSESKIP_THRES_100MA),2 (PULSESKIP_THRES_150MA),3 (PULSESKIP_THRES_200MA)"
    tree.end
    tree "BOOST_SMART_BOOST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_SMART_BOOST (at 0x1a0e6)"
      tindex ezaxi:0xfc4cf980 %l 0x83a0e60 0x3a0e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HW_FOLLOW_EN                             = " "0 (IGNORE_BST_REQ),1 (FOLLOW_BST_REQ)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1_FOLLOW_EN                         = " "0 (IGNORE_DTEST1),1 (FOLLOW_DTEST1)"
    tree.end
  tree.end
tree.end
tree "BOOST_BYP"
  tree "BOOST_BYP"
    tree "BOOST_BYP_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_REVISION1 (at 0x1a200)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2000 0x3a2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BOOST_BYP_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_REVISION2 (at 0x1a201)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2010 0x3a2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BOOST_BYP_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_REVISION3 (at 0x1a202)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2020 0x3a2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BOOST_BYP_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_REVISION4 (at 0x1a203)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2030 0x3a2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BOOST_BYP_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PERPH_TYPE (at 0x1a204)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2040 0x3a2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BOOST_BYP_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PERPH_SUBTYPE (at 0x1a205)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2050 0x3a2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BOOST_BYP_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_STATUS1 (at 0x1a208)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2080 0x3a2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (BB_DISABLED),1 (BB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ISL_FLAG                                 = " "0 (ISL_FLAG_LOW),1 (ISL_FLAG_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USL_FLAG                                 = " "0 (USL_FLAG_LOW),1 (USL_FLAG_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LSL_FLAG                                 = " "0 (LSL_FLAG_LOW),1 (LSL_FLAG_HIGH)"
    tree.end
    tree "BOOST_BYP_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_RT_STS (at 0x1a210)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2100 0x3a2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_RT_STS                      = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BOOST_BYP_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_SET_TYPE (at 0x1a211)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2110 0x3a2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BOOST_BYP_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_POLARITY_HIGH (at 0x1a212)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2120 0x3a2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BOOST_BYP_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_POLARITY_LOW (at 0x1a213)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2130 0x3a2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BOOST_BYP_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_LATCHED_CLR (at 0x1a214)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2140 0x3a2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "BOOST_BYP_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_EN_SET (at 0x1a215)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2150 0x3a2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BOOST_BYP_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_EN_CLR (at 0x1a216)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2160 0x3a2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BOOST_BYP_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_LATCHED_STS (at 0x1a218)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2180 0x3a2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BOOST_BYP_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_PENDING_STS (at 0x1a219)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2190 0x3a2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BOOST_BYP_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_MID_SEL (at 0x1a21a)"
      tindex ezaxi:0xfc4cf980 %l 0x83a21a0 0x3a21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BOOST_BYP_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_PRIORITY (at 0x1a21b)"
      tindex ezaxi:0xfc4cf980 %l 0x83a21b0 0x3a21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BOOST_BYP_OUTPUT_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_OUTPUT_VOLTAGE (at 0x1a241)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2410 0x3a2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "BOOST_BYP_OUTPUT_VOLTAGE_MODE_BB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_OUTPUT_VOLTAGE_MODE_BB (at 0x1a242)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2420 0x3a2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "BOOST_BYP_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_MODE_CTL (at 0x1a245)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2450 0x3a2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BBYP_MODE                                = " "0 (FORCED_BYPASS),1 (AUTO_BOOST)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BOOST_MODE                               = " "0 (FORCED_PBM),1 (FORCED_PWM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PULSE_SKIP                               = " "0 (PULSE_SKIP_DIS),1 (PULSE_SKIP_EN)"
    tree.end
    tree "BOOST_BYP_BBYP_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_BBYP_ENABLE (at 0x1a246)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2460 0x3a2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BBYP_ENABLE                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "BOOST_BYP_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_CLK_DIV (at 0x1a24a)"
      tindex ezaxi:0xfc4cf980 %l 0x83a24a0 0x3a24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CLK_DIV                                  = " "0 (MHZ6P4),1 (MHZ4P8),2 (MHZ3P84),3 (MHZ3P2),4 (MHZ2P4),5 (MHZ1P92),6 (MHZ1P6),7 (MHZ1P2)"
    tree.end
    tree "BOOST_BYP_CURRENT_LIMIT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_CURRENT_LIMIT_CTL (at 0x1a24b)"
      tindex ezaxi:0xfc4cf980 %l 0x83a24b0 0x3a24b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   ILIMIT_COUNT                             = " "0 (CYC8),1 (CYC16),2 (CYC32),3 (CYC64)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SET_CURRENT_MAX                          = " "0 (MA500),1 (MA1000),2 (MA1500),3 (MA2000),4 (MA2500),5 (MA3000),6 (MA3500),7 (MA4000)"
    tree.end
    tree "BOOST_BYP_CURRENT_SENSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_CURRENT_SENSE (at 0x1a24c)"
      tindex ezaxi:0xfc4cf980 %l 0x83a24c0 0x3a24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ISENSE_GAIN                              = " "0 (X0P5),1 (X1),2 (X1P5),3 (X2)"
    tree.end
    tree "BOOST_BYP_LOOP_COMP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_LOOP_COMP_CTL (at 0x1a250)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2500 0x3a2500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LOOP_COMP_CAP                            = " "0 (PF40),1 (PF60),2 (PF80),3 (PF100)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOOP_COMP_RES                            = " "0 (KOHM50),1 (KOHM150),2 (KOHM300),3 (KOHM400)"
    tree.end
    tree "BOOST_BYP_SLOPE_COMP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_SLOPE_COMP_CTL (at 0x1a251)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2510 0x3a2510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   SLOPE_COMP_CURRENT                       = " "0 (UA4P5),1 (UA4),2 (UA3P5),3 (UA3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLOPE_COMP_DOUBLER                       = " "0 (DO_NOT_DOUBLE),1 (DOUBLE)"
    tree.end
    tree "BOOST_BYP_IP_ZERO_DETECTOR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_IP_ZERO_DETECTOR (at 0x1a252)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2520 0x3a2520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VOLTAGE_OFFSET                           = " "0 (MV0),1 (MV1P5),2 (MV3),3 (MV4P5)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_DETECT_ON                             = " "0 (ZX_DET_DISABLED),1 (ZX_DET_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTOZERO_ON                              = " "0 (AUTO_ZERORING_DISABLED),1 (AUTO_ZEROING_ENABLED)"
    tree.end
    tree "BOOST_BYP_RDSON_MNGMNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_RDSON_MNGMNT (at 0x1a253)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2530 0x3a2530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BYPASS_PFET_SIZE                         = " "0 (X0P125),1 (X0P25),2 (X0P5),3 (X1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFET_SIZE                                = " "0 (X0P125),1 (X0P25),2 (X0P5),3 (X1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   NFET_SIZE                                = " "0 (X0P125),1 (X0P25),2 (X0P5),3 (X1)"
    tree.end
    tree "BOOST_BYP_MAX_DUTY_CYCLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_MAX_DUTY_CYCLE (at 0x1a254)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2540 0x3a2540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MAX_DUTY_CYCLE                        = " "0 (MAX_DC_DISABLED),1 (MAX_DC_ENABLED)"
    tree.end
    tree "BOOST_BYP_PS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PS_CTL (at 0x1a255)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2550 0x3a2550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PS_THRESHOLD                             = " "0 (MA50),1 (MA100),2 (MA200),3 (MA300)"
    tree.end
    tree "BOOST_BYP_PBM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PBM_CTL (at 0x1a256)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2560 0x3a2560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PBM_ILIMIT                               = " "0 (A2P5),1 (A3),2 (A3P5),3 (A4)"
    tree.end
    tree "BOOST_BYP_PWM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PWM_CTL (at 0x1a257)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2570 0x3a2570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ERR_AMP_GAIN                             = " "0 (LOW_GAIN),1 (HIGH_GAIN)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BLANK_TIME                               = " "0 (NS5),1 (NS10),2 (NS20),3 (NS35)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIN_DUTY_CYCLE                           = " "0 (PCT7P5),1 (PCT9),2 (PCT10),3 (PCT15)"
    tree.end
    tree "BOOST_BYP_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_SOFT_START_CTL (at 0x1a25a)"
      tindex ezaxi:0xfc4cf980 %l 0x83a25a0 0x3a25a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SELECT_THE_MAX_SOFT_START_TIME           = " "0 (US200),1 (US300),2 (US400),3 (US500)"
    tree.end
    tree "BOOST_BYP_VREG_OK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_VREG_OK_CTL (at 0x1a25b)"
      tindex ezaxi:0xfc4cf980 %l 0x83a25b0 0x3a25b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_DEB                              = " "0 (US53P3),1 (US80),2 (US106P7),3 (US133P3)"
    tree.end
    tree "BOOST_BYP_MODE_TRSN_VTH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_MODE_TRSN_VTH (at 0x1a25c)"
      tindex ezaxi:0xfc4cf980 %l 0x83a25c0 0x3a25c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BYP_TO_BOOST_VTH                         = " "0 (MV0),1 (MV10),2 (MV20),3 (MV30),4 (MV40),5 (MV50),6 (MV60),7 (MV70)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   BOOST_TO_BYP_VTH                         = " "0 (MV0X),1 (MV25),2 (MV50X),3 (MV75),4 (MV100),5 (MV125),6 (MV150),7 (MV175)"
    tree.end
    tree "BOOST_BYP_MODE_TRSN_DEB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_MODE_TRSN_DEB (at 0x1a25d)"
      tindex ezaxi:0xfc4cf980 %l 0x83a25d0 0x3a25d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   BYP_TO_BOOST_DEB                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BOOST_TO_BYP_DEB                         = "
    tree.end
    tree "BOOST_BYP_TX_GTR_TRESH_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_TX_GTR_TRESH_CTL (at 0x1a25e)"
      tindex ezaxi:0xfc4cf980 %l 0x83a25e0 0x3a25e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TX_GTR_TRESH_ENABLE                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   THRESHOLD                                = " "0 (MV200),1 (MV300),2 (MV400),3 (MV500)"
    tree.end
    tree "BOOST_BYP_UL_LL_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_UL_LL_CTRL (at 0x1a268)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2680 0x3a2680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "BOOST_BYP_BOOST_VSET_UL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_BOOST_VSET_UL (at 0x1a269)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2690 0x3a2690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BOOST_VSET_UL                            = "
    tree.end
    tree "BOOST_BYP_BOOST_VSET_LL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_BOOST_VSET_LL (at 0x1a26b)"
      tindex ezaxi:0xfc4cf980 %l 0x83a26b0 0x3a26b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BOOST_VSET_LL                            = "
    tree.end
    tree "BOOST_BYP_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_SEC_ACCESS (at 0x1a2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2d00 0x3a2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BOOST_BYP_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PERPH_RESET_CTL1 (at 0x1a2d8)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2d80 0x3a2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BOOST_BYP_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PERPH_RESET_CTL2 (at 0x1a2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2d90 0x3a2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BOOST_BYP_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PERPH_RESET_CTL3 (at 0x1a2da)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2da0 0x3a2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BOOST_BYP_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_PERPH_RESET_CTL4 (at 0x1a2db)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2db0 0x3a2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BOOST_BYP_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_TEST1 (at 0x1a2e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e00 0x3a2e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BOOST_BYP_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_INT_TEST_VAL (at 0x1a2e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e10 0x3a2e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "BOOST_BYP_DTEST1_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_DTEST1_ACCESS (at 0x1a2e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e20 0x3a2e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (CURRENT_COMPARATOR_OUTPUT),2 (PBM_COMPARATOR_OUTPUT),3 (CURRENT_LIMIT_COMPARATOR_OUTPUT),4 (PULSE_SKIP_COMPARATOR_OUTPUT),5 (DUTY_CYCLE_MONITOR_COMPARATOR_OUTPUT),6 (VIN_HIGHER_THAN_VSET_COMPARATOR_OUTPUT),7 (VREG_OK_COMPARATOR_OUTPUT)"
    tree.end
    tree "BOOST_BYP_DTEST2_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_DTEST2_ACCESS (at 0x1a2e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e30 0x3a2e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (SWITCHING_FREQUENCY_CLOCK),2 (MAX_D_SIGNAL),3 (CLOCK_19P2M),4 (NFET_GATE_LOGIC),5 (PFET_GATE_LOGIC),6 (BYPASS_PFET_GATE_LOGIC),7 (INZERO_COMP_OUT)"
    tree.end
    tree "BOOST_BYP_DTEST3_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_DTEST3_ACCESS (at 0x1a2e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e40 0x3a2e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (BIAS_LOW),2 (PWM_ENABLE),3 (PBM_ENABLE),4 (NFET_GATE_DRIVE),5 (PFET_GATE_DRIVE),6 (BYPASS_PFET_GATE_DRIVE),7 (DVSS)"
    tree.end
    tree "BOOST_BYP_DTEST4_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_DTEST4_ACCESS (at 0x1a2e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e50 0x3a2e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (DEBOUCED_VOK_SIGNAL),2 (DEBOUCED_BYPASS_MODE_SIGNAL),3 (CURRENT_SENSE_SWITCH_CONTROL_SIGNAL),4 (DVSS4),5 (DVSS5),6 (DVSS6),7 (DVSS7)"
    tree.end
    tree "BOOST_BYP_ATEST1_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_ATEST1_ACCESS (at 0x1a2e6)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e60 0x3a2e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (ERRAMP_OUT),2 (VREF1P25_BUF),3 (BGAP_BIAS_P_MIR),4 (BGAP_BIAS_P_CAS),5 (BGAP_BIAS_N_CAS),6 (VOUT_DIV_PBM),7 (BYP_THRES)"
    tree.end
    tree "BOOST_BYP_ATEST2_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_ATEST2_ACCESS (at 0x1a2e7)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e70 0x3a2e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (VOUT_DIV_ERRAMP),2 (VOUT_DIV_VOKCOMP),3 (VIN_DIV_BPSCOMP),4 (VIN_DIV_DUTYCOMP),5 (VIN_DIV_BUFFER),6 (PGND_SENSING_POINT),7 (V2P0_PBMCOMP)"
    tree.end
    tree "BOOST_BYP_ATEST3_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_ATEST3_ACCESS (at 0x1a2e8)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e80 0x3a2e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (V2P0_ERRAMP),2 (VREF_PS),3 (NFET_DSNS)"
    tree.end
    tree "BOOST_BYP_ATEST4_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_ATEST4_ACCESS (at 0x1a2e9)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2e90 0x3a2e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (V2P0_ERRAMP),2 (VLIMIT),3 (IMAX_VREF)"
    tree.end
    tree "BOOST_BYP_TEST_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_TEST_CTL (at 0x1a2ea)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2ea0 0x3a2ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_NFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_BPPFET_OVERRIDE                       = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BPPFET_CTL                               = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SCALE_ILIM                               = " "0 (X1),1 (X0P5),2 (X0P33),3 (X0P25)"
    tree.end
    tree "BOOST_BYP_DEBOUNCER_OVERRIDE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_DEBOUNCER_OVERRIDE (at 0x1a2eb)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2eb0 0x3a2eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEB_ILIMIT                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEB_VREG_OK                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEB_BYPASS_ON                            = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "BOOST_BYP_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_TRIM_NUM (at 0x1a2f0)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2f00 0x3a2f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "BOOST_BYP_TRIM_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_TRIM_CTL1 (at 0x1a2f1)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2f10 0x3a2f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIM_EN                                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ERR_AMP_OFFSET                           = "
    tree.end
    tree "BOOST_BYP_TRIM_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_BYP_TRIM_CTL2 (at 0x1a2f2)"
      tindex ezaxi:0xfc4cf980 %l 0x83a2f20 0x3a2f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PBM_COMP_OFFSET                          = "
    tree.end
  tree.end
tree.end
tree "BOOST_FREQ"
  tree "BOOST_FREQ"
    tree "BOOST_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_REVISION1 (at 0x1a100)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1000 0x3a1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BOOST_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_REVISION2 (at 0x1a101)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1010 0x3a1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BOOST_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_PERPH_TYPE (at 0x1a104)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1040 0x3a1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BOOST_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_PERPH_SUBTYPE (at 0x1a105)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1050 0x3a1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BOOST_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_CLK_ENABLE (at 0x1a146)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1460 0x3a1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BOOST_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_CLK_DIV (at 0x1a150)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1500 0x3a1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "BOOST_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_CLK_PHASE (at 0x1a151)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1510 0x3a1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "BOOST_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_GANG_CTL1 (at 0x1a1c0)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1c00 0x3a1c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "BOOST_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_GANG_CTL2 (at 0x1a1c1)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1c10 0x3a1c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "BOOST_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_SEC_ACCESS (at 0x1a1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1d00 0x3a1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BOOST_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_PERPH_RESET_CTL2 (at 0x1a1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1d90 0x3a1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BOOST_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_PERPH_RESET_CTL3 (at 0x1a1da)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1da0 0x3a1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BOOST_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_PERPH_RESET_CTL4 (at 0x1a1db)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1db0 0x3a1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BOOST_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BOOST_FREQ_TEST1 (at 0x1a1e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83a1e20 0x3a1e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BSI"
  tree "BSI"
    tree "BSI_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_REVISION1 (at 0x1b00)"
      tindex ezaxi:0xfc4cf980 %l 0x821b000 0x21b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BSI_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_REVISION2 (at 0x1b01)"
      tindex ezaxi:0xfc4cf980 %l 0x821b010 0x21b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BSI_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_REVISION3 (at 0x1b02)"
      tindex ezaxi:0xfc4cf980 %l 0x821b020 0x21b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BSI_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_REVISION4 (at 0x1b03)"
      tindex ezaxi:0xfc4cf980 %l 0x821b030 0x21b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BSI_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_PERPH_TYPE (at 0x1b04)"
      tindex ezaxi:0xfc4cf980 %l 0x821b040 0x21b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BSI_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_PERPH_SUBTYPE (at 0x1b05)"
      tindex ezaxi:0xfc4cf980 %l 0x821b050 0x21b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BSI_BSI_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BSI_STS (at 0x1b08)"
      tindex ezaxi:0xfc4cf980 %l 0x821b080 0x21b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BSI_ACTIVE                               = " "0 (BSI_NOT_ACTIVE),1 (BSI_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BSI_TX_DISABLE                           = " "0 (TX_ENABLED),1 (TX_DISABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_ERR_FLAG                        = " "0 (OK),1 (ERROR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MIPI_BIF_TX_BUSY                         = " "0 (TX_IDLE),1 (TX_BUSY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_RX_BUSY                         = " "0 (RX_IDLE),1 (RX_BUSY)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_TX_GO_STATUS                    = " "0 (TX_GO_CLEAR),1 (TX_GO_SET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_RX_FLOW_STATUS                  = " "0 (NO_RX_DATA),1 (RX_DATA_AVAIL)"
    tree.end
    tree "BSI_MIPI_BIF_FSM_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_FSM_STS (at 0x1b09)"
      tindex ezaxi:0xfc4cf980 %l 0x821b090 0x21b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MIPI_BIF_TX_FSM                          = " "0 (TX_IDLE),1 (TX_DATA_STATE),2 (TX_STOP),3 (TX_BAT_IRQ),4 (TX_PUL),5 (TX_WAIT_CLR_ERR),6 (TX_DLY_STATE),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MIPI_BIF_RX_FSM                          = " "0 (RX_IDLE),1 (RX_BCF),2 (RX_NOT_BCF),3 (RX_DATA_STATE),4 (RX_STOP),5 (RX_BAT_IRQ),6 (RX_WAIT_CLR_ERR),7 (reserved)"
    tree.end
    tree "BSI_RX_FIFO_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_STS (at 0x1b0a)"
      tindex ezaxi:0xfc4cf980 %l 0x821b0a0 0x21b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WORD_NUM                                 = "
    tree.end
    tree "BSI_BSI_BAT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BSI_BAT_STS (at 0x1b0d)"
      tindex ezaxi:0xfc4cf980 %l 0x821b0d0 0x21b0d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_MISS_DEB                             = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISS_RAW                             = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_DEB_PRES_STATUS                      = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_NODEB_PRES_STATUS                    = " "0 (BATT_PRESENT),1 (BATT_GONE)"
    tree.end
    tree "BSI_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_RT_STS (at 0x1b10)"
      tindex ezaxi:0xfc4cf980 %l 0x821b100 0x21b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_RT_STS                      = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_RT_STS                    = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_RT_STS                  = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BSI_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_SET_TYPE (at 0x1b11)"
      tindex ezaxi:0xfc4cf980 %l 0x821b110 0x21b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_SET_TYPE                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_SET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BSI_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_POLARITY_HIGH (at 0x1b12)"
      tindex ezaxi:0xfc4cf980 %l 0x821b120 0x21b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_POLARITY_HIGH               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_POLARITY_HIGH             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_POLARITY_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_POLARITY_HIGH            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_POLARITY_HIGH            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_POLARITY_HIGH           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BSI_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_POLARITY_LOW (at 0x1b13)"
      tindex ezaxi:0xfc4cf980 %l 0x821b130 0x21b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_POLARITY_LOW                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_POLARITY_LOW              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_POLARITY_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_POLARITY_LOW             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_POLARITY_LOW             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_POLARITY_LOW            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BSI_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_LATCHED_CLR (at 0x1b14)"
      tindex ezaxi:0xfc4cf980 %l 0x821b140 0x21b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_LATCHED_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "BSI_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_EN_SET (at 0x1b15)"
      tindex ezaxi:0xfc4cf980 %l 0x821b150 0x21b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BSI_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_EN_CLR (at 0x1b16)"
      tindex ezaxi:0xfc4cf980 %l 0x821b160 0x21b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BSI_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_LATCHED_STS (at 0x1b18)"
      tindex ezaxi:0xfc4cf980 %l 0x821b180 0x21b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BSI_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_PENDING_STS (at 0x1b19)"
      tindex ezaxi:0xfc4cf980 %l 0x821b190 0x21b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BSI_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_MID_SEL (at 0x1b1a)"
      tindex ezaxi:0xfc4cf980 %l 0x821b1a0 0x21b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BSI_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_PRIORITY (at 0x1b1b)"
      tindex ezaxi:0xfc4cf980 %l 0x821b1b0 0x21b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BSI_BSI_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BSI_EN (at 0x1b46)"
      tindex ezaxi:0xfc4cf980 %l 0x821b460 0x21b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BSI_EN                                   = " "0 (BSI_DISABLED),1 (BSI_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_ERR_CLEAR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_ERR_CLEAR (at 0x1b4f)"
      tindex ezaxi:0xfc4cf980 %l 0x821b4f0 0x21b4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_CLEAR_ERR                       = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_FSM_RESET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_FSM_RESET (at 0x1b50)"
      tindex ezaxi:0xfc4cf980 %l 0x821b500 0x21b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_FSM_RESET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MIPI_BIF_RX_FIFO_RESET                   = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_FORCE_BCL_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_FORCE_BCL_LOW (at 0x1b51)"
      tindex ezaxi:0xfc4cf980 %l 0x821b510 0x21b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_FORCE_BCL_LOW                   = " "0 (BCL_RELEASED),1 (BCL_FORCED_LOW)"
    tree.end
    tree "BSI_MIPI_BIF_TAU_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_TAU_CFG (at 0x1b52)"
      tindex ezaxi:0xfc4cf980 %l 0x821b520 0x21b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_SAMPLE_RATE                     = " "0 (SAMPLE_RATE_4X),1 (SAMPLE_RATE_8X)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MIPI_BIF_SEL_TAU                         = " "0 (TAU_150US),1 (TAU_122US),2 (TAU_62US),3 (TAU_32US),4 (TAU_16US),5 (TAU_8US),6 (TAU_4US),7 (TAU_2US)"
    tree.end
    tree "BSI_MIPI_BIF_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_MODE (at 0x1b53)"
      tindex ezaxi:0xfc4cf980 %l 0x821b530 0x21b530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_TX_PULSE_MODE                   = " "0 (TX_DATA_MODE),1 (TX_PULSE_MODE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MIPI_BIF_RX_PULSE_MODE                   = " "0 (RX_DATA_MODE),1 (RX_PULSE_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_PULSE_TYPE                   = " "0 (TX_PULSE_1_TAU),1 (TX_PULSE_240US)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_DATA_FORMAT                  = " "0 (RX_11BIT_MODE),1 (RX_17BIT_MODE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_TX_DATA_FORMAT                  = " "0 (TX_11BIT_MODE),1 (TX_17BIT_MODE)"
    tree.end
    tree "BSI_MIPI_BIF_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_EN (at 0x1b54)"
      tindex ezaxi:0xfc4cf980 %l 0x821b540 0x21b540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_TX_EN                           = " "0 (TX_DISABLED),1 (TX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MIPI_BIF_RX_EN                           = " "0 (RX_DISABLED),1 (RX_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_CFG (at 0x1b55)"
      tindex ezaxi:0xfc4cf980 %l 0x821b550 0x21b550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_PU_EN                           = " "0 (PULLUP_DISABLED),1 (PULLUP_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_RX_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_RX_CFG (at 0x1b56)"
      tindex ezaxi:0xfc4cf980 %l 0x821b560 0x21b560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_EN                                  = " "0 (FIFO_DISABLED),1 (FIFO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_IRQ_FREQ                              = " "0 (FREQ_1_WORD),1 (FREQ_2_WORDS),2 (FREQ_3_WORDS),3 (FREQ_4_WORDS),4 (FREQ_5_WORDS),5 (FREQ_6_WORDS),6 (FREQ_7_WORDS),7 (FREQ_8_WORDS)"
    tree.end
    tree "BSI_MIPI_BIF_TX_DLY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_TX_DLY (at 0x1b59)"
      tindex ezaxi:0xfc4cf980 %l 0x821b590 0x21b590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIPI_BIF_TX_DLY                          = " "0 (DLY_0_TAU),1 (DLY_5_TAU),2 (DLY_10_TAU),3 (DLY_15_TAU)"
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_DATA_TX_0 (at 0x1b5a)"
      tindex ezaxi:0xfc4cf980 %l 0x821b5a0 0x21b5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_TX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_DATA_TX_1 (at 0x1b5b)"
      tindex ezaxi:0xfc4cf980 %l 0x821b5b0 0x21b5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_TX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_DATA_TX_2 (at 0x1b5c)"
      tindex ezaxi:0xfc4cf980 %l 0x821b5c0 0x21b5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_DATA_TX                         = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_TX_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_TX_CTL (at 0x1b5d)"
      tindex ezaxi:0xfc4cf980 %l 0x821b5d0 0x21b5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_TX_GO                           = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_DATA_RX_0 (at 0x1b60)"
      tindex ezaxi:0xfc4cf980 %l 0x821b600 0x21b600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_RX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_DATA_RX_1 (at 0x1b61)"
      tindex ezaxi:0xfc4cf980 %l 0x821b610 0x21b610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_RX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_DATA_RX_2 (at 0x1b62)"
      tindex ezaxi:0xfc4cf980 %l 0x821b620 0x21b620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_DATA_LOOPBACK_TAG               = " "0 (NORMAL_DATA),1 (LOOPBACK_DATA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_DATA_RX                         = " "0, 1"
    tree.end
    tree "BSI_RX_FIFO_WORD1_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD1_0 (at 0x1b63)"
      tindex ezaxi:0xfc4cf980 %l 0x821b630 0x21b630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD1_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD1_1 (at 0x1b64)"
      tindex ezaxi:0xfc4cf980 %l 0x821b640 0x21b640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD2_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD2_0 (at 0x1b65)"
      tindex ezaxi:0xfc4cf980 %l 0x821b650 0x21b650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD2_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD2_1 (at 0x1b66)"
      tindex ezaxi:0xfc4cf980 %l 0x821b660 0x21b660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD3_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD3_0 (at 0x1b67)"
      tindex ezaxi:0xfc4cf980 %l 0x821b670 0x21b670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD3_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD3_1 (at 0x1b68)"
      tindex ezaxi:0xfc4cf980 %l 0x821b680 0x21b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD4_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD4_0 (at 0x1b69)"
      tindex ezaxi:0xfc4cf980 %l 0x821b690 0x21b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD4_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_RX_FIFO_WORD4_1 (at 0x1b6a)"
      tindex ezaxi:0xfc4cf980 %l 0x821b6a0 0x21b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_MIPI_BIF_BCL_RAW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_BCL_RAW (at 0x1b6d)"
      tindex ezaxi:0xfc4cf980 %l 0x821b6d0 0x21b6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_BCL_RAW                         = " "0 (BCL_STATE_LOW),1 (BCL_STATE_HIGH)"
    tree.end
    tree "BSI_MIPI_BIF_ERROR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_ERROR (at 0x1b70)"
      tindex ezaxi:0xfc4cf980 %l 0x821b700 0x21b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MIPI_BIF_ERROR_CODE                      = "
    tree.end
    tree "BSI_BAT_GONE_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BAT_GONE_CFG (at 0x1ba7)"
      tindex ezaxi:0xfc4cf980 %l 0x821ba70 0x21ba70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_GONE_SEL                             = " "0 (NON_DEBOUNCED),1 (DEBOUNCED)"
    tree.end
    tree "BSI_BAT_RMV_DEB_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BAT_RMV_DEB_TIMER (at 0x1ba8)"
      tindex ezaxi:0xfc4cf980 %l 0x821ba80 0x21ba80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RMV_TIMER                                = "
    tree.end
    tree "BSI_BAT_PRES_DEB_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BAT_PRES_DEB_TIMER (at 0x1ba9)"
      tindex ezaxi:0xfc4cf980 %l 0x821ba90 0x21ba90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PRES_TIMER                               = "
    tree.end
    tree "BSI_BAT_GONE_DLY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BAT_GONE_DLY (at 0x1baa)"
      tindex ezaxi:0xfc4cf980 %l 0x821baa0 0x21baa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DLY_CFG                                  = " "0 (BYPASSED),1 (DLY_10U3),2 (DLY_15U6),3 (DLY_19U6)"
    tree.end
    tree "BSI_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_SEC_ACCESS (at 0x1bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x821bd00 0x21bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BSI_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_PERPH_RESET_CTL2 (at 0x1bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x821bd90 0x21bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BSI_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_PERPH_RESET_CTL3 (at 0x1bda)"
      tindex ezaxi:0xfc4cf980 %l 0x821bda0 0x21bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BSI_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_PERPH_RESET_CTL4 (at 0x1bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x821bdb0 0x21bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BSI_BSI_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BSI_SPARE (at 0x1bdf)"
      tindex ezaxi:0xfc4cf980 %l 0x821bdf0 0x21bdf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "BSI_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_TEST1 (at 0x1be0)"
      tindex ezaxi:0xfc4cf980 %l 0x821be00 0x21be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BSI_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_INT_TEST_VAL (at 0x1be1)"
      tindex ezaxi:0xfc4cf980 %l 0x821be10 0x21be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_INT_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_INT_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_INT_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "BSI_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_TEST1 (at 0x1be2)"
      tindex ezaxi:0xfc4cf980 %l 0x821be20 0x21be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "BSI_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_TEST2 (at 0x1be3)"
      tindex ezaxi:0xfc4cf980 %l 0x821be30 0x21be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   BSI_DTEST_SEL                            = "
    tree.end
    tree "BSI_MIPI_BIF_TX_ATE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_MIPI_BIF_TX_ATE_CTL (at 0x1be4)"
      tindex ezaxi:0xfc4cf980 %l 0x821be40 0x21be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_GO_ATE                                = " "0, 1"
    tree.end
    tree "BSI_BSI_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BSI_BSI_TEST (at 0x1be5)"
      tindex ezaxi:0xfc4cf980 %l 0x821be50 0x21be50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DISABLE_TEST                          = " "0 (NORMAL),1 (IGNORED)"
    tree.end
  tree.end
tree.end
tree "BUA"
  tree "BUA"
    tree "BUA_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_REVISION1 (at 0x1c00)"
      tindex ezaxi:0xfc4cf980 %l 0x821c000 0x21c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_REVISION2 (at 0x1c01)"
      tindex ezaxi:0xfc4cf980 %l 0x821c010 0x21c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_REVISION3 (at 0x1c02)"
      tindex ezaxi:0xfc4cf980 %l 0x821c020 0x21c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BUA_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_REVISION4 (at 0x1c03)"
      tindex ezaxi:0xfc4cf980 %l 0x821c030 0x21c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BUA_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_PERPH_TYPE (at 0x1c04)"
      tindex ezaxi:0xfc4cf980 %l 0x821c040 0x21c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_PERPH_SUBTYPE (at 0x1c05)"
      tindex ezaxi:0xfc4cf980 %l 0x821c050 0x21c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_STATUS1 (at 0x1c08)"
      tindex ezaxi:0xfc4cf980 %l 0x821c080 0x21c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
    tree.end
    tree "BUA_BUA_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_BUA_CTL1 (at 0x1c40)"
      tindex ezaxi:0xfc4cf980 %l 0x821c400 0x21c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0 (SCLK_0_TO_1),1 (SCLK_1_TO_2),2 (SCLK_2_TO_3),3 (SCLK_5_TO_6),4 (SCLK_8_TO_9),5 (SCLK_11_TO_12),6 (SCLK_15_TO_16),7 (SCLK_31_TO_32)"
    tree.end
    tree "BUA_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EN_CTL1 (at 0x1c46)"
      tindex ezaxi:0xfc4cf980 %l 0x821c460 0x21c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
    tree.end
    tree "BUA_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_SEC_ACCESS (at 0x1cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x821cd00 0x21cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_PERPH_RESET_CTL1 (at 0x1cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x821cd80 0x21cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BUA_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_PERPH_RESET_CTL2 (at 0x1cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x821cd90 0x21cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_PERPH_RESET_CTL3 (at 0x1cda)"
      tindex ezaxi:0xfc4cf980 %l 0x821cda0 0x21cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_PERPH_RESET_CTL4 (at 0x1cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x821cdb0 0x21cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUA_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_TEST1 (at 0x1ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x821ce20 0x21ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_REVISION1 (at 0x400)"
      tindex ezaxi:0xfc4cf980 %l 0x8204000 0x204000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_REVISION2 (at 0x401)"
      tindex ezaxi:0xfc4cf980 %l 0x8204010 0x204010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_TYPE (at 0x404)"
      tindex ezaxi:0xfc4cf980 %l 0x8204040 0x204040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_SUBTYPE (at 0x405)"
      tindex ezaxi:0xfc4cf980 %l 0x8204050 0x204050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_STATUS1 (at 0x408)"
      tindex ezaxi:0xfc4cf980 %l 0x8204080 0x204080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_TIMEOUT (at 0x444)"
      tindex ezaxi:0xfc4cf980 %l 0x8204440 0x204440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_SEC_ACCESS (at 0x4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8204d00 0x204d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8204d90 0x204d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_RESET_CTL3 (at 0x4da)"
      tindex ezaxi:0xfc4cf980 %l 0x8204da0 0x204da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_RESET_CTL4 (at 0x4db)"
      tindex ezaxi:0xfc4cf980 %l 0x8204db0 0x204db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_TEST1 (at 0x4e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8204e20 0x204e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION1 (at 0x5900)"
      tindex ezaxi:0xfc4cf980 %l 0x8259000 0x259000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION2 (at 0x5901)"
      tindex ezaxi:0xfc4cf980 %l 0x8259010 0x259010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION3 (at 0x5902)"
      tindex ezaxi:0xfc4cf980 %l 0x8259020 0x259020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION4 (at 0x5903)"
      tindex ezaxi:0xfc4cf980 %l 0x8259030 0x259030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_TYPE (at 0x5904)"
      tindex ezaxi:0xfc4cf980 %l 0x8259040 0x259040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
      tindex ezaxi:0xfc4cf980 %l 0x8259050 0x259050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_STATUS1 (at 0x5908)"
      tindex ezaxi:0xfc4cf980 %l 0x8259080 0x259080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_RT_STS (at 0x5910)"
      tindex ezaxi:0xfc4cf980 %l 0x8259100 0x259100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_SET_TYPE (at 0x5911)"
      tindex ezaxi:0xfc4cf980 %l 0x8259110 0x259110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
      tindex ezaxi:0xfc4cf980 %l 0x8259120 0x259120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
      tindex ezaxi:0xfc4cf980 %l 0x8259130 0x259130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
      tindex ezaxi:0xfc4cf980 %l 0x8259140 0x259140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_EN_SET (at 0x5915)"
      tindex ezaxi:0xfc4cf980 %l 0x8259150 0x259150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_EN_CLR (at 0x5916)"
      tindex ezaxi:0xfc4cf980 %l 0x8259160 0x259160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
      tindex ezaxi:0xfc4cf980 %l 0x8259180 0x259180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_PENDING_STS (at 0x5919)"
      tindex ezaxi:0xfc4cf980 %l 0x8259190 0x259190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_MID_SEL (at 0x591a)"
      tindex ezaxi:0xfc4cf980 %l 0x82591a0 0x2591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_PRIORITY (at 0x591b)"
      tindex ezaxi:0xfc4cf980 %l 0x82591b0 0x2591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL1 (at 0x5940)"
      tindex ezaxi:0xfc4cf980 %l 0x8259400 0x259400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL2 (at 0x5941)"
      tindex ezaxi:0xfc4cf980 %l 0x8259410 0x259410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL3 (at 0x5942)"
      tindex ezaxi:0xfc4cf980 %l 0x8259420 0x259420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL4 (at 0x5943)"
      tindex ezaxi:0xfc4cf980 %l 0x8259430 0x259430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_HALT_CTL (at 0x5945)"
      tindex ezaxi:0xfc4cf980 %l 0x8259450 0x259450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_RC_CTL (at 0x5946)"
      tindex ezaxi:0xfc4cf980 %l 0x8259460 0x259460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PD_CTL (at 0x5948)"
      tindex ezaxi:0xfc4cf980 %l 0x8259480 0x259480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
      tindex ezaxi:0xfc4cf980 %l 0x82594a0 0x2594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0, 1"
    tree.end
    tree "CLK_DIST_SPARE1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SPARE1 (at 0x5951)"
      tindex ezaxi:0xfc4cf980 %l 0x8259510 0x259510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SPARE2 (at 0x5952)"
      tindex ezaxi:0xfc4cf980 %l 0x8259520 0x259520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SPARE3 (at 0x5953)"
      tindex ezaxi:0xfc4cf980 %l 0x8259530 0x259530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SEC_ACCESS (at 0x59d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8259d00 0x259d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8259d90 0x259d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
      tindex ezaxi:0xfc4cf980 %l 0x8259da0 0x259da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
      tindex ezaxi:0xfc4cf980 %l 0x8259db0 0x259db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_TEST1 (at 0x59e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8259e00 0x259e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8259e10 0x259e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_TEST1 (at 0x59e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8259e20 0x259e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_TEST2 (at 0x59e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8259e40 0x259e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_TRIM_NUM (at 0x59f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8259f00 0x259f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8259f10 0x259f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_RCLF_TRIM (at 0x59f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8259f20 0x259f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "FG_ADC_MDM"
  tree "FG_ADC_MDM"
    tree "FG_ADC_MDM_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_PERPH_TYPE (at 0x4304)"
      tindex ezaxi:0xfc4cf980 %l 0x8243040 0x243040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_ADC_MDM_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_PERPH_SUBTYPE (at 0x4305)"
      tindex ezaxi:0xfc4cf980 %l 0x8243050 0x243050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_ADC_MDM_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_RT_STS (at 0x4310)"
      tindex ezaxi:0xfc4cf980 %l 0x8243100 0x243100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_ADC_MDM_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_SET_TYPE (at 0x4311)"
      tindex ezaxi:0xfc4cf980 %l 0x8243110 0x243110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_ADC_MDM_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_POLARITY_HIGH (at 0x4312)"
      tindex ezaxi:0xfc4cf980 %l 0x8243120 0x243120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_POLARITY_LOW (at 0x4313)"
      tindex ezaxi:0xfc4cf980 %l 0x8243130 0x243130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_LATCHED_CLR (at 0x4314)"
      tindex ezaxi:0xfc4cf980 %l 0x8243140 0x243140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_EN_SET (at 0x4315)"
      tindex ezaxi:0xfc4cf980 %l 0x8243150 0x243150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_EN_CLR (at 0x4316)"
      tindex ezaxi:0xfc4cf980 %l 0x8243160 0x243160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_LATCHED_STS (at 0x4318)"
      tindex ezaxi:0xfc4cf980 %l 0x8243180 0x243180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_ADC_MDM_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_PENDING_STS (at 0x4319)"
      tindex ezaxi:0xfc4cf980 %l 0x8243190 0x243190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_ADC_MDM_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_MID_SEL (at 0x431a)"
      tindex ezaxi:0xfc4cf980 %l 0x82431a0 0x2431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_ADC_MDM_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_PRIORITY (at 0x431b)"
      tindex ezaxi:0xfc4cf980 %l 0x82431b0 0x2431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_ADC_MDM_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_EN_CTL (at 0x4346)"
      tindex ezaxi:0xfc4cf980 %l 0x8243460 0x243460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_ADC_EN                                = " "0 (BCL_MONITORING_DISABLE),1 (BCL_MONITORING_ENABLE)"
    tree.end
    tree "FG_ADC_MDM_ACCESS_BAT_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_ACCESS_BAT_REQ (at 0x4350)"
      tindex ezaxi:0xfc4cf980 %l 0x8243500 0x243500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CMD                                      = " "0 (ACC_NOT_REQUESTED),1 (O59ACC_REQUESTED)"
    tree.end
    tree "FG_ADC_MDM_ACCESS_BAT_GRNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_ACCESS_BAT_GRNT (at 0x4351)"
      tindex ezaxi:0xfc4cf980 %l 0x8243510 0x243510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STS                                      = " "0 (ACC_NOT_GRANTED),1 (ACC_GRANTED)"
    tree.end
    tree "FG_ADC_MDM_BCL_VALUES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_VALUES (at 0x4353)"
      tindex ezaxi:0xfc4cf980 %l 0x8243530 0x243530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDY                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_VBAT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_VBAT (at 0x4354)"
      tindex ezaxi:0xfc4cf980 %l 0x8243540 0x243540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_IBAT (at 0x4355)"
      tindex ezaxi:0xfc4cf980 %l 0x8243550 0x243550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_VBAT_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_VBAT_CP (at 0x4356)"
      tindex ezaxi:0xfc4cf980 %l 0x8243560 0x243560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_IBAT_CP (at 0x4357)"
      tindex ezaxi:0xfc4cf980 %l 0x8243570 0x243570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_VBAT_MIN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_VBAT_MIN (at 0x4358)"
      tindex ezaxi:0xfc4cf980 %l 0x8243580 0x243580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_IBAT_MAX (at 0x4359)"
      tindex ezaxi:0xfc4cf980 %l 0x8243590 0x243590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_VBAT_MIN_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_VBAT_MIN_CP (at 0x435a)"
      tindex ezaxi:0xfc4cf980 %l 0x82435a0 0x2435a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_MAX_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_IBAT_MAX_CP (at 0x435b)"
      tindex ezaxi:0xfc4cf980 %l 0x82435b0 0x2435b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BAT_RES_7_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BAT_RES_7_0 (at 0x435c)"
      tindex ezaxi:0xfc4cf980 %l 0x82435c0 0x2435c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BAT_RES_15_8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BAT_RES_15_8 (at 0x435d)"
      tindex ezaxi:0xfc4cf980 %l 0x82435d0 0x2435d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_MODE (at 0x435e)"
      tindex ezaxi:0xfc4cf980 %l 0x82435e0 0x2435e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   STS                                      = " "0 (BCL_IS_LPM),1 (BCL_IS_HPM),2 (BCL_IS_MPM),3 (BCL_IS_INVALID_MODE)"
    tree.end
    tree "FG_ADC_MDM_BCL_V_GAIN_BATT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_V_GAIN_BATT (at 0x4360)"
      tindex ezaxi:0xfc4cf980 %l 0x8243600 0x243600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_GAIN_RSENSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_I_GAIN_RSENSE (at 0x4361)"
      tindex ezaxi:0xfc4cf980 %l 0x8243610 0x243610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_OFFSET_RSENSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_I_OFFSET_RSENSE (at 0x4362)"
      tindex ezaxi:0xfc4cf980 %l 0x8243620 0x243620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_GAIN_BATFET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_I_GAIN_BATFET (at 0x4363)"
      tindex ezaxi:0xfc4cf980 %l 0x8243630 0x243630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_OFFSET_BATFET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_I_OFFSET_BATFET (at 0x4364)"
      tindex ezaxi:0xfc4cf980 %l 0x8243640 0x243640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_MDM_BCL_I_SENSE_SOURCE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_BCL_I_SENSE_SOURCE (at 0x4365)"
      tindex ezaxi:0xfc4cf980 %l 0x8243650 0x243650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STS                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_VBAT_MIN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_VBAT_MIN_CLR (at 0x4366)"
      tindex ezaxi:0xfc4cf980 %l 0x8243660 0x243660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_IBAT_MAX_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_IBAT_MAX_CLR (at 0x4367)"
      tindex ezaxi:0xfc4cf980 %l 0x8243670 0x243670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_VBAT_INT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_VBAT_INT (at 0x4368)"
      tindex ezaxi:0xfc4cf980 %l 0x8243680 0x243680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_MDM_IBAT_INT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_IBAT_INT (at 0x4369)"
      tindex ezaxi:0xfc4cf980 %l 0x8243690 0x243690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_MDM_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_SEC_ACCESS (at 0x43d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8243d00 0x243d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_ADC_MDM_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_PERPH_RESET_CTL2 (at 0x43d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8243d90 0x243d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_PERPH_RESET_CTL3 (at 0x43da)"
      tindex ezaxi:0xfc4cf980 %l 0x8243da0 0x243da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_ADC_MDM_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_PERPH_RESET_CTL4 (at 0x43db)"
      tindex ezaxi:0xfc4cf980 %l 0x8243db0 0x243db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_ADC_MDM_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_TEST1 (at 0x43e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8243e00 0x243e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_ADC_MDM_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_MDM_INT_TEST_VAL (at 0x43e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8243e10 0x243e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "FG_ADC_USR"
  tree "FG_ADC_USR"
    tree "FG_ADC_USR_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_PERPH_TYPE (at 0x4204)"
      tindex ezaxi:0xfc4cf980 %l 0x8242040 0x242040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_ADC_USR_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_PERPH_SUBTYPE (at 0x4205)"
      tindex ezaxi:0xfc4cf980 %l 0x8242050 0x242050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_ADC_USR_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_RT_STS (at 0x4210)"
      tindex ezaxi:0xfc4cf980 %l 0x8242100 0x242100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_ADC_USR_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_SET_TYPE (at 0x4211)"
      tindex ezaxi:0xfc4cf980 %l 0x8242110 0x242110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_ADC_USR_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_POLARITY_HIGH (at 0x4212)"
      tindex ezaxi:0xfc4cf980 %l 0x8242120 0x242120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_POLARITY_LOW (at 0x4213)"
      tindex ezaxi:0xfc4cf980 %l 0x8242130 0x242130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_HIGH                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_LATCHED_CLR (at 0x4214)"
      tindex ezaxi:0xfc4cf980 %l 0x8242140 0x242140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "FG_ADC_USR_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_EN_SET (at 0x4215)"
      tindex ezaxi:0xfc4cf980 %l 0x8242150 0x242150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_EN_CLR (at 0x4216)"
      tindex ezaxi:0xfc4cf980 %l 0x8242160 0x242160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_LATCHED_STS (at 0x4218)"
      tindex ezaxi:0xfc4cf980 %l 0x8242180 0x242180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_ADC_USR_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_PENDING_STS (at 0x4219)"
      tindex ezaxi:0xfc4cf980 %l 0x8242190 0x242190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_ADC_USR_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_MID_SEL (at 0x421a)"
      tindex ezaxi:0xfc4cf980 %l 0x82421a0 0x2421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_ADC_USR_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_PRIORITY (at 0x421b)"
      tindex ezaxi:0xfc4cf980 %l 0x82421b0 0x2421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_ADC_USR_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_EN_CTL (at 0x4246)"
      tindex ezaxi:0xfc4cf980 %l 0x8242460 0x242460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_ADC_EN                                = " "0 (BCL_MONITORING_DISABLE),1 (BCL_MONITORING_ENABLE)"
    tree.end
    tree "FG_ADC_USR_ACCESS_BAT_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_ACCESS_BAT_REQ (at 0x4250)"
      tindex ezaxi:0xfc4cf980 %l 0x8242500 0x242500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CMD                                      = " "0 (ACC_NOT_REQUESTED),1 (O59ACC_REQUESTED)"
    tree.end
    tree "FG_ADC_USR_ACCESS_BAT_GRNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_ACCESS_BAT_GRNT (at 0x4251)"
      tindex ezaxi:0xfc4cf980 %l 0x8242510 0x242510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STS                                      = " "0 (ACC_NOT_GRANTED),1 (ACC_GRANTED)"
    tree.end
    tree "FG_ADC_USR_BCL_VALUES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_VALUES (at 0x4253)"
      tindex ezaxi:0xfc4cf980 %l 0x8242530 0x242530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDY                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_VBAT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_VBAT (at 0x4254)"
      tindex ezaxi:0xfc4cf980 %l 0x8242540 0x242540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_IBAT (at 0x4255)"
      tindex ezaxi:0xfc4cf980 %l 0x8242550 0x242550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_VBAT_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_VBAT_CP (at 0x4256)"
      tindex ezaxi:0xfc4cf980 %l 0x8242560 0x242560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_IBAT_CP (at 0x4257)"
      tindex ezaxi:0xfc4cf980 %l 0x8242570 0x242570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_VBAT_MIN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_VBAT_MIN (at 0x4258)"
      tindex ezaxi:0xfc4cf980 %l 0x8242580 0x242580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_IBAT_MAX (at 0x4259)"
      tindex ezaxi:0xfc4cf980 %l 0x8242590 0x242590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_VBAT_MIN_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_VBAT_MIN_CP (at 0x425a)"
      tindex ezaxi:0xfc4cf980 %l 0x82425a0 0x2425a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_MAX_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_IBAT_MAX_CP (at 0x425b)"
      tindex ezaxi:0xfc4cf980 %l 0x82425b0 0x2425b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BAT_RES_7_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BAT_RES_7_0 (at 0x425c)"
      tindex ezaxi:0xfc4cf980 %l 0x82425c0 0x2425c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BAT_RES_15_8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BAT_RES_15_8 (at 0x425d)"
      tindex ezaxi:0xfc4cf980 %l 0x82425d0 0x2425d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_MODE (at 0x425e)"
      tindex ezaxi:0xfc4cf980 %l 0x82425e0 0x2425e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   STS                                      = " "0 (BCL_IS_LPM),1 (BCL_IS_HPM),2 (BCL_IS_MPM),3 (BCL_IS_INVALID_MODE)"
    tree.end
    tree "FG_ADC_USR_BCL_V_GAIN_BATT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_V_GAIN_BATT (at 0x4260)"
      tindex ezaxi:0xfc4cf980 %l 0x8242600 0x242600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_GAIN_RSENSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_I_GAIN_RSENSE (at 0x4261)"
      tindex ezaxi:0xfc4cf980 %l 0x8242610 0x242610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_OFFSET_RSENSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_I_OFFSET_RSENSE (at 0x4262)"
      tindex ezaxi:0xfc4cf980 %l 0x8242620 0x242620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_GAIN_BATFET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_I_GAIN_BATFET (at 0x4263)"
      tindex ezaxi:0xfc4cf980 %l 0x8242630 0x242630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_OFFSET_BATFET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_I_OFFSET_BATFET (at 0x4264)"
      tindex ezaxi:0xfc4cf980 %l 0x8242640 0x242640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_ADC_USR_BCL_I_SENSE_SOURCE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_BCL_I_SENSE_SOURCE (at 0x4265)"
      tindex ezaxi:0xfc4cf980 %l 0x8242650 0x242650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STS                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_VBAT_MIN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_VBAT_MIN_CLR (at 0x4266)"
      tindex ezaxi:0xfc4cf980 %l 0x8242660 0x242660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_IBAT_MAX_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_IBAT_MAX_CLR (at 0x4267)"
      tindex ezaxi:0xfc4cf980 %l 0x8242670 0x242670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_VBAT_INT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_VBAT_INT (at 0x4268)"
      tindex ezaxi:0xfc4cf980 %l 0x8242680 0x242680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_USR_IBAT_INT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_IBAT_INT (at 0x4269)"
      tindex ezaxi:0xfc4cf980 %l 0x8242690 0x242690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_ADC_USR_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_SEC_ACCESS (at 0x42d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8242d00 0x242d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_ADC_USR_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_PERPH_RESET_CTL2 (at 0x42d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8242d90 0x242d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_ADC_USR_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_PERPH_RESET_CTL3 (at 0x42da)"
      tindex ezaxi:0xfc4cf980 %l 0x8242da0 0x242da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_ADC_USR_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_PERPH_RESET_CTL4 (at 0x42db)"
      tindex ezaxi:0xfc4cf980 %l 0x8242db0 0x242db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_ADC_USR_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_TEST1 (at 0x42e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8242e00 0x242e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_ADC_USR_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_ADC_USR_INT_TEST_VAL (at 0x42e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8242e10 0x242e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_LT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBAT_GT_THR_INT_TEST_VAL                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "FG_BATT"
  tree "FG_BATT"
    tree "FG_BATT_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PERPH_TYPE (at 0x4104)"
      tindex ezaxi:0xfc4cf980 %l 0x8241040 0x241040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_BATT_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PERPH_SUBTYPE (at 0x4105)"
      tindex ezaxi:0xfc4cf980 %l 0x8241050 0x241050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_BATT_BATTERY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_BATTERY (at 0x4106)"
      tindex ezaxi:0xfc4cf980 %l 0x8241060 0x241060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ID                                       = " "0, 1, 2, 3"
    tree.end
    tree "FG_BATT_SYS_BATT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_SYS_BATT (at 0x4107)"
      tindex ezaxi:0xfc4cf980 %l 0x8241070 0x241070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   STS                                      = " "0 (ISMISSING),1 (CHARGING_CV),2 (CHARGING_CC),3 (SYSTEM_FULL),4 (DISCHARGING),5 (AUTOMATIC_RECHARGE),6 (SUPPLEMENTAL),7 (EMPTY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_REMOVED_LATCHED_STS                 = " "0 (BATT_PRESENT),1 (BATT_REMOVED_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_LOW_RT_STS                          = " "0 (BATT_VOLTAGE_NORMAL),1 (BATT_VOLTAGE_LOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_PROFILE_STS                         = " "0 (BATT_PROFILE_ORIGINAL),1 (BATT_PROFILE_CHANGED)"
    tree.end
    tree "FG_BATT_BATT_DET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_BATT_DET (at 0x4108)"
      tindex ezaxi:0xfc4cf980 %l 0x8241080 0x241080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ERR                                      = " "0 (BATT_ID_DETECTION_OK),1 (BATT_ID_DETECTION_ERR)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SMART                                    = " "0 (BATT_ID_DETECTION_NOT_SMART),1 (BATT_ID_DETECTION_SMART)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FLOAT                                    = " "0 (BATTERY_ID_NOT_FLOAT_TO_GND),1 (BATTERY_ID_FLOAT_TO_GND)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GND                                      = " "0 (BATT_ID_NOT_SHORTED_TO_GND),1 (BATT_ID_SHORTED_GND)"
    tree.end
    tree "FG_BATT_BATT_INFO_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_BATT_INFO_STS (at 0x4109)"
      tindex ezaxi:0xfc4cf980 %l 0x8241090 0x241090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ESR_UPDATE                               = " "0 (ESR_NOT_UPDATED_THIS_CYCLE),1 (ESR_UPDATED_THIS_CYCLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   JEITA_HARD_HOT_RT_STS                    = " "0 (JEITA_BELOW_HARD_HOT_THRESHOLD),1 (JEITA_ABOVE_HARD_HOT_THRESHOLD)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   JEITA_HARD_COLD_RT_STS                   = " "0 (JEITA_BELOW_HARD_COLD_THRESHOLD),1 (JEITA_ABOVE_HARD_COLD_THRESHOLD)"
    tree.end
    tree "FG_BATT_RECOVERY_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_RECOVERY_STS (at 0x410a)"
      tindex ezaxi:0xfc4cf980 %l 0x82410a0 0x2410a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RECOVERY_DATA_WAIT                       = " "0 (RECOVERY_DATA_NOT_WAIT),1 (RECOVERY_DATA_WAIT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RECOVERY_DATA_ACK                        = " "0 (RECOVERY_DATA_NOT_ACK),1 (RECOVERY_DATA_ACK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   RECOVERY_TIMEOUT_STS                     = " "0 (RECOVERY_TIMEOUT_FALSE),1 (RECOVERY_TIMEOUT_TRUE)"
    tree.end
    tree "FG_BATT_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_RT_STS (at 0x4110)"
      tindex ezaxi:0xfc4cf980 %l 0x8241100 0x241100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_RT_STS                        = " "0 (BATT_MATCH_RT_STS_FALSE),1 (BATT_MATCH_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_RT_STS                      = " "0 (BATT_MISSING_RT_STS_FALSE),1 (BATT_MISSING_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_RT_STS                      = " "0 (BATT_UNKNOWN_RT_STS_FALSE),1 (BATT_UNKNOWN_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_RT_STS                       = " "0 (BATT_ID_REQ_RT_STS_FALSE),1 (BATT_ID_REQ_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_RT_STS                   = " "0 (BATT_IDENTIFIED_RT_STS_FALSE),1 (BATT_IDENTIFIED_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_RT_STS                         = " "0 (VBATT_LOW_RT_STS_FALSE),1 (VBATT_LOW_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_RT_STS                    = " "0 (JEITA_SOFT_HOT_RT_STS_FALSE),1 (JEITA_SOFT_HOT_RT_STS_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_RT_STS                   = " "0 (JEITA_SOFT_COLD_RT_STS_FALSE),1 (JEITA_SOFT_COLD_RT_STS_TRUE)"
    tree.end
    tree "FG_BATT_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_SET_TYPE (at 0x4111)"
      tindex ezaxi:0xfc4cf980 %l 0x8241110 0x241110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_SET_TYPE                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_SET_TYPE             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_SET_TYPE                   = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_SET_TYPE             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_BATT_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_POLARITY_HIGH (at 0x4112)"
      tindex ezaxi:0xfc4cf980 %l 0x8241120 0x241120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_HIGH                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_HIGH                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_POLARITY_LOW (at 0x4113)"
      tindex ezaxi:0xfc4cf980 %l 0x8241130 0x241130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LOW                        = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LOW                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_LATCHED_CLR (at 0x4114)"
      tindex ezaxi:0xfc4cf980 %l 0x8241140 0x241140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LATCHED_CLR               = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LATCHED_CLR             = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LATCHED_CLR             = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LATCHED_CLR              = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_LATCHED_CLR          = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LATCHED_CLR                = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LATCHED_CLR           = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LATCHED_CLR          = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_BATT_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_EN_SET (at 0x4115)"
      tindex ezaxi:0xfc4cf980 %l 0x8241150 0x241150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LATCHED_SET               = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LATCHED_SET             = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LATCHED_SET             = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LATCHED_SET              = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_LATCHED_SET          = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LATCHED_SET                = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LATCHED_SET           = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LATCHED_SET          = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
    tree.end
    tree "FG_BATT_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_EN_CLR (at 0x4116)"
      tindex ezaxi:0xfc4cf980 %l 0x8241160 0x241160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_EN_CLR                    = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_EN_CLR                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_EN_CLR                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_EN_CLR                   = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_EN_CLR               = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_EN_CLR                     = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_EN_CLR                = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_EN_CLR               = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
    tree.end
    tree "FG_BATT_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_LATCHED_STS (at 0x4118)"
      tindex ezaxi:0xfc4cf980 %l 0x8241180 0x241180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_LATCHED_STS               = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_LATCHED_STS             = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_LATCHED_STS             = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_LATCHED_STS              = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_LATCHED_STS          = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_LATCHED_STS                = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_LATCHED_STS           = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_LATCHED_STS          = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
    tree.end
    tree "FG_BATT_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_PENDING_STS (at 0x4119)"
      tindex ezaxi:0xfc4cf980 %l 0x8241190 0x241190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_PENDING_STS               = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_PENDING_STS             = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_PENDING_STS             = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_PENDING_STS              = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_PENDING_STS          = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_PENDING_STS                = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_PENDING_STS           = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_PENDING_STS          = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
    tree.end
    tree "FG_BATT_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_MID_SEL (at 0x411a)"
      tindex ezaxi:0xfc4cf980 %l 0x82411a0 0x2411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_BATT_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_PRIORITY (at 0x411b)"
      tindex ezaxi:0xfc4cf980 %l 0x82411b0 0x2411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY0),1 (INT_PRIORITY1)"
    tree.end
    tree "FG_BATT_SW_BATT_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_SW_BATT_ID (at 0x4150)"
      tindex ezaxi:0xfc4cf980 %l 0x8241500 0x241500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE                                    = " "0 (FORCE_BATID_FALSE),1 (FORCE_BATID_TRUE)"
    tree.end
    tree "FG_BATT_PROFILE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PROFILE_ID (at 0x4151)"
      tindex ezaxi:0xfc4cf980 %l 0x8241510 0x241510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   NUM                                      = " "0 (SW_BATT_ID0),1 (SW_BATT_ID1),2 (SW_BATT_ID2),3 (SW_BATT_ID3)"
    tree.end
    tree "FG_BATT_BATT_REMOVED_LATCHED"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_BATT_REMOVED_LATCHED (at 0x4152)"
      tindex ezaxi:0xfc4cf980 %l 0x8241520 0x241520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0 (BATT_REMOVED_LATCH_CLEAR_FALSE),1 (BATT_REMOVED_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_BATT_BATT_RECOVERY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_BATT_RECOVERY (at 0x4153)"
      tindex ezaxi:0xfc4cf980 %l 0x8241530 0x241530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RECOVERY_DATA_RDY                        = " "0 (RECOVERY_DATA_RDY_FALSE),1 (RECOVERY_DATA_RDY_TRUE)"
    tree.end
    tree "FG_BATT_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_SEC_ACCESS (at 0x41d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8241d00 0x241d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_BATT_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PERPH_RESET_CTL2 (at 0x41d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8241d90 0x241d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_BATT_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PERPH_RESET_CTL3 (at 0x41da)"
      tindex ezaxi:0xfc4cf980 %l 0x8241da0 0x241da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_BATT_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PERPH_RESET_CTL4 (at 0x41db)"
      tindex ezaxi:0xfc4cf980 %l 0x8241db0 0x241db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "FG_BATT_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_TEST1 (at 0x41e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8241e00 0x241e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLE),1 (INT_TEST_MODE_ENABLE)"
    tree.end
    tree "FG_BATT_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_INT_TEST_VAL (at 0x41e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8241e10 0x241e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_MATCH_INT_TEST_VAL                  = " "0 (BATT_MATCH_INT_TEST_VAL_FALSE),1 (BATT_MATCH_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_MISSING_INT_TEST_VAL                = " "0 (BATT_MISSING_INT_TEST_VAL_FALSE),1 (BATT_MISSING_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATT_UNKNOWN_INT_TEST_VAL                = " "0 (BATT_UNKNOWN_INT_TEST_VAL_FALSE),1 (BATT_UNKNOWN_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_ID_REQ_INT_TEST_VAL                 = " "0 (BATT_ID_REQ_INT_TEST_VAL_FALSE),1 (BATT_ID_REQ_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IDENTIFIED_INT_TEST_VAL             = " "0 (BATT_IDENTIFIED_INT_TEST_VAL_FALSE),1 (BATT_IDENTIFIED_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_INT_TEST_VAL                   = " "0 (VBATT_LOW_INT_TEST_VAL_FALSE),1 (VBATT_LOW_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_SOFT_HOT_INT_TEST_VAL              = " "0 (JEITA_SOFT_HOT_INT_TEST_VAL_FALSE),1 (JEITA_SOFT_HOT_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_SOFT_COLD_INT_TEST_VAL             = " "0 (JEITA_SOFT_COLD_INT_TEST_VAL_FALSE),1 (JEITA_SOFT_COLD_INT_TEST_VAL_TRUE)"
    tree.end
    tree "FG_BATT_ESR_CHANGE_BOUND"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_ESR_CHANGE_BOUND (at 0x41e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8241e20 0x241e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LOW_TEMP_RANGE                           = " "0 (ESR_LOW_TEMP_RANGE_FALSE),1 (ESR_LOW_TEMP_RANGE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UPPER_HIT                                = " "0 (ESR_BELOW_HI_SATURATE_THRESH),1 (ESR_ABOVE_HI_SATURATE_THRESH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LOWER_HIT                                = " "0 (ESR_ABOVE_LO_SATURATE_THRESH),1 (ESR_BELOW_LO_SATURATE_THRESH)"
    tree.end
    tree "FG_BATT_PEEK_MUX1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PEEK_MUX1 (at 0x41eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8241eb0 0x241eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_PEEK_MUX2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PEEK_MUX2 (at 0x41ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8241ec0 0x241ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_PEEK_MUX3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PEEK_MUX3 (at 0x41ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8241ed0 0x241ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_PEEK_MUX4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_PEEK_MUX4 (at 0x41ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8241ee0 0x241ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_DTEST_RDBACK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_DTEST_RDBACK (at 0x41ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8241ef0 0x241ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   STS                                      = "
    tree.end
    tree "FG_BATT_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_TRIM_NUM (at 0x41f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8241f00 0x241f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "FG_BATT_MISC_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_MISC_CFG (at 0x41f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8241f10 0x241f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RECOVERY_DATA_EN                         = " "0 (RECOVERY_DATA_DISABLE),1 (RECOVERY_DATA_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RECOVERY_TIMEOUT_EN                      = " "0 (RECOVERY_TIMEOUT_DISABLE),1 (RECOVERY_TIMEOUT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERMISTOR_CFG                           = " "0 (THERMISTOR_ON_PCB),1 (THERMISTOR_ON_BATT)"
    tree.end
    tree "FG_BATT_BATT_ID_CURR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_BATT_ID_CURR0 (at 0x41f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8241f20 0x241f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM                                     = "
    tree.end
    tree "FG_BATT_BATT_ID_CURR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_BATT_ID_CURR1 (at 0x41f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8241f30 0x241f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM                                     = "
    tree.end
    tree "FG_BATT_ESR_CUR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_ESR_CUR (at 0x41f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8241f40 0x241f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG                                      = " "0 (ESR_MEAS_CUR_60MA),1 (ESR_MEAS_CUR_120MA),2 (ESR_MEAS_CUR_180MA),3 (ESR_MEAS_CUR_240MA)"
    tree.end
    tree "FG_BATT_ESR_MEAS_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_ESR_MEAS_EN (at 0x41f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8241f50 0x241f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG                                      = " "0 (ESR_MEAS_DISABLE),1 (ESR_MEAS_ENABLE)"
    tree.end
    tree "FG_BATT_RBIAS_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_BATT_RBIAS_DIV (at 0x41f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8241f60 0x241f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL                                      = " "0 (RBIAS_REF_UNBUF),1 (RBIAS_REF_BUF)"
    tree.end
  tree.end
tree.end
tree "FG_MEMIF"
  tree "FG_MEMIF"
    tree "FG_MEMIF_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_REVISION1 (at 0x4400)"
      tindex ezaxi:0xfc4cf980 %l 0x8244000 0x244000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "FG_MEMIF_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_REVISION2 (at 0x4401)"
      tindex ezaxi:0xfc4cf980 %l 0x8244010 0x244010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "FG_MEMIF_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_REVISION3 (at 0x4402)"
      tindex ezaxi:0xfc4cf980 %l 0x8244020 0x244020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "FG_MEMIF_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_REVISION4 (at 0x4403)"
      tindex ezaxi:0xfc4cf980 %l 0x8244030 0x244030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "FG_MEMIF_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_PERPH_TYPE (at 0x4404)"
      tindex ezaxi:0xfc4cf980 %l 0x8244040 0x244040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_MEMIF_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_PERPH_SUBTYPE (at 0x4405)"
      tindex ezaxi:0xfc4cf980 %l 0x8244050 0x244050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_MEMIF_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_RT_STS (at 0x4410)"
      tindex ezaxi:0xfc4cf980 %l 0x8244100 0x244100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_RT_STS                    = " "0 (DATA_RCVRY_SUG_FALSE),1 (DATA_RCVRY_SUG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_RT_STS                      = " "0 (FG_MEM_AVAIL_FALSE),1 (FG_MEM_AVAIL_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_SET_TYPE (at 0x4411)"
      tindex ezaxi:0xfc4cf980 %l 0x8244110 0x244110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_MEMIF_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_POLARITY_HIGH (at 0x4412)"
      tindex ezaxi:0xfc4cf980 %l 0x8244120 0x244120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_HIGH                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_MEMIF_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_POLARITY_LOW (at 0x4413)"
      tindex ezaxi:0xfc4cf980 %l 0x8244130 0x244130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_LOW                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_MEMIF_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_LATCHED_CLR (at 0x4414)"
      tindex ezaxi:0xfc4cf980 %l 0x8244140 0x244140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_LATCHED_CLR           = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_LATCHED_CLR             = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_EN_SET (at 0x4415)"
      tindex ezaxi:0xfc4cf980 %l 0x8244150 0x244150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_EN_SET                = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_EN_SET                  = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_EN_CLR (at 0x4416)"
      tindex ezaxi:0xfc4cf980 %l 0x8244160 0x244160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_EN_CLR                = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_EN_CLR                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_LATCHED_STS (at 0x4418)"
      tindex ezaxi:0xfc4cf980 %l 0x8244180 0x244180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_LATCHED_STS           = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_LATCHED_STS             = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_PENDING_STS (at 0x4419)"
      tindex ezaxi:0xfc4cf980 %l 0x8244190 0x244190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_PENDING_STS           = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_PENDING_STS             = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_MID_SEL (at 0x441a)"
      tindex ezaxi:0xfc4cf980 %l 0x82441a0 0x2441a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_MEMIF_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_PRIORITY (at 0x441b)"
      tindex ezaxi:0xfc4cf980 %l 0x82441b0 0x2441b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY0),1 (INT_PRIORITY1)"
    tree.end
    tree "FG_MEMIF_MEM_INTF_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_CFG (at 0x4440)"
      tindex ezaxi:0xfc4cf980 %l 0x8244400 0x244400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_REQ                       = " "0 (RIF_MEM_ACCESS_REQ_FALSE),1 (RIF_MEM_ACCESS_REQ_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LOW_LATENCY_ACS_EN                       = " "0 (LOW_LATENCY_ACS_EN_FALSE),1 (LOW_LATENCY_ACS_EN_TRUE)"
    tree.end
    tree "FG_MEMIF_MEM_INTF_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_CTL (at 0x4441)"
      tindex ezaxi:0xfc4cf980 %l 0x8244410 0x244410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (MEM_ACS_SINGLE),1 (MEM_ACS_BURST)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "FG_MEMIF_MEM_INTF_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_ADDR_LSB (at 0x4442)"
      tindex ezaxi:0xfc4cf980 %l 0x8244420 0x244420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_ADDR_MSB (at 0x4443)"
      tindex ezaxi:0xfc4cf980 %l 0x8244430 0x244430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_WR_DATA0 (at 0x4448)"
      tindex ezaxi:0xfc4cf980 %l 0x8244480 0x244480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_WR_DATA1 (at 0x4449)"
      tindex ezaxi:0xfc4cf980 %l 0x8244490 0x244490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_WR_DATA2 (at 0x444a)"
      tindex ezaxi:0xfc4cf980 %l 0x82444a0 0x2444a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_WR_DATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_WR_DATA3 (at 0x444b)"
      tindex ezaxi:0xfc4cf980 %l 0x82444b0 0x2444b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_RD_DATA0 (at 0x444c)"
      tindex ezaxi:0xfc4cf980 %l 0x82444c0 0x2444c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_RD_DATA1 (at 0x444d)"
      tindex ezaxi:0xfc4cf980 %l 0x82444d0 0x2444d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_RD_DATA2 (at 0x444e)"
      tindex ezaxi:0xfc4cf980 %l 0x82444e0 0x2444e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "FG_MEMIF_MEM_INTF_RD_DATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_MEM_INTF_RD_DATA3 (at 0x444f)"
      tindex ezaxi:0xfc4cf980 %l 0x82444f0 0x2444f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "FG_MEMIF_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_SEC_ACCESS (at 0x44d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8244d00 0x244d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_MEMIF_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_PERPH_RESET_CTL2 (at 0x44d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8244d90 0x244d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_MEMIF_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_PERPH_RESET_CTL3 (at 0x44da)"
      tindex ezaxi:0xfc4cf980 %l 0x8244da0 0x244da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_MEMIF_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_PERPH_RESET_CTL4 (at 0x44db)"
      tindex ezaxi:0xfc4cf980 %l 0x8244db0 0x244db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "FG_MEMIF_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_TEST1 (at 0x44e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8244e00 0x244e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLE),1 (INT_TEST_MODE_ENABLE)"
    tree.end
    tree "FG_MEMIF_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_INT_TEST_VAL (at 0x44e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8244e10 0x244e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_RCVRY_SUG_INT_TEST_VAL              = " "0 (DATA_RCVRY_SUG_INT_TEST_VAL_FALSE),1 (DATA_RCVRY_SUG_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_AVAIL_INT_TEST_VAL                = " "0 (FG_MEM_AVAIL_INT_TEST_VAL_FALSE),1 (FG_MEM_AVAIL_INT_TEST_VAL_TRUE)"
    tree.end
    tree "FG_MEMIF_OTP_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_OTP_CFG1 (at 0x44e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8244e20 0x244e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (VPP_SEL_DVDD),1 (VPP_SEL_VPP)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAM_DISABLE),1 (OTP_PROGRAM_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (OTP_TM0),1 (OTP_TM1),2 (OTP_TM2),3 (OTP_TM3)"
    tree.end
    tree "FG_MEMIF_OTP_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_MEMIF_OTP_CFG2 (at 0x44e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8244e30 0x244e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
  tree.end
tree.end
tree "FG_SOC"
  tree "FG_SOC"
    tree "FG_SOC_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_PERPH_TYPE (at 0x4004)"
      tindex ezaxi:0xfc4cf980 %l 0x8240040 0x240040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_SOC_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_PERPH_SUBTYPE (at 0x4005)"
      tindex ezaxi:0xfc4cf980 %l 0x8240050 0x240050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_SOC_FG_ALG_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_ALG_STS (at 0x4006)"
      tindex ezaxi:0xfc4cf980 %l 0x8240060 0x240060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDY                                      = " "0 (FG_NOT_READY),1 (FG_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BOOT_DONE                                = " "0 (FG_BOOT_NOT_DONE),1 (FG_BOOT_DONE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_ITER_DONE                          = " "0 (FG_FIRST_ITER_NOT_DONE),1 (FG_FIRST_ITER_DONE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESTART_DONE                             = " "0 (FG_RESTART_NOT_DONE),1 (FG_RESTART_DONE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RESTART_IN_PROGRESS                      = " "0 (FG_RESTART_NOT_IN_PROGRESS),1 (FG_RESTART_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_EXP                                 = " "0 (FG_WDOG_NOT_EXPIRED),1 (FG_WDOG_EXPIRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CYCLE_STRETCHED                          = " "0 (FG_CYCLE_NOT_STRETCHED),1 (FG_CYCLE_STRETCHED)"
    tree.end
    tree "FG_SOC_FG_ALG_AUX_STS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_ALG_AUX_STS0 (at 0x4007)"
      tindex ezaxi:0xfc4cf980 %l 0x8240070 0x240070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_BELOW_TERMINATION                      = " "0 (TERM_CURRENT_NOT_REACHED),1 (TERM_CURRENT_REACHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   V_REACHED_FLOAT_THRESHOLD                = " "0 (VBATT_FLOAT_NOT_REACHED),1 (VBATT_FLOAT_REACHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   I_CC_AVAILABLE                           = " "0 (I_CC_INACTIVE),1 (I_CC_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_PREDICTION_CHARGE                   = " "0 (BATT_MODEL_DISCHARGE),1 (BATT_MODEL_CHARGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PULSE_APPROVED                           = " "0 (PULSE_NOT_APPROVED),1 (PULSE_APPROVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ONCONNECT_OCV                            = " "0 (ONCONNECT_OCV_FALSE),1 (ONCONNECT_OCV_TRUE)"
    tree.end
    tree "FG_SOC_SLEEP_SHUTDOWN_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_SLEEP_SHUTDOWN_STS (at 0x4008)"
      tindex ezaxi:0xfc4cf980 %l 0x8240080 0x240080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_SLEEP_REQ                             = " "0 (SLEEP_NOT_REQUEST),1 (SLEEP_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SHUTDOWN_OR_SLEEP                        = " "0 (FG_AWAKE),1 (FG_IN_SHDN_OR_SLEEP)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_SHUTDOWN_REQ                          = " "0 (SLEEP_NOT_REQUEST),1 (SLEEP_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FG_SHUTDOWN_ALLOWED                      = " "0 (FG_DOES_NOT_ALOOW_SHDN),1 (FG_ALLOWS_SHDN)"
    tree.end
    tree "FG_SOC_FG_MONOTONIC_SOC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_MONOTONIC_SOC (at 0x4009)"
      tindex ezaxi:0xfc4cf980 %l 0x8240090 0x240090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_SOC_FG_MONOTONIC_SOC_CP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_MONOTONIC_SOC_CP (at 0x400a)"
      tindex ezaxi:0xfc4cf980 %l 0x82400a0 0x2400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_SOC_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_RT_STS (at 0x4010)"
      tindex ezaxi:0xfc4cf980 %l 0x8240100 0x240100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTRT_STS                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_RT_STS                     = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_RT_STS                    = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_SOC_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_SET_TYPE (at 0x4011)"
      tindex ezaxi:0xfc4cf980 %l 0x8240110 0x240110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_SET_TYPE           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_SET_TYPE               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_SET_TYPE                   = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_SET_TYPE                   = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_SOC_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_POLARITY_HIGH (at 0x4012)"
      tindex ezaxi:0xfc4cf980 %l 0x8240120 0x240120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_HIGH               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_HIGH                   = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_HIGH                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_HIGH                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_HIGH                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_SOC_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_POLARITY_LOW (at 0x4013)"
      tindex ezaxi:0xfc4cf980 %l 0x8240130 0x240130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_LOW                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_LOW                    = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LOW                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LOW                        = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LOW                        = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_SOC_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_LATCHED_CLR (at 0x4014)"
      tindex ezaxi:0xfc4cf980 %l 0x8240140 0x240140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LATCHED_CLR                 = " "0, 1"
    tree.end
    tree "FG_SOC_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_EN_SET (at 0x4015)"
      tindex ezaxi:0xfc4cf980 %l 0x8240150 0x240150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_LATCHED_SET        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_LATCHED_SET            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LATCHED_SET           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LATCHED_SET                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LATCHED_SET                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LATCHED_SET                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LATCHED_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LATCHED_SET                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_SOC_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_EN_CLR (at 0x4016)"
      tindex ezaxi:0xfc4cf980 %l 0x8240160 0x240160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_EN_CLR             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_EN_CLR                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_EN_CLR                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_EN_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_EN_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_SOC_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_LATCHED_STS (at 0x4018)"
      tindex ezaxi:0xfc4cf980 %l 0x8240180 0x240180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_LATCHED_STS        = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_LATCHED_STS            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_LATCHED_STS           = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_SOC_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_PENDING_STS (at 0x4019)"
      tindex ezaxi:0xfc4cf980 %l 0x8240190 0x240190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_PENDING_STS        = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_PENDING_STS            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_PENDING_STS           = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_SOC_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_MID_SEL (at 0x401a)"
      tindex ezaxi:0xfc4cf980 %l 0x82401a0 0x2401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_SOC_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_PRIORITY (at 0x401b)"
      tindex ezaxi:0xfc4cf980 %l 0x82401b0 0x2401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_SOC_BOOT_MOD"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_BOOT_MOD (at 0x4050)"
      tindex ezaxi:0xfc4cf980 %l 0x8240500 0x240500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PREVENT_OTP_SYS_RELOAD                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PREVENT_OTP_PROFILE_RELOAD               = " "0 (DO_NOT_PREVENT_OTP_PROFILE_RELOAD),1 (PREVENT_OTP_PROFILE_RELOAD)"
    tree.end
    tree "FG_SOC_RESTART"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_RESTART (at 0x4051)"
      tindex ezaxi:0xfc4cf980 %l 0x8240510 0x240510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REDO_BATID_DURING_FIRST_EST              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RERUN_FIRST_EST                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RELOAD_PROFILE                           = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RELOAD_SYS                               = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GO                                       = " "0 (DO_NOT_EXECUTE_SEQUENCE),1 (EXECUTE_SEQUENCE)"
    tree.end
    tree "FG_SOC_FG_WDOG_EXP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_WDOG_EXP (at 0x4052)"
      tindex ezaxi:0xfc4cf980 %l 0x8240520 0x240520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0, 1"
    tree.end
    tree "FG_SOC_STS_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_STS_CLR (at 0x4053)"
      tindex ezaxi:0xfc4cf980 %l 0x8240530 0x240530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CYCLE_STRETCH_CLR                        = " "0, 1"
    tree.end
    tree "FG_SOC_SPARE_FG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_SPARE_FG (at 0x4054)"
      tindex ezaxi:0xfc4cf980 %l 0x8240540 0x240540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ALG_ST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ALG_ST (at 0x40cf)"
      tindex ezaxi:0xfc4cf980 %l 0x8240cf0 0x240cf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CMP                                      = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ST_MAC                                   = "
    tree.end
    tree "FG_SOC_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_SEC_ACCESS (at 0x40d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8240d00 0x240d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_SOC_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_PERPH_RESET_CTL2 (at 0x40d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8240d90 0x240d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_SOC_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_PERPH_RESET_CTL3 (at 0x40da)"
      tindex ezaxi:0xfc4cf980 %l 0x8240da0 0x240da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_SOC_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_PERPH_RESET_CTL4 (at 0x40db)"
      tindex ezaxi:0xfc4cf980 %l 0x8240db0 0x240db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_SOC_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_TEST1 (at 0x40e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e00 0x240e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_SOC_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_INT_TEST_VAL (at 0x40e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e10 0x240e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FALLBK_NEW_BATTINT_TEST_VAL           = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SW_FALLBK_OCV_INT_TEST_VAL               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FIRST_EST_DONE_INT_TEST_VAL              = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DELTA_SOC_INT_TEST_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY_SOC_INT_TEST_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL_SOC_INT_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LOW_SOC_INT_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HIGH_SOC_INT_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "FG_SOC_ADC_TST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ADC_TST1 (at 0x40e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e20 0x240e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ADC_TST2 (at 0x40e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e30 0x240e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ADC_TST3 (at 0x40e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e40 0x240e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ADC_TST4 (at 0x40e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e50 0x240e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ADC_TST5 (at 0x40e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e60 0x240e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_ADC_TST6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ADC_TST6 (at 0x40e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e70 0x240e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "FG_SOC_VADC_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_VADC_DATA0 (at 0x40e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e80 0x240e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BYTE_7_0                                 = "
    tree.end
    tree "FG_SOC_BCL_TST0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_BCL_TST0 (at 0x40e9)"
      tindex ezaxi:0xfc4cf980 %l 0x8240e90 0x240e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FORCE_BCL_MODE                           = " "0, 1, 2, 3"
    tree.end
    tree "FG_SOC_DBG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_DBG_CFG (at 0x40ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8240ea0 0x240ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CFG                                      = "
    tree.end
    tree "FG_SOC_ALG_STS_CMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_ALG_STS_CMP (at 0x40eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8240eb0 0x240eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ALG_ST_TRACKER                           = "
    tree.end
    tree "FG_SOC_TEST_DT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_TEST_DT (at 0x40ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8240ec0 0x240ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_TRIM_COPY_DONE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ADC_REAL_CONV                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_CONV_I_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_CONV_I                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ADC_V_SOURCE_SEL                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_CONV_V_USE_SOURCE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CONV_V                               = " "0, 1"
    tree.end
    tree "FG_SOC_TEST_CLK_MANAGER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_TEST_CLK_MANAGER (at 0x40ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8240ed0 0x240ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MUX_EN                                   = " "0 (MUX_DISABLED),1 (MUX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   CTRL                                     = " "0 (NO_CLOCK_PROVIDED),1 (USE_STANDBY_CLOCK),2 (USE_MAIN_OSC),3 (INVALID_SELECTION)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   MUX_BITS                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_SOC_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_TRIM_NUM (at 0x40f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f00 0x240f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "FG_SOC_FG_PBS_TRIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_PBS_TRIG (at 0x40f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f10 0x240f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_SEL_EN                             = " "0 (ENABLE_DTEST_FOR_PBS_DISABLE),1 (ENABLE_DTEST_FOR_PBS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   INV                                      = " "0 (INVERT_DTEST_DISABLE),1 (INVERT_DTEST_ENABLE)"
    tree.end
    tree "FG_SOC_FG_PBS_TRIG_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_PBS_TRIG_MUX (at 0x40f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f20 0x240f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SEL                                      = "
    tree.end
    tree "FG_SOC_FG_RESET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_RESET (at 0x40f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f30 0x240f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CMD                                      = " "0 (FG_NOT_IN_RESET),1 (FG_IN_RESET)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPE_SEL                                 = " "0 (HYBRID_DVDD_RB_RAW),1 (HYBRID_DVDD_RB)"
    tree.end
    tree "FG_SOC_FG_CYA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_FG_CYA_CFG (at 0x40f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f40 0x240f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_WDOG_EN                               = " "0 (FG_WDOG_DISABLED),1 (FG_WDOG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LCSMB_TRIM                               = " "0 (DO_NOT_USE_ADC_LOW_CURRENT_MODE),1 (USE_ADC_LOW_CURRENT_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   I_ADC_SRC_MUX_SEL                        = " "0 (I_ADC_SRC_FROM_FG),1 (I_ADC_SRC_FROM_FG_CYA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   I_ADC_SRC_SEL                            = " "0 (I_ADC_FROM_BATFET),1 (I_ADC_FROM_ISENSE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   V_BCL_ADC_BIT_SEL                        = " "0 (I_BCL_ADC_7_BIT_LONG),1 (I_BCL_ADC_8_BIT_LONG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   I_BCL_ADC_BIT_SEL                        = " "0 (I_BCL_ADC_7_BIT_LONG),1 (I_BCL_ADC_8_BIT_LONG)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   V_ADC_CMP_POL_TRIM                       = " "0 (V_ADC_POS_IS_POS),1 (V_ADC_POS_IS_NEG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   I_ADC_CMP_POL_TRIM                       = " "0 (I_ADC_DISCH_POS),1 (I_ADC_DISCH_NEG)"
    tree.end
    tree "FG_SOC_LOW_PWR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_LOW_PWR_CFG (at 0x40f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f50 0x240f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLEEP_EN                                 = " "0 (SLEEP_IS_DISABLED),1 (SLEEP_IS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LO_FRQ_CLKSWITCH_EN                      = " "0 (LO_FRQ_CLKSWITCH_DISABLED),1 (LO_FRQ_CLKSWITCH_ENABLED)"
    tree.end
    tree "FG_SOC_BCL_V_GAIN_BATT_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_BCL_V_GAIN_BATT_TRIM (at 0x40f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f60 0x240f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_GAIN_RSENSE_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_BCL_I_GAIN_RSENSE_TRIM (at 0x40f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f70 0x240f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_OFFSET_RSENSE_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_BCL_I_OFFSET_RSENSE_TRIM (at 0x40f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f80 0x240f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_GAIN_BATFET_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_BCL_I_GAIN_BATFET_TRIM (at 0x40f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8240f90 0x240f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_SOC_BCL_I_OFFSET_BATFET_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FG_SOC_BCL_I_OFFSET_BATFET_TRIM (at 0x40fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8240fa0 0x240fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
  tree.end
tree.end
tree "FLASH1"
  tree "FLASH1"
    tree "FLASH1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_REVISION1 (at 0x1d300)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3000 0x3d3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "FLASH1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_REVISION2 (at 0x1d301)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3010 0x3d3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "FLASH1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_REVISION3 (at 0x1d302)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3020 0x3d3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "FLASH1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_REVISION4 (at 0x1d303)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3030 0x3d3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "FLASH1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_PERPH_TYPE (at 0x1d304)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3040 0x3d3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FLASH1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_PERPH_SUBTYPE (at 0x1d305)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3050 0x3d3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FLASH1_LED_FAULT_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED_FAULT_STATUS (at 0x1d308)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3080 0x3d3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OK_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   THERMAL_DERATE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED2_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_SHORT_FAULT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_SHORT_FAULT                         = " "0, 1"
    tree.end
    tree "FLASH1_LED1_IRAMP_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED1_IRAMP_STATUS (at 0x1d309)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3090 0x3d3090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_RAMP_CURRENT                        = "
    tree.end
    tree "FLASH1_LED2_IRAMP_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED2_IRAMP_STATUS (at 0x1d30a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d30a0 0x3d30a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_RAMP_CURRENT                        = "
    tree.end
    tree "FLASH1_LED1_MASK_RAMP_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED1_MASK_RAMP_STATUS (at 0x1d30b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d30b0 0x3d30b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_MASK_CLIP_CURRENT                   = "
    tree.end
    tree "FLASH1_LED2_MASK_RAMP_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED2_MASK_RAMP_STATUS (at 0x1d30c)"
      tindex ezaxi:0xfc4cf980 %l 0x83d30c0 0x3d30c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_MASK_CLIP_CURRENT                   = "
    tree.end
    tree "FLASH1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_RT_STS (at 0x1d310)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3100 0x3d3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_RT_STS                  = " "0, 1"
    tree.end
    tree "FLASH1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_SET_TYPE (at 0x1d311)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3110 0x3d3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_TYPE                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FLASH1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_POLARITY_HIGH (at 0x1d312)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3120 0x3d3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FLASH1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_POLARITY_LOW (at 0x1d313)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3130 0x3d3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FLASH1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_LATCHED_CLR (at 0x1d314)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3140 0x3d3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "FLASH1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_EN_SET (at 0x1d315)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3150 0x3d3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FLASH1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_EN_CLR (at 0x1d316)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3160 0x3d3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FLASH1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_LATCHED_STS (at 0x1d318)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3180 0x3d3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FLASH1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_PENDING_STS (at 0x1d319)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3190 0x3d3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FLASH1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_MID_SEL (at 0x1d31a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d31a0 0x3d31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FLASH1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_PRIORITY (at 0x1d31b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d31b0 0x3d31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FLASH1_FLASH_SAFETY_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_FLASH_SAFETY_TIMER (at 0x1d340)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3400 0x3d3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   FLASH_TIMER_DURATION                     = "
    tree.end
    tree "FLASH1_MAX_FLSH_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_MAX_FLSH_CURRENT (at 0x1d341)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3410 0x3d3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAX_LED_CURRENT                          = "
    tree.end
    tree "FLASH1_LED1_CURRENT_PRGM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED1_CURRENT_PRGM (at 0x1d342)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3420 0x3d3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_CURRENT_CONTROL                     = "
    tree.end
    tree "FLASH1_LED2_CURRENT_PRGM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED2_CURRENT_PRGM (at 0x1d343)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3430 0x3d3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_CURRENT_CONTROL                     = "
    tree.end
    tree "FLASH1_MASK_CLAMP_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_MASK_CLAMP_CURRENT (at 0x1d344)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3440 0x3d3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MASK_CURRENT                             = "
    tree.end
    tree "FLASH1_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_ENABLE_CONTROL (at 0x1d346)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3460 0x3d3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_ENABLE                            = " "0 (MOD_DIS),1 (MOD_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED1_DRVR_SEL                            = " "0 (TORCH_EN),1 (FLASH_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED2_DRVR_SEL                            = " "0 (TORCH_EN),1 (FLASH_EN)"
    tree.end
    tree "FLASH1_LED_STROBE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED_STROBE_CONTROL (at 0x1d347)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3470 0x3d3470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LED1_OUTPUT                           = " "0 (LED1_DIS),1 (LED1_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_LED2_OUTPUT                           = " "0 (LED2_DIS),1 (LED2_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HW_SW_STROBE_SEL                         = " "0 (STROBE_SW),1 (STROBE_HW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_STROBE_TRIGGER                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_STROBE_POLARITY                       = " "0 (ACTIVE_LOW),1 (ACTIVE_HIGH)"
    tree.end
    tree "FLASH1_LED_TMR_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED_TMR_CONTROL (at 0x1d348)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3480 0x3d3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIMER1_SEL                               = " "0 (LED1_TIMER_FLASH),1 (LED1_TIMER_WTCHDG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER2_SEL                               = " "0 (LED2_TIMER_FLASH),1 (LED2_TIMER_WTCHDG)"
    tree.end
    tree "FLASH1_WATCHDOG_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_WATCHDOG_TIMER (at 0x1d349)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3490 0x3d3490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   WATCHDOG_TIMER_DURATION                  = "
    tree.end
    tree "FLASH1_FLASH_HEADRM_PRGM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_FLASH_HEADRM_PRGM (at 0x1d34a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d34a0 0x3d34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FLSH_DRVR_HEADROOM                       = " "0 (HEADRM_250MV),1 (HEADRM_300MV),2 (HEADRM_400MV),3 (HEADRM_500MV)"
    tree.end
    tree "FLASH1_STARTUP_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_STARTUP_DELAY (at 0x1d34b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d34b0 0x3d34b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STARTUP_DELAY                            = " "0 (STRTUP_DLY_10US),1 (STRTUP_DLY_32US),2 (STRTUP_DLY_64US),3 (STRTUP_DLY_128US)"
    tree.end
    tree "FLASH1_MASK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_MASK_ENABLE (at 0x1d34c)"
      tindex ezaxi:0xfc4cf980 %l 0x83d34c0 0x3d34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MASK3                                 = " "0 (MASK3_DIS),1 (MASK3_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_MASK2                                 = " "0 (MASK2_DIS),1 (MASK2_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_MASK1                                 = " "0 (VPH_DROOP_DIS),1 (VPH_DROOP_EN)"
    tree.end
    tree "FLASH1_LED1_FINE_CURRENT_PRGM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED1_FINE_CURRENT_PRGM (at 0x1d34d)"
      tindex ezaxi:0xfc4cf980 %l 0x83d34d0 0x3d34d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_FINE_CURRENT_CONTROL                = "
    tree.end
    tree "FLASH1_LED2_FINE_CURRENT_PRGM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED2_FINE_CURRENT_PRGM (at 0x1d34e)"
      tindex ezaxi:0xfc4cf980 %l 0x83d34e0 0x3d34e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_FINE_CURRENT_CONTROL                = "
    tree.end
    tree "FLASH1_VREG_OK_FORCE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_VREG_OK_FORCE (at 0x1d34f)"
      tindex ezaxi:0xfc4cf980 %l 0x83d34f0 0x3d34f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FORCE_VREG_OK                         = " "0 (VREGOK),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HW_VREG_OK                        = " "0 (VREGOK_SW),1 (VREGOK_HW)"
    tree.end
    tree "FLASH1_MASK_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_MASK_CONFIG (at 0x1d350)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3500 0x3d3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK3_POLARITY                           = " "0 (MASK3_ACTIVE_LOW),1 (MASK3_ACTIVE_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MASK2_POLARITY                           = " "0 (MASK2_ACTIVE_LOW),1 (MASK2_ACTIVE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MASK1_POLARITY                           = " "0 (MASK1_ACTIVE_LOW),1 (MASK1_ACTIVE_HIGH)"
    tree.end
    tree "FLASH1_FAULT_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_FAULT_DETECT (at 0x1d351)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3510 0x3d3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SELF_CHECK                            = " "0 (SELF_CHECK_DIS),1 (SELF_CHECK_EN)"
    tree.end
    tree "FLASH1_THERMAL_DERATE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_THERMAL_DERATE (at 0x1d352)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3520 0x3d3520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_THERMAL_DERATE                        = " "0 (THERM_DERATE_DIS),1 (THERM_DERATE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   DERATE_RATE                              = " "0 (RATE_2_PERCENT),1 (RATE_2P5_PERCENT),2 (RATE_4_PERCENT),3 (RATE_5_PERCENT),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DERATE_THRESHOLD                         = " "0 (THRESHOLD_80C),1 (THRESHOLD_90C),2 (THRESHOLD_100C),3 (THRESHOLD_110C),4 (THRESHOLD_120C),5 (THRESHOLD_130C),6 (reserved),7 (reserved)"
    tree.end
    tree "FLASH1_PWM_DIMMING"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_PWM_DIMMING (at 0x1d353)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3530 0x3d3530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_DIMMING                           = " "0 (PWM_DIM_DIS),1 (PWM_DIM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FULL_SCALE_CURRENT                   = " "0 (PWMDIMMING_12P5MA),1 (PWMDIMMING_25MA),2 (PWMDIMMING_37P5MA),3 (PWMDIMMING_50MA),4 (PWMDIMMING_62P5MA),5 (PWMDIMMING_75MA),6 (PWMDIMMING_87P5MA),7 (PWMDIMMING_100MA)"
    tree.end
    tree "FLASH1_LED_CURRENT_RAMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED_CURRENT_RAMP (at 0x1d354)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3540 0x3d3540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_RAMP                                  = " "0 (RAMP_DIS),1 (RAMP_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_UP_STEP                             = " "0 (RAMP_UP_STEP_0P2US),1 (RAMP_UP_STEP_0P4US),2 (RAMP_UP_STEP_0P8US),3 (RAMP_UP_STEP_1P6US),4 (RAMP_UP_STEP_3P3US),5 (RAMP_UP_STEP_6P7US),6 (RAMP_UP_STEP_13P5US),7 (RAMP_UP_STEP_27US)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_DN_STEP                             = " "0 (RAMP_DN_STEP_0P2US),1 (RAMP_DN_STEP_0P4US),2 (RAMP_DN_STEP_0P8US),3 (RAMP_DN_STEP_1P6US),4 (RAMP_DN_STEP_3P3US),5 (RAMP_DN_STEP_6P7US),6 (RAMP_DN_STEP_13P5US),7 (RAMP_DN_STEP_27US)"
    tree.end
    tree "FLASH1_ALT_RAMP_DN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_ALT_RAMP_DN (at 0x1d355)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3550 0x3d3550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ALTERNATE_RAMP_DN                        = " "0 (ALT_RMP_DWN_0P2US),1 (ALT_RMP_DWN_0P4US),2 (ALT_RMP_DWN_0P8US),3 (ALT_RMP_DWN_1P6US)"
    tree.end
    tree "FLASH1_WATCHDOG_PET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_WATCHDOG_PET (at 0x1d356)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3560 0x3d3560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PET_WATCHDOG                             = " "0, 1"
    tree.end
    tree "FLASH1_STROBE_DEBOUNCE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_STROBE_DEBOUNCE (at 0x1d357)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3570 0x3d3570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_STROBE                     = " "0 (STROBE_DEBOUNCE_0US),1 (STROBE_DEBOUNCE_10US),2 (STROBE_DEBOUNCE_32US),3 (STROBE_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_MASK_DEBOUNCE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_MASK_DEBOUNCE (at 0x1d358)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3580 0x3d3580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEBOUNCE_TIME_MASK1                      = " "0 (MASK1_DEBOUNCE_0US),1 (MASK1_DEBOUNCE_10US),2 (MASK1_DEBOUNCE_32US),3 (MASK1_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_OTHER_MASKS                = " "0 (OTHER_MASK_DEBOUNCE_0US),1 (OTHER_MASK_DEBOUNCE_10US),2 (OTHER_MASK_DEBOUNCE_32US),3 (OTHER_MASK_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_FAULT_DEBOUNCE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_FAULT_DEBOUNCE (at 0x1d359)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3590 0x3d3590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEBOUNCE_TIME_LED1_OPEN                  = " "0 (LED1_OPEN_DEBOUNCE_0US),1 (LED1_OPEN_DEBOUNCE_10US),2 (LED1_OPEN_DEBOUNCE_32US),3 (LED1_OPEN_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEBOUNCE_TIME_LED2_OPEN                  = " "0 (LED2_OPEN_DEBOUNCE_0US),1 (LED2_OPEN_DEBOUNCE_10US),2 (LED2_OPEN_DEBOUNCE_32US),3 (LED2_OPEN_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEBOUNCE_TIME_LED1_SHORT                 = " "0 (LED1_SHORT_DEBOUNCE_0US),1 (LED1_SHORT_DEBOUNCE_10US),2 (LED1_SHORT_DEBOUNCE_32US),3 (LED1_SHORT_DEBOUNCE_64US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_LED2_SHORT                 = " "0 (LED2_SHORT_DEBOUNCE_0US),1 (LED2_SHORT_DEBOUNCE_10US),2 (LED2_SHORT_DEBOUNCE_32US),3 (LED2_SHORT_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_VPH_PWR_DROOP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_VPH_PWR_DROOP (at 0x1d35a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d35a0 0x3d35a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_VPH_PWR_DROOP                         = " "0 (VPH_DROOP_DIS),1 (VPHDROOP_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   VPH_PWR_DROOP_THRESHOLD                  = " "0 (VDIP_THRES_2P5V),1 (VDIP_THRES_2P6V),2 (VDIP_THRES_2P7V),3 (VDIP_THRES_2P8V),4 (VDIP_THRES_2P9V),5 (VDIP_THRES_3V),6 (VDIP_THRES_3P1V),7 (VDIP_THRES_3P2V)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_VPH_PWR_DROOP              = " "0 (VPH_DROOP_DEBOUNCE_0US),1 (VPH_DROOP_DEBOUNCE_10US),2 (VPH_DROOP_DEBOUNCE_32US),3 (VPH_DROOP_DEBOUNCE_64US)"
    tree.end
    tree "FLASH1_MASK_RAMP_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_MASK_RAMP_CTRL (at 0x1d35b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d35b0 0x3d35b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MASK_RAMP_CTRL                           = " "0 (MASK_RAMP_DIS),1 (MASK_RAMP_EN)"
    tree.end
    tree "FLASH1_LED1_HDRM_SNS_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED1_HDRM_SNS_CTRL (at 0x1d35c)"
      tindex ezaxi:0xfc4cf980 %l 0x83d35c0 0x3d35c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_HDRM_SNS_EN                         = " "0 (LED1_HR_SNS_DIS),1 (LED1_HR_SNS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_GAIN_CORRECTION                     = " "0 (LED1_GAIN_CORR_HW),1 (LED1_GAIN_CORR_SW)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED1_HDRM_SNS_THRESHOLD                  = " "0 (LED1_HR_SNS_THRES_600MV),1 (LED1_HR_SNS_THRES_700MV),2 (LED1_HR_SNS_THRES_800MV),3 (LED1_HR_SNS_THRES_900MV)"
    tree.end
    tree "FLASH1_LED2_HDRM_SNS_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_LED2_HDRM_SNS_CTRL (at 0x1d35d)"
      tindex ezaxi:0xfc4cf980 %l 0x83d35d0 0x3d35d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_HDRM_SNS_EN                         = " "0 (LED2_HR_SNS_DIS),1 (LED2_HR_SNS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED2_GAIN_CORRECTION                     = " "0 (LED2_GAIN_CORR_HW),1 (LED2_GAIN_CORR_SW)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED2_HDRM_SNS_THRESHOLD                  = " "0 (LED2_HR_SNS_THRES_600MV),1 (LED2_HR_SNS_THRES_700MV),2 (LED2_HR_SNS_THRES_800MV),3 (LED2_HR_SNS_THRES_900MV)"
    tree.end
    tree "FLASH1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_SEC_ACCESS (at 0x1d3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3d00 0x3d3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FLASH1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_PERPH_RESET_CTL2 (at 0x1d3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3d90 0x3d3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "FLASH1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_PERPH_RESET_CTL3 (at 0x1d3da)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3da0 0x3d3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "FLASH1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_PERPH_RESET_CTL4 (at 0x1d3db)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3db0 0x3d3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "FLASH1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_TEST1 (at 0x1d3e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e00 0x3d3e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "FLASH1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_INT_TEST_VAL (at 0x1d3e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e10 0x3d3e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_TEST_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_TEST_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_TEST_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_TEST_VAL                = " "0, 1"
    tree.end
    tree "FLASH1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TEST1 (at 0x1d3e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e20 0x3d3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "FLASH1_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TEST2 (at 0x1d3e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e30 0x3d3e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FLSH_ATEST_CTRL                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FLASH1_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TEST3 (at 0x1d3e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e40 0x3d3e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_WDOG_TIMER                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_SFTY_TIMER                            = " "0, 1"
    tree.end
    tree "FLASH1_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TEST4 (at 0x1d3e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e50 0x3d3e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLKRATE_TEST                             = " "0, 1"
    tree.end
    tree "FLASH1_TEST5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TEST5 (at 0x1d3e6)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e60 0x3d3e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED1_SEGMENT_CTRL                        = "
    tree.end
    tree "FLASH1_TEST6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TEST6 (at 0x1d3e7)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3e70 0x3d3e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED2_SEGMENT_CTRL                        = "
    tree.end
    tree "FLASH1_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TRIM_NUM (at 0x1d3f0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3f00 0x3d3f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "FLASH1_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TRIM1 (at 0x1d3f1)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3f10 0x3d3f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED1_CURR_TRIM_VIN                       = "
    tree.end
    tree "FLASH1_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TRIM2 (at 0x1d3f2)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3f20 0x3d3f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED1_CURR_TRIM_VREG                      = "
    tree.end
    tree "FLASH1_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TRIM3 (at 0x1d3f3)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3f30 0x3d3f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED2_CURR_TRIM_VIN                       = "
    tree.end
    tree "FLASH1_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "FLASH1_TRIM4 (at 0x1d3f4)"
      tindex ezaxi:0xfc4cf980 %l 0x83d3f40 0x3d3f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED2_CURR_TRIM_VREG                      = "
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION1 (at 0xc000)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0000 0x2c0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION2 (at 0xc001)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0010 0x2c0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION3 (at 0xc002)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0020 0x2c0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION4 (at 0xc003)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0030 0x2c0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_TYPE (at 0xc004)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0040 0x2c0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_SUBTYPE (at 0xc005)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0050 0x2c0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_STATUS1 (at 0xc008)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0080 0x2c0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_RT_STS (at 0xc010)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0100 0x2c0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_SET_TYPE (at 0xc011)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0110 0x2c0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0120 0x2c0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_POLARITY_LOW (at 0xc013)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0130 0x2c0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_LATCHED_CLR (at 0xc014)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0140 0x2c0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_EN_SET (at 0xc015)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0150 0x2c0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_EN_CLR (at 0xc016)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0160 0x2c0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_LATCHED_STS (at 0xc018)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0180 0x2c0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_PENDING_STS (at 0xc019)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0190 0x2c0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_MID_SEL (at 0xc01a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c01a0 0x2c01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_PRIORITY (at 0xc01b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c01b0 0x2c01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_MODE_CTL (at 0xc040)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0400 0x2c0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_VIN_CTL (at 0xc041)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0410 0x2c0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_PULL_CTL (at 0xc042)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0420 0x2c0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO1_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_IN_CTL (at 0xc043)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0430 0x2c0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO1_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_OUT_CTL (at 0xc045)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0450 0x2c0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_EN_CTL (at 0xc046)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0460 0x2c0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_SEC_ACCESS (at 0xc0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0d00 0x2c0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0d80 0x2c0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0d90 0x2c0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0da0 0x2c0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c0db0 0x2c0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO10"
  tree "GPIO10"
    tree "GPIO10_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION1 (at 0xc900)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9000 0x2c9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION2 (at 0xc901)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9010 0x2c9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO10_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION3 (at 0xc902)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9020 0x2c9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION4 (at 0xc903)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9030 0x2c9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO10_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_TYPE (at 0xc904)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9040 0x2c9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO10_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_SUBTYPE (at 0xc905)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9050 0x2c9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO10_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_STATUS1 (at 0xc908)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9080 0x2c9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO10_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_RT_STS (at 0xc910)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9100 0x2c9100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO10_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_SET_TYPE (at 0xc911)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9110 0x2c9110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO10_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_POLARITY_HIGH (at 0xc912)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9120 0x2c9120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_POLARITY_LOW (at 0xc913)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9130 0x2c9130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_LATCHED_CLR (at 0xc914)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9140 0x2c9140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO10_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_EN_SET (at 0xc915)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9150 0x2c9150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_EN_CLR (at 0xc916)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9160 0x2c9160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_LATCHED_STS (at 0xc918)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9180 0x2c9180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO10_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_PENDING_STS (at 0xc919)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9190 0x2c9190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO10_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_MID_SEL (at 0xc91a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c91a0 0x2c91a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO10_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_PRIORITY (at 0xc91b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c91b0 0x2c91b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO10_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_MODE_CTL (at 0xc940)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9400 0x2c9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO10_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_VIN_CTL (at 0xc941)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9410 0x2c9410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO10_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_PULL_CTL (at 0xc942)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9420 0x2c9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO10_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_IN_CTL (at 0xc943)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9430 0x2c9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO10_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_OUT_CTL (at 0xc945)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9450 0x2c9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO10_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_EN_CTL (at 0xc946)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9460 0x2c9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO10_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_SEC_ACCESS (at 0xc9d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9d00 0x2c9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO10_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL1 (at 0xc9d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9d80 0x2c9d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL2 (at 0xc9d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9d90 0x2c9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL3 (at 0xc9da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9da0 0x2c9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL4 (at 0xc9db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c9db0 0x2c9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION1 (at 0xc100)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1000 0x2c1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION2 (at 0xc101)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1010 0x2c1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION3 (at 0xc102)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1020 0x2c1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION4 (at 0xc103)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1030 0x2c1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_TYPE (at 0xc104)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1040 0x2c1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_SUBTYPE (at 0xc105)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1050 0x2c1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_STATUS1 (at 0xc108)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1080 0x2c1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_RT_STS (at 0xc110)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1100 0x2c1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_SET_TYPE (at 0xc111)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1110 0x2c1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1120 0x2c1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_POLARITY_LOW (at 0xc113)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1130 0x2c1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_LATCHED_CLR (at 0xc114)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1140 0x2c1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_EN_SET (at 0xc115)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1150 0x2c1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_EN_CLR (at 0xc116)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1160 0x2c1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_LATCHED_STS (at 0xc118)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1180 0x2c1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_PENDING_STS (at 0xc119)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1190 0x2c1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_MID_SEL (at 0xc11a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c11a0 0x2c11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_PRIORITY (at 0xc11b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c11b0 0x2c11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_MODE_CTL (at 0xc140)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1400 0x2c1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_VIN_CTL (at 0xc141)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1410 0x2c1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_PULL_CTL (at 0xc142)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1420 0x2c1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO2_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_IN_CTL (at 0xc143)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1430 0x2c1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO2_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_OUT_CTL (at 0xc145)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1450 0x2c1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_EN_CTL (at 0xc146)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1460 0x2c1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_SEC_ACCESS (at 0xc1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1d00 0x2c1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1d80 0x2c1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1d90 0x2c1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1da0 0x2c1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c1db0 0x2c1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO3"
  tree "GPIO3"
    tree "GPIO3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION1 (at 0xc200)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2000 0x2c2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION2 (at 0xc201)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2010 0x2c2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO3_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION3 (at 0xc202)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2020 0x2c2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION4 (at 0xc203)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2030 0x2c2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_TYPE (at 0xc204)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2040 0x2c2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_SUBTYPE (at 0xc205)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2050 0x2c2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_STATUS1 (at 0xc208)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2080 0x2c2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_RT_STS (at 0xc210)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2100 0x2c2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_SET_TYPE (at 0xc211)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2110 0x2c2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_POLARITY_HIGH (at 0xc212)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2120 0x2c2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_POLARITY_LOW (at 0xc213)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2130 0x2c2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_LATCHED_CLR (at 0xc214)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2140 0x2c2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_EN_SET (at 0xc215)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2150 0x2c2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_EN_CLR (at 0xc216)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2160 0x2c2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_LATCHED_STS (at 0xc218)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2180 0x2c2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_PENDING_STS (at 0xc219)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2190 0x2c2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_MID_SEL (at 0xc21a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c21a0 0x2c21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_PRIORITY (at 0xc21b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c21b0 0x2c21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO3_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_MODE_CTL (at 0xc240)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2400 0x2c2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO3_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_VIN_CTL (at 0xc241)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2410 0x2c2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO3_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_PULL_CTL (at 0xc242)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2420 0x2c2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO3_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_IN_CTL (at 0xc243)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2430 0x2c2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO3_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_OUT_CTL (at 0xc245)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2450 0x2c2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_EN_CTL (at 0xc246)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2460 0x2c2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_SEC_ACCESS (at 0xc2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2d00 0x2c2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL1 (at 0xc2d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2d80 0x2c2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL2 (at 0xc2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2d90 0x2c2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL3 (at 0xc2da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2da0 0x2c2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL4 (at 0xc2db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c2db0 0x2c2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO4"
  tree "GPIO4"
    tree "GPIO4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION1 (at 0xc300)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3000 0x2c3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION2 (at 0xc301)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3010 0x2c3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO4_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION3 (at 0xc302)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3020 0x2c3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION4 (at 0xc303)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3030 0x2c3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_TYPE (at 0xc304)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3040 0x2c3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_SUBTYPE (at 0xc305)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3050 0x2c3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO4_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_STATUS1 (at 0xc308)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3080 0x2c3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_RT_STS (at 0xc310)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3100 0x2c3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_SET_TYPE (at 0xc311)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3110 0x2c3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_POLARITY_HIGH (at 0xc312)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3120 0x2c3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_POLARITY_LOW (at 0xc313)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3130 0x2c3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_LATCHED_CLR (at 0xc314)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3140 0x2c3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_EN_SET (at 0xc315)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3150 0x2c3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_EN_CLR (at 0xc316)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3160 0x2c3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_LATCHED_STS (at 0xc318)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3180 0x2c3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_PENDING_STS (at 0xc319)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3190 0x2c3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_MID_SEL (at 0xc31a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c31a0 0x2c31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_PRIORITY (at 0xc31b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c31b0 0x2c31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO4_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_MODE_CTL (at 0xc340)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3400 0x2c3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO4_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_VIN_CTL (at 0xc341)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3410 0x2c3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO4_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_PULL_CTL (at 0xc342)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3420 0x2c3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO4_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_IN_CTL (at 0xc343)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3430 0x2c3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO4_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_OUT_CTL (at 0xc345)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3450 0x2c3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO4_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_EN_CTL (at 0xc346)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3460 0x2c3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_SEC_ACCESS (at 0xc3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3d00 0x2c3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO4_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL1 (at 0xc3d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3d80 0x2c3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL2 (at 0xc3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3d90 0x2c3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL3 (at 0xc3da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3da0 0x2c3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL4 (at 0xc3db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c3db0 0x2c3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO5"
  tree "GPIO5"
    tree "GPIO5_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION1 (at 0xc400)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4000 0x2c4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION2 (at 0xc401)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4010 0x2c4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO5_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION3 (at 0xc402)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4020 0x2c4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION4 (at 0xc403)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4030 0x2c4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO5_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_TYPE (at 0xc404)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4040 0x2c4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO5_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_SUBTYPE (at 0xc405)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4050 0x2c4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO5_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_STATUS1 (at 0xc408)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4080 0x2c4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO5_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_RT_STS (at 0xc410)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4100 0x2c4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO5_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_SET_TYPE (at 0xc411)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4110 0x2c4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO5_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_POLARITY_HIGH (at 0xc412)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4120 0x2c4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_POLARITY_LOW (at 0xc413)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4130 0x2c4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_LATCHED_CLR (at 0xc414)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4140 0x2c4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO5_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_EN_SET (at 0xc415)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4150 0x2c4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_EN_CLR (at 0xc416)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4160 0x2c4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_LATCHED_STS (at 0xc418)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4180 0x2c4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO5_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_PENDING_STS (at 0xc419)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4190 0x2c4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO5_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_MID_SEL (at 0xc41a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c41a0 0x2c41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO5_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_PRIORITY (at 0xc41b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c41b0 0x2c41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO5_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_MODE_CTL (at 0xc440)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4400 0x2c4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO5_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_VIN_CTL (at 0xc441)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4410 0x2c4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO5_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_PULL_CTL (at 0xc442)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4420 0x2c4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO5_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_IN_CTL (at 0xc443)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4430 0x2c4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO5_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_OUT_CTL (at 0xc445)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4450 0x2c4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO5_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_EN_CTL (at 0xc446)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4460 0x2c4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO5_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_SEC_ACCESS (at 0xc4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4d00 0x2c4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO5_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL1 (at 0xc4d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4d80 0x2c4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL2 (at 0xc4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4d90 0x2c4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL3 (at 0xc4da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4da0 0x2c4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL4 (at 0xc4db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c4db0 0x2c4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO6"
  tree "GPIO6"
    tree "GPIO6_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION1 (at 0xc500)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5000 0x2c5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION2 (at 0xc501)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5010 0x2c5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO6_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION3 (at 0xc502)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5020 0x2c5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION4 (at 0xc503)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5030 0x2c5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO6_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_TYPE (at 0xc504)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5040 0x2c5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO6_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_SUBTYPE (at 0xc505)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5050 0x2c5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO6_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_STATUS1 (at 0xc508)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5080 0x2c5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO6_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_RT_STS (at 0xc510)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5100 0x2c5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO6_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_SET_TYPE (at 0xc511)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5110 0x2c5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO6_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_POLARITY_HIGH (at 0xc512)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5120 0x2c5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_POLARITY_LOW (at 0xc513)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5130 0x2c5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_LATCHED_CLR (at 0xc514)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5140 0x2c5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO6_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_EN_SET (at 0xc515)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5150 0x2c5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_EN_CLR (at 0xc516)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5160 0x2c5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_LATCHED_STS (at 0xc518)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5180 0x2c5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO6_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_PENDING_STS (at 0xc519)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5190 0x2c5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO6_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_MID_SEL (at 0xc51a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c51a0 0x2c51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO6_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_PRIORITY (at 0xc51b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c51b0 0x2c51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO6_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_MODE_CTL (at 0xc540)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5400 0x2c5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO6_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_VIN_CTL (at 0xc541)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5410 0x2c5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO6_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_PULL_CTL (at 0xc542)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5420 0x2c5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO6_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_IN_CTL (at 0xc543)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5430 0x2c5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO6_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_OUT_CTL (at 0xc545)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5450 0x2c5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO6_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_EN_CTL (at 0xc546)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5460 0x2c5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO6_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_SEC_ACCESS (at 0xc5d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5d00 0x2c5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO6_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL1 (at 0xc5d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5d80 0x2c5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL2 (at 0xc5d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5d90 0x2c5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL3 (at 0xc5da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5da0 0x2c5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL4 (at 0xc5db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c5db0 0x2c5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO7"
  tree "GPIO7"
    tree "GPIO7_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION1 (at 0xc600)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6000 0x2c6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO7_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION2 (at 0xc601)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6010 0x2c6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO7_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION3 (at 0xc602)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6020 0x2c6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO7_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION4 (at 0xc603)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6030 0x2c6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO7_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_TYPE (at 0xc604)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6040 0x2c6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO7_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_SUBTYPE (at 0xc605)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6050 0x2c6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO7_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_STATUS1 (at 0xc608)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6080 0x2c6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO7_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_RT_STS (at 0xc610)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6100 0x2c6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO7_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_SET_TYPE (at 0xc611)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6110 0x2c6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO7_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_POLARITY_HIGH (at 0xc612)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6120 0x2c6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO7_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_POLARITY_LOW (at 0xc613)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6130 0x2c6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO7_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_LATCHED_CLR (at 0xc614)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6140 0x2c6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO7_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_EN_SET (at 0xc615)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6150 0x2c6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO7_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_EN_CLR (at 0xc616)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6160 0x2c6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO7_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_LATCHED_STS (at 0xc618)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6180 0x2c6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO7_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_PENDING_STS (at 0xc619)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6190 0x2c6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO7_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_MID_SEL (at 0xc61a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c61a0 0x2c61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO7_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_PRIORITY (at 0xc61b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c61b0 0x2c61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO7_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_MODE_CTL (at 0xc640)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6400 0x2c6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO7_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_VIN_CTL (at 0xc641)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6410 0x2c6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO7_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_PULL_CTL (at 0xc642)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6420 0x2c6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO7_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_IN_CTL (at 0xc643)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6430 0x2c6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO7_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_OUT_CTL (at 0xc645)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6450 0x2c6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO7_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_EN_CTL (at 0xc646)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6460 0x2c6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO7_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_SEC_ACCESS (at 0xc6d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6d00 0x2c6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO7_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL1 (at 0xc6d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6d80 0x2c6d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL2 (at 0xc6d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6d90 0x2c6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL3 (at 0xc6da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6da0 0x2c6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL4 (at 0xc6db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c6db0 0x2c6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO8"
  tree "GPIO8"
    tree "GPIO8_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION1 (at 0xc700)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7000 0x2c7000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO8_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION2 (at 0xc701)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7010 0x2c7010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO8_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION3 (at 0xc702)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7020 0x2c7020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO8_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION4 (at 0xc703)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7030 0x2c7030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO8_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_TYPE (at 0xc704)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7040 0x2c7040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO8_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_SUBTYPE (at 0xc705)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7050 0x2c7050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO8_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_STATUS1 (at 0xc708)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7080 0x2c7080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO8_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_RT_STS (at 0xc710)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7100 0x2c7100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO8_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_SET_TYPE (at 0xc711)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7110 0x2c7110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO8_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_POLARITY_HIGH (at 0xc712)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7120 0x2c7120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO8_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_POLARITY_LOW (at 0xc713)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7130 0x2c7130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO8_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_LATCHED_CLR (at 0xc714)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7140 0x2c7140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO8_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_EN_SET (at 0xc715)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7150 0x2c7150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO8_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_EN_CLR (at 0xc716)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7160 0x2c7160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO8_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_LATCHED_STS (at 0xc718)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7180 0x2c7180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO8_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_PENDING_STS (at 0xc719)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7190 0x2c7190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO8_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_MID_SEL (at 0xc71a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c71a0 0x2c71a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO8_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_PRIORITY (at 0xc71b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c71b0 0x2c71b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO8_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_MODE_CTL (at 0xc740)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7400 0x2c7400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO8_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_VIN_CTL (at 0xc741)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7410 0x2c7410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO8_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_PULL_CTL (at 0xc742)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7420 0x2c7420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO8_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_IN_CTL (at 0xc743)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7430 0x2c7430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO8_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_OUT_CTL (at 0xc745)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7450 0x2c7450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO8_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_EN_CTL (at 0xc746)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7460 0x2c7460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO8_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_SEC_ACCESS (at 0xc7d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7d00 0x2c7d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO8_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL1 (at 0xc7d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7d80 0x2c7d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL2 (at 0xc7d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7d90 0x2c7d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL3 (at 0xc7da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7da0 0x2c7da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL4 (at 0xc7db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c7db0 0x2c7db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO9"
  tree "GPIO9"
    tree "GPIO9_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION1 (at 0xc800)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8000 0x2c8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO9_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION2 (at 0xc801)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8010 0x2c8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO9_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION3 (at 0xc802)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8020 0x2c8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO9_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION4 (at 0xc803)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8030 0x2c8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO9_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_TYPE (at 0xc804)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8040 0x2c8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO9_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_SUBTYPE (at 0xc805)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8050 0x2c8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO9_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_STATUS1 (at 0xc808)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8080 0x2c8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO9_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_RT_STS (at 0xc810)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8100 0x2c8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO9_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_SET_TYPE (at 0xc811)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8110 0x2c8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO9_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_POLARITY_HIGH (at 0xc812)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8120 0x2c8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO9_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_POLARITY_LOW (at 0xc813)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8130 0x2c8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO9_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_LATCHED_CLR (at 0xc814)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8140 0x2c8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO9_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_EN_SET (at 0xc815)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8150 0x2c8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO9_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_EN_CLR (at 0xc816)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8160 0x2c8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO9_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_LATCHED_STS (at 0xc818)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8180 0x2c8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO9_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_PENDING_STS (at 0xc819)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8190 0x2c8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO9_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_MID_SEL (at 0xc81a)"
      tindex ezaxi:0xfc4cf980 %l 0x82c81a0 0x2c81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO9_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_PRIORITY (at 0xc81b)"
      tindex ezaxi:0xfc4cf980 %l 0x82c81b0 0x2c81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO9_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_MODE_CTL (at 0xc840)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8400 0x2c8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO9_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_VIN_CTL (at 0xc841)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8410 0x2c8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO9_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_PULL_CTL (at 0xc842)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8420 0x2c8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO9_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_IN_CTL (at 0xc843)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8430 0x2c8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO9_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_OUT_CTL (at 0xc845)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8450 0x2c8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO9_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_EN_CTL (at 0xc846)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8460 0x2c8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO9_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_SEC_ACCESS (at 0xc8d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8d00 0x2c8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO9_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL1 (at 0xc8d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8d80 0x2c8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO9_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL2 (at 0xc8d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8d90 0x2c8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO9_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL3 (at 0xc8da)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8da0 0x2c8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO9_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL4 (at 0xc8db)"
      tindex ezaxi:0xfc4cf980 %l 0x82c8db0 0x2c8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "HAPTICS"
  tree "HAPTICS"
    tree "HAPTICS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_REVISION1 (at 0x1c000)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0000 0x3c0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "HAPTICS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_REVISION2 (at 0x1c001)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0010 0x3c0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "HAPTICS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_REVISION3 (at 0x1c002)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0020 0x3c0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "HAPTICS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_REVISION4 (at 0x1c003)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0030 0x3c0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "HAPTICS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_PERPH_TYPE (at 0x1c004)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0040 0x3c0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "HAPTICS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_PERPH_SUBTYPE (at 0x1c005)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0050 0x3c0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "HAPTICS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_STATUS_1 (at 0x1c00a)"
      tindex ezaxi:0xfc4cf980 %l 0x83c00a0 0x3c00a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_STS                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AUTO_RES_ERROR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SC_FLAG                                  = " "0 (NO_SC),1 (SC_DET)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OC_FLAG                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BUSY                                     = " "0 (IDLE),1 (BUSY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PLAY_STS                                 = " "0, 1"
    tree.end
    tree "HAPTICS_LRA_AUTO_RES_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_LRA_AUTO_RES_LO (at 0x1c00b)"
      tindex ezaxi:0xfc4cf980 %l 0x83c00b0 0x3c00b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PERIOD                                   = "
    tree.end
    tree "HAPTICS_LRA_AUTO_RES_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_LRA_AUTO_RES_HI (at 0x1c00c)"
      tindex ezaxi:0xfc4cf980 %l 0x83c00c0 0x3c00c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PERIOD                                   = "
    tree.end
    tree "HAPTICS_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_RT_STS (at 0x1c010)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0100 0x3c0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_RT_STS                            = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "HAPTICS_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_SET_TYPE (at 0x1c011)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0110 0x3c0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_SET_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_SET_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "HAPTICS_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_POLARITY_HIGH (at 0x1c012)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0120 0x3c0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_POLARITY_HIGH                   = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_POLARITY_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "HAPTICS_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_POLARITY_LOW (at 0x1c013)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0130 0x3c0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_POLARITY_LOW                    = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_POLARITY_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "HAPTICS_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_LATCHED_CLR (at 0x1c014)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0140 0x3c0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_LATCHED_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_LATCHED_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "HAPTICS_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_EN_SET (at 0x1c015)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0150 0x3c0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_EN_SET                          = " "0 (reserved),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_EN_SET                            = " "0 (reserved),1 (INT_ENABLED)"
    tree.end
    tree "HAPTICS_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_EN_CLR (at 0x1c016)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0160 0x3c0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_EN_CLR                          = " "0 (reserved),1 (INT_DISABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_EN_CLR                            = " "0 (reserved),1 (INT_DISABLED)"
    tree.end
    tree "HAPTICS_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_LATCHED_STS (at 0x1c018)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0180 0x3c0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "HAPTICS_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_PENDING_STS (at 0x1c019)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0190 0x3c0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "HAPTICS_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_MID_SEL (at 0x1c01a)"
      tindex ezaxi:0xfc4cf980 %l 0x83c01a0 0x3c01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "HAPTICS_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_PRIORITY (at 0x1c01b)"
      tindex ezaxi:0xfc4cf980 %l 0x83c01b0 0x3c01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "HAPTICS_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_EN_CTL1 (at 0x1c046)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0460 0x3c0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HAPTICS_EN                               = " "0 (HAPTICS_DIS),1 (HAPTICS_EN)"
    tree.end
    tree "HAPTICS_EN_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_EN_CTL2 (at 0x1c048)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0480 0x3c0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_OTST2_EN                          = " "0 (DERATE_OTST2_DIS),1 (DERATE_OTST2_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_HIGH_IBAT_EN                      = " "0 (DERATE_HIGH_IBAT_DIS),1 (DERATE_HIGH_IBAT_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DERATE_HIGH_TEMP_EN                      = " "0 (DERATE_HIGH_TEMP_DIS),1 (DERATE_HIGH_TEMP_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DERATE_LOW_VBAT_EN                       = " "0 (DERATE_LOW_VBAT_DIS),1 (DERATE_LOW_VBAT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BRAKE_EN                                 = " "0 (BRAKING_DIS),1 (BRAKING_EN)"
    tree.end
    tree "HAPTICS_EN_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_EN_CTL3 (at 0x1c04a)"
      tindex ezaxi:0xfc4cf980 %l 0x83c04a0 0x3c04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HBRIDGE_EN                               = " "0 (HIGH_Z),1 (HBRIDGE_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PWM_SIGNAL_EN                            = " "0 (PWM_ZERO),1 (PWM_SIGNAL_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIM_EN                                  = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILIM_CC_EN                               = " "0 (CC_EN),1 (CC_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AUTO_RES_RBIAS_EN                        = " "0 (RBIAS_DIS),1 (RBIAS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DAC_EN                                   = " "0 (DAC_DIS),1 (DAC_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_HYST_EN                               = " "0 (ZX_HYST_DIS),1 (ZX_HYST_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_CTL_EN                               = " "0 (PWM_DIS),1 (PWM_CTL_EN)"
    tree.end
    tree "HAPTICS_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_CFG1 (at 0x1c04c)"
      tindex ezaxi:0xfc4cf980 %l 0x83c04c0 0x3c04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ACTUATOR_TYPE                            = " "0 (LRA),1 (ERM)"
    tree.end
    tree "HAPTICS_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_CFG2 (at 0x1c04d)"
      tindex ezaxi:0xfc4cf980 %l 0x83c04d0 0x3c04d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LRA_RES_TYPE                             = " "0 (SINUSOID),1 (SQUARE)"
    tree.end
    tree "HAPTICS_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_SEL (at 0x1c04e)"
      tindex ezaxi:0xfc4cf980 %l 0x83c04e0 0x3c04e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   WF_SOURCE                                = " "0 (VMAX),1 (BUFFER),2 (AUDIO),3 (EXT_PWM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER                                  = " "0 (HAPTICS_PLAY),1 (LINE_IN)"
    tree.end
    tree "HAPTICS_AUTO_RES_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_AUTO_RES_CFG (at 0x1c04f)"
      tindex ezaxi:0xfc4cf980 %l 0x83c04f0 0x3c04f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   LRA_AUTO_RES_MODE                        = " "0 (NO_AUTO_RES),1 (ZXD),2 (QWD),3 (MAX_QWD),4 (ZXD_EOP),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LRA_HIGH_Z                               = " "0 (NO_HIGHZ),1 (HIGHZ_OPT1),2 (HIGHZ_OPT2),3 (HIGHZ_OPT3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LRA_RES_CALIB                            = " "0 (FOUR_PERIODS),1 (EIGHT_PERIODS),2 (SIXTEEN_PERIODS),3 (THIRTYTWO_PERIODS)"
    tree.end
    tree "HAPTICS_SLEW_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_SLEW_CFG (at 0x1c050)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0500 0x3c0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEW_RATE                                = " "0 (SLEW_6NS),1 (SLEW_16NS)"
    tree.end
    tree "HAPTICS_VMAX_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_VMAX_CFG (at 0x1c051)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0510 0x3c0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VMAX                                     = "
    tree.end
    tree "HAPTICS_ILIM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_ILIM_CFG (at 0x1c052)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0520 0x3c0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_SEL                                 = " "0 (ILIM_400MA),1 (ILIM_800MA)"
    tree.end
    tree "HAPTICS_SC_DEB_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_SC_DEB_CFG (at 0x1c053)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0530 0x3c0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SC_DEB                                   = " "0 (NO_DEB),1 (DEB_8CLK),2 (DEB_16CLK),3 (DEB_32CLK),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "HAPTICS_RATE_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_RATE_CFG1 (at 0x1c054)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0540 0x3c0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RATE_7_0                                 = "
    tree.end
    tree "HAPTICS_RATE_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_RATE_CFG2 (at 0x1c055)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0550 0x3c0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RATE_11_8                                = "
    tree.end
    tree "HAPTICS_INTERNAL_PWM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INTERNAL_PWM (at 0x1c056)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0560 0x3c0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FREQ_SEL                                 = " "0 (PWM_253KHZ),1 (PWM_505KHZ),2 (PWM_739KHZ),3 (PWM_1076KHZ)"
    tree.end
    tree "HAPTICS_EXTERNAL_PWM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_EXTERNAL_PWM (at 0x1c057)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0570 0x3c0570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FREQ_SEL                                 = " "0 (EXT_PWM_25KHZ),1 (EXT_PWM_50KHZ),2 (EXT_PWM_75KHZ),3 (EXT_PWM_100KHZ)"
    tree.end
    tree "HAPTICS_PWM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_PWM (at 0x1c058)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0580 0x3c0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CAP_SEL                                  = " "0 (PWM_CAP_26PF),1 (PWM_CAP_13PF),2 (PWM_CAP_8P7PF),3 (PWM_CAP_6P5PF)"
    tree.end
    tree "HAPTICS_SC_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_SC_CLR (at 0x1c059)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0590 0x3c0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_CLR                                   = " "0 (SC_DIS),1 (SC_CLR)"
    tree.end
    tree "HAPTICS_BRAKE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_BRAKE (at 0x1c05c)"
      tindex ezaxi:0xfc4cf980 %l 0x83c05c0 0x3c05c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   PATTERN4                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PATTERN3                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PATTERN2                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PATTERN1                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
    tree.end
    tree "HAPTICS_WF_REPEAT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_REPEAT (at 0x1c05e)"
      tindex ezaxi:0xfc4cf980 %l 0x83c05e0 0x3c05e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   WF_REPEAT                                = " "0 (WF_REPEAT_1_TIMES),1 (WF_REPEAT_2_TIMES),2 (WF_REPEAT_4_TIMES),3 (WF_REPEAT_8_TIMES),4 (WF_REPEAT_16_TIMES),5 (WF_REPEAT_32_TIMES),6 (WF_REPEAT_64_TIMES),7 (WF_REPEAT_128_TIMES)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   WF_REPEAT_RSVD                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WF_S_REPEAT                              = " "0 (WF_S_REPEAT_1_TIMES),1 (WF_S_REPEAT_2_TIMES),2 (WF_S_REPEAT_4_TIMES),3 (WF_S_REPEAT_8_TIMES)"
    tree.end
    tree "HAPTICS_WF_S1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S1 (at 0x1c060)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0600 0x3c0600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S2 (at 0x1c061)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0610 0x3c0610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S3 (at 0x1c062)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0620 0x3c0620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S4 (at 0x1c063)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0630 0x3c0630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S5 (at 0x1c064)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0640 0x3c0640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S6 (at 0x1c065)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0650 0x3c0650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S7"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S7 (at 0x1c066)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0660 0x3c0660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_WF_S8 (at 0x1c067)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0670 0x3c0670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_PLAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_PLAY (at 0x1c070)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0700 0x3c0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PLAY                                     = " "0 (STOP),1 (PLAY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PAUSE                                    = " "0 (CONTINUE),1 (PAUSE)"
    tree.end
    tree "HAPTICS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_SEC_ACCESS (at 0x1c0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0d00 0x3c0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_PERPH_RESET_CTL2 (at 0x1c0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0d90 0x3c0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_PERPH_RESET_CTL3 (at 0x1c0da)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0da0 0x3c0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_PERPH_RESET_CTL4 (at 0x1c0db)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0db0 0x3c0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "HAPTICS_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_SPARE (at 0x1c0df)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0df0 0x3c0df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "HAPTICS_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_TEST1 (at 0x1c0e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0e00 0x3c0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "HAPTICS_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_INT_TEST_VAL (at 0x1c0e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0e10 0x3c0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_VAL                             = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_VAL                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "HAPTICS_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_TEST1 (at 0x1c0e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0e20 0x3c0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST_SEL                                = "
    tree.end
    tree "HAPTICS_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_TEST2 (at 0x1c0e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0e30 0x3c0e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AUTO_RES_EN                              = " "0 (AUTO_RES_DIS),1 (AUTO_RES_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   EXT_PWM_DTEST_SEL                        = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "HAPTICS_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_TEST3 (at 0x1c0e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0e40 0x3c0e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_ILIM_100MA                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_HI_Z                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_PFET_P_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TM_NFET_P_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TM_PFET_M_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_NFET_M_ON                             = " "0, 1"
    tree.end
    tree "HAPTICS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_TRIM_NUM (at 0x1c0f0)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0f00 0x3c0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "HAPTICS_REF_BUFF_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_REF_BUFF_TRIM (at 0x1c0f1)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0f10 0x3c0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DIS_TRIM),1 (EN_TRIM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CALIB                                    = " "0 (DIS_CAL),1 (EN_CAL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CODE                                     = "
    tree.end
    tree "HAPTICS_ERR_AMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "HAPTICS_ERR_AMP_TRIM (at 0x1c0f2)"
      tindex ezaxi:0xfc4cf980 %l 0x83c0f20 0x3c0f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DIS_TRIM),1 (EN_TRIM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CALIB                                    = " "0 (DIS_CAL),1 (EN_CAL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CODE                                     = "
    tree.end
  tree.end
tree.end
tree "IBB"
  tree "IBB"
    tree "IBB_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_REVISION1 (at 0x1dc00)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc000 0x3dc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "IBB_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_REVISION2 (at 0x1dc01)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc010 0x3dc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "IBB_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_REVISION3 (at 0x1dc02)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc020 0x3dc020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "IBB_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_REVISION4 (at 0x1dc03)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc030 0x3dc030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "IBB_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PERPH_TYPE (at 0x1dc04)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc040 0x3dc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "IBB_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PERPH_SUBTYPE (at 0x1dc05)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc050 0x3dc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "IBB_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_STATUS1 (at 0x1dc08)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc080 0x3dc080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_NOTOK),1 (VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SC_DETECT                                = " "0 (MODULE_SHORT_CIRCUIT),1 (MODULE_NO_SC_FAULT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIMIT_ERROR                             = " "0 (NO_ILIMIT_ERROR),1 (ILIMIT_ERROR)"
    tree.end
    tree "IBB_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_STATUS2 (at 0x1dc09)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc090 0x3dc090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CURRENT_OUTPUT_VOLTAGE                   = "
    tree.end
    tree "IBB_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_STATUS3 (at 0x1dc0a)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc0a0 0x3dc0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IBB_STATUS                               = "
    tree.end
    tree "IBB_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_RT_STS (at 0x1dc10)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc100 0x3dc100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_RT_STS                      = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "IBB_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_SET_TYPE (at 0x1dc11)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc110 0x3dc110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "IBB_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_POLARITY_HIGH (at 0x1dc12)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc120 0x3dc120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "IBB_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_POLARITY_LOW (at 0x1dc13)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc130 0x3dc130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "IBB_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_LATCHED_CLR (at 0x1dc14)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc140 0x3dc140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "IBB_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_EN_SET (at 0x1dc15)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc150 0x3dc150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "IBB_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_EN_CLR (at 0x1dc16)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc160 0x3dc160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "IBB_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_LATCHED_STS (at 0x1dc18)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc180 0x3dc180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "IBB_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_PENDING_STS (at 0x1dc19)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc190 0x3dc190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "IBB_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_MID_SEL (at 0x1dc1a)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc1a0 0x3dc1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "IBB_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_PRIORITY (at 0x1dc1b)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc1b0 0x3dc1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "IBB_OUTPUT_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_OUTPUT_VOLTAGE (at 0x1dc41)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc410 0x3dc410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERRIDE_OUTPUT_VOLTAGE                  = " "0 (DEFAULT_OUTPUT_VOLTAGE),1 (OVERRIDE_OUTPUT_VOLTAGE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "IBB_RING_SUPPRESSION_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_RING_SUPPRESSION_CTL (at 0x1dc42)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc420 0x3dc420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RING_SUPPRESSION                  = " "0 (RING_SUPPRESSION_DISABLED),1 (RING_SUPPRESSION_ENABLED)"
    tree.end
    tree "IBB_VREF_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_VREF_SEL (at 0x1dc43)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc430 0x3dc430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_SEL                                 = " "0 (SUMMIT_BG),1 (PMIC_BG)"
    tree.end
    tree "IBB_LCD_AMOLED_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_LCD_AMOLED_SEL (at 0x1dc44)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc440 0x3dc440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LCD_AMOLED_SELECT                        = " "0 (LCD_MODE),1 (AMOLED_MODE)"
    tree.end
    tree "IBB_MODULE_RDY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_MODULE_RDY (at 0x1dc45)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc450 0x3dc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_RDY                               = " "0 (IBB_NOT_RDY),1 (IBB_RDY)"
    tree.end
    tree "IBB_ENABLE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_ENABLE_CTL (at 0x1dc46)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc460 0x3dc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_EN                                = " "0 (MODULE_DIS),1 (MODULE_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SWIRE_RDY                                = " "0 (SWIRE_NOT_RDY),1 (SWIRE_RDY)"
    tree.end
    tree "IBB_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PD_CTL (at 0x1dc47)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc470 0x3dc470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_PD                                = " "0 (PD_DISABLE),1 (PD_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PD_STRENGTH                              = " "0 (PD_FULLSTRENGTH),1 (PD_HALFSTRENGTH)"
    tree.end
    tree "IBB_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_CLK_DIV (at 0x1dc48)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc480 0x3dc480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "IBB_IPLIMIT_STARTUP_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_IPLIMIT_STARTUP_CTL_1 (at 0x1dc49)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc490 0x3dc490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_IPLIMIT_STEPPER                       = " "0 (DIS_IPLIMIT_STEPPER),1 (EN_IPLIMIT_STEPPER)"
    tree.end
    tree "IBB_IPLIMIT_STARTUP_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_IPLIMIT_STARTUP_CTL_2 (at 0x1dc4a)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc4a0 0x3dc4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   STARTUP_IPLIMIT                          = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CURRENT_STEP_SIZE                        = " "0 (MA50),1 (MA100),2 (MA150),3 (MA200)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIMIT_STEPPER_CYCLES                   = " "0 (CYCLES_PER_STEP_8),1 (CYCLES_PER_STEP_16),2 (CYCLES_PER_STEP_32),3 (CYCLES_PER_STEP_64)"
    tree.end
    tree "IBB_CURRENT_LIMIT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_CURRENT_LIMIT (at 0x1dc4b)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc4b0 0x3dc4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ILIMIT_COUNT                             = " "0 (CYC8),1 (CYC16),2 (CYC32),3 (CYC64)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SET_CURRENT_MAX                          = "
    tree.end
    tree "IBB_CURRENT_SENSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_CURRENT_SENSE (at 0x1dc4c)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc4c0 0x3dc4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SEL_C_COMP                               = " "0 (CURR_SNS_COMP_CAP_50FF),1 (CURR_SNS_COMP_CAP_70FF)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_GAIN                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "IBB_LOOP_COMP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_LOOP_COMP_CTL (at 0x1dc4d)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc4d0 0x3dc4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LOOP_COMP_CAP                            = " "0 (COMP_CAP_96PF),1 (COMP_CAP_106PF),2 (COMP_CAP_116PF),3 (COMP_CAP_126PF)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_COMP_RES                            = "
    tree.end
    tree "IBB_SLOPE_COMP_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_SLOPE_COMP_CURRENT (at 0x1dc4e)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc4e0 0x3dc4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP_CURRENT                       = " "0 (COMP_CURR_0P25UA),1 (COMP_CURR_0P5UA),2 (COMP_CURR_0P75UA),3 (COMP_CURR_1UA),4 (COMP_CURR_1P25UA),5 (COMP_CURR_1P5UA),6 (COMP_CURR_1P75UA),7 (COMP_CURR_2UA)"
    tree.end
    tree "IBB_INZERO_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INZERO_CTL (at 0x1dc4f)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc4f0 0x3dc4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   INZERO_DELAY                             = " "0 (NS70),1 (NS35_1),2 (NS35_2),3 (NS25)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERRIDE_VOLTAGE_OFFSET                  = " "0 (DEFAULT_VOLTAGE_OFFSET),1 (OVERRIDE_VOLTAGE_OFFSET)"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   VOLTAGE_OFFSET                           = " "0 (VOFF_0MV),1 (VOFF_M1MV),2 (VOFF_M4MV),3 (VOFF_M8MV),4 (VOFF_1MV),5 (VOFF_4MV),6 (VOFF_6MV),7 (VOFF_8MV)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_DETECT_ON                             = " "0 (INZERODET_ZERO),1 (INZERODET_EN)"
    tree.end
    tree "IBB_PS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PS_CTL (at 0x1dc50)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc500 0x3dc500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PS                                    = " "0 (DIS_PS),1 (EN_PS)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_THRESHOLD                             = " "0 (UA0),1 (UA0P5),2 (UA1),3 (UA1P5),4 (UA2),5 (UA2P5),6 (UA3),7 (UA3P5)"
    tree.end
    tree "IBB_PWM_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PWM_CTL_1 (at 0x1dc51)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc510 0x3dc510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UNLIMITED_DUTY_CYCLE                     = " "0 (LIMITED_DUTY_CYCLE),1 (UNLIMITED_DUTY_CYCLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   MAX_DUTY_CYCLE                           = " "0 (NS26),1 (NS52),2 (NS78),3 (NS104)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIN_DUTY_CYCLE                           = " "0 (NS26),1 (NS52),2 (NS78),3 (NS104)"
    tree.end
    tree "IBB_PWM_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PWM_CTL_2 (at 0x1dc52)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc520 0x3dc520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   ERR_AMP_GAIN                             = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIMIT_BLANK_TIME                       = " "0 (NS20_1),1 (NS14),2 (NS20_2),3 (NS40)"
    tree.end
    tree "IBB_RDSON_MNGMNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_RDSON_MNGMNT (at 0x1dc53)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc530 0x3dc530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NFET_SLEW                                = " "0 (NFET_HALF_SLEW),1 (NFET_FULL_SLEW)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_SLEW                                = " "0 (PFET_HALF_SLEW),1 (PFET_FULL_SLEW)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVERRIDE_NFET_SW_SIZE                    = " "0 (DEFAULT_NFET_SW_SIZE),1 (OVERRIDE_NFET_SW_SIZE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   NFET_SW_SIZE                             = " "0 (LCD_NFET_HALF_SIZE),1 (LCD_NFET_FULL_SIZE),2 (AMOLED_NFET_HALF_SIZE),3 (AMOLED_NFET_FULL_SIZE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERRIDE_PFET_SW_SIZE                    = " "0 (DEFAULT_PFET_SW_SIZE),1 (OVERRIDE_PFET_SW_SIZE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFET_SW_SIZE                             = " "0 (LCD_PFET_HALF_SIZE),1 (LCD_PFET_FULL_SIZE),2 (AMOLED_PFET_HALF_SIZE),3 (AMOLED_PFET_FULL_SIZE)"
    tree.end
    tree "IBB_SHORT_CIRCUIT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_SHORT_CIRCUIT_CTL (at 0x1dc54)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc540 0x3dc540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SHORT_CIRCUIT_DEB                        = " "0 (US2),1 (US4),2 (US16),3 (US32)"
    tree.end
    tree "IBB_VREG_OK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_VREG_OK_CTL (at 0x1dc55)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc550 0x3dc550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_VREG_NOT_OK_BLANK                     = " "0 (DIS_VREG_NOT_OK_BLANKING),1 (EN_VREG_NOT_OK_BLANKING)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VREG_NOT_OK_BLANKTIME                    = " "0 (MS8),1 (MS16),2 (MS32),3 (MS64)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_DEB                              = " "0 (US2),1 (US4),2 (US8),3 (US16)"
    tree.end
    tree "IBB_NONOVERLAP_TIME_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_NONOVERLAP_TIME_1 (at 0x1dc56)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc560 0x3dc560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVERRIDE_NONOVERLAP                      = " "0 (DEFAULT_NONOVERLAP_TIME),1 (OVERRIDE_NONOVERLAP_TIME)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NONOVERLAP_PFET                          = " "0 (GATE_DELAY_8),1 (GATE_DELAY_6),2 (GATE_DELAY_4),3 (GATE_DELAY_2),4 (GATE_DELAY_22),5 (GATE_DELAY_18),6 (GATE_DELAY_14),7 (GATE_DELAY_10)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NONOVERLAP_NFET                          = " "0 (GATE_DELAY_8),1 (GATE_DELAY_6),2 (GATE_DELAY_4),3 (GATE_DELAY_2),4 (GATE_DELAY_22),5 (GATE_DELAY_18),6 (GATE_DELAY_14),7 (GATE_DELAY_10)"
    tree.end
    tree "IBB_NONOVERLAP_TIME_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_NONOVERLAP_TIME_2 (at 0x1dc57)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc570 0x3dc570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   P2N_MUX_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N2P_MUX_SEL                              = " "0, 1"
    tree.end
    tree "IBB_PWRUP_PWRDN_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PWRUP_PWRDN_CTL_1 (at 0x1dc58)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc580 0x3dc580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWRUP_DLY1_SRC                           = " "0 (BIAS_ACTIVE),1 (LAB_VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWRUP_DLY1                            = " "0 (DIS_PWRUP_DLY1),1 (EN_PWRUP_DLY1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWRUP_DLY1                               = " "0 (MS1),1 (MS2),2 (MS4),3 (MS8)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWRDN_DLY2_SRC                           = " "0 (IBB_DIS),1 (IBB_DISCHARGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWRDN_DLY2                               = " "0 (MS1),1 (MS2),2 (MS4),3 (MS8)"
    tree.end
    tree "IBB_PWRUP_PWRDN_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PWRUP_PWRDN_CTL_2 (at 0x1dc59)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc590 0x3dc590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WAIT_MBG_OK                              = " "0 (DIS_WAIT_MBG_OK),1 (EN_WAIT_MBG_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IBB_DIS_DLY                              = " "0 (MS0),1 (MS1),2 (MS2),3 (MS4)"
    tree.end
    tree "IBB_SWIRE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_SWIRE_CTL (at 0x1dc5a)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc5a0 0x3dc5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OUTPUT_VOLTAGE_AT_ONE_PULSE              = "
    tree.end
    tree "IBB_OUTPUT_VOLTAGE_INTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_OUTPUT_VOLTAGE_INTL (at 0x1dc5b)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc5b0 0x3dc5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE_INTERNAL              = "
    tree.end
    tree "IBB_OUTPUT_SLEW_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_OUTPUT_SLEW_CTL (at 0x1dc5c)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc5c0 0x3dc5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DIGITAL_SLEW_CTL                      = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   STEP_INTERVAL_TIME                       = " "0 (MS0P25),1 (MS0P5),2 (MS1),3 (MS2),4 (MS4),5 (MS8),6 (MS16),7 (MS32)"
    tree.end
    tree "IBB_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD (at 0x1dc5d)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc5d0 0x3dc5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD    = "
    tree.end
    tree "IBB_RAMP_OFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_RAMP_OFFSET (at 0x1dc5e)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc5e0 0x3dc5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_OFFSET                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "IBB_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_SOFT_START_CTL (at 0x1dc5f)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc5f0 0x3dc5f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SOFT_START                               = " "0, 1, 2, 3"
    tree.end
    tree "IBB_SPARE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_SPARE_CTL (at 0x1dc60)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc600 0x3dc600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   UNDEFINED_LV                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   SPARES                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_SHORT_CIRCUIT_PROTECTION             = " "0 (EN_SCP),1 (DIS_SCP)"
    tree.end
    tree "IBB_NLIMIT_DAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_NLIMIT_DAC (at 0x1dc61)"
      tindex ezaxi:0xfc4cf980 %l 0x83dc610 0x3dc610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NLIMIT_DAC                               = " "0 (MA0),1 (MA80),2 (MA160),3 (MA240),4 (MA320),5 (MA400),6 (MA480),7 (MA560)"
    tree.end
    tree "IBB_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_SEC_ACCESS (at 0x1dcd0)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcd00 0x3dcd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "IBB_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PERPH_RESET_CTL1 (at 0x1dcd8)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcd80 0x3dcd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "IBB_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PERPH_RESET_CTL2 (at 0x1dcd9)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcd90 0x3dcd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "IBB_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PERPH_RESET_CTL3 (at 0x1dcda)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcda0 0x3dcda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "IBB_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_PERPH_RESET_CTL4 (at 0x1dcdb)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcdb0 0x3dcdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "IBB_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_TEST1 (at 0x1dce0)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce00 0x3dce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "IBB_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_INT_TEST_VAL (at 0x1dce1)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce10 0x3dce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "IBB_DTEST1_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_DTEST1_ACCESS (at 0x1dce2)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce20 0x3dce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1_ACCESS                            = "
    tree.end
    tree "IBB_DTEST2_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_DTEST2_ACCESS (at 0x1dce3)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce30 0x3dce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_ACCESS                            = "
    tree.end
    tree "IBB_DTEST3_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_DTEST3_ACCESS (at 0x1dce4)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce40 0x3dce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3_ACCESS                            = "
    tree.end
    tree "IBB_DTEST4_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_DTEST4_ACCESS (at 0x1dce5)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce50 0x3dce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_ACCESS                            = "
    tree.end
    tree "IBB_ATEST1_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_ATEST1_ACCESS (at 0x1dce6)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce60 0x3dce60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (ATEST_GM_2UA),2 (ATEST_BIAS1UA),3 (DISCHARGE_RAMP_ATEST),4 (PREAMP_TRIM_OUT),5 (RESERVED),6 (PWM_COMP),7 (BKSP1)"
    tree.end
    tree "IBB_ATEST2_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_ATEST2_ACCESS (at 0x1dce7)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce70 0x3dce70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (RESERVED),2 (VREF_BUFFF_TRIM2_OUT),3 (VREF),4 (ERROR_AMP_OUT_TRIM),5 (PWR_DRV_ATEST),6 (IPLIMIT),7 (KSP2)"
    tree.end
    tree "IBB_ATEST3_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_ATEST3_ACCESS (at 0x1dce8)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce80 0x3dce80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (REF_CAP_CHARGED),2 (TOP_RES_1),3 (DIVIDER_TOP),4 (IBB_VREF),5 (INM_PREAMP),6 (BOT_RES_1),7 (DAC_OUT)"
    tree.end
    tree "IBB_ATEST4_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_ATEST4_ACCESS (at 0x1dce9)"
      tindex ezaxi:0xfc4cf980 %l 0x83dce90 0x3dce90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (RESERVED),2 (PSKIP_THRESHOLD),3 (VFLOAT),4 (VREG_OK),5 (RING_KILL_MV),6 (PULSE_SKIP),7 (N_OFF_LV)"
    tree.end
    tree "IBB_TEST_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TEST_CTL_1 (at 0x1dcea)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcea0 0x3dcea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_OFF_WIRTE_ONCE                     = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_OUTPUT_VOLTAGE_TEST                   = " "0 (DIS),1 (EN)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OUTPUT_VOLTAGE_TEST_MODE                 = " "0 (VM6P1),1 (VM6P2),2 (VM6P3),3 (VM6P4)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RDSON_TEST                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NFET_CTL                                 = " "0 (OFF),1 (ON)"
    tree.end
    tree "IBB_TEST_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TEST_CTL_2 (at 0x1dceb)"
      tindex ezaxi:0xfc4cf980 %l 0x83dceb0 0x3dceb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_FORCE_ON                          = " "0 (NOT_FORCE_ON),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_PWR_STAGE_OFF                      = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ERRAMP_TRIM_DIS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ERRAMP_TRIM_CALIB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_TRIM_INZERO_OFFSET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DISABLE_PREAMP_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CALIB_BUFF_TRIM                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALIB_PREAMP_TRIM                        = " "0, 1"
    tree.end
    tree "IBB_DEBOUNCER_OVERRIDE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_DEBOUNCER_OVERRIDE (at 0x1dcec)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcec0 0x3dcec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEB_ILIMIT                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEB_VREG_OK                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEB_SC                                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "IBB_TEST_CTL_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TEST_CTL_3 (at 0x1dced)"
      tindex ezaxi:0xfc4cf980 %l 0x83dced0 0x3dced0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   STATUS3_CTRL_SEL                         = "
    tree.end
    tree "IBB_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TRIM_NUM (at 0x1dcf0)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcf00 0x3dcf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_NUM                                 = "
    tree.end
    tree "IBB_TRIM_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TRIM_CTL1 (at 0x1dcf1)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcf10 0x3dcf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ERR_AMP_OFFSET_TRIM                      = "
    tree.end
    tree "IBB_TRIM_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TRIM_CTL2 (at 0x1dcf2)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcf20 0x3dcf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_BIAS_GM                             = "
    tree.end
    tree "IBB_TRIM_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TRIM_CTL3 (at 0x1dcf3)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcf30 0x3dcf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_PREAMP_OFFSET                       = "
    tree.end
    tree "IBB_TRIM_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TRIM_CTL4 (at 0x1dcf4)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcf40 0x3dcf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_INZERO_OFFSET                       = "
    tree.end
    tree "IBB_TRIM_CTL5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "IBB_TRIM_CTL5 (at 0x1dcf5)"
      tindex ezaxi:0xfc4cf980 %l 0x83dcf50 0x3dcf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_REF_DAC_BUFF                        = "
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_REVISION1 (at 0x500)"
      tindex ezaxi:0xfc4cf980 %l 0x8205000 0x205000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_REVISION2 (at 0x501)"
      tindex ezaxi:0xfc4cf980 %l 0x8205010 0x205010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_TYPE (at 0x504)"
      tindex ezaxi:0xfc4cf980 %l 0x8205040 0x205040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_SUBTYPE (at 0x505)"
      tindex ezaxi:0xfc4cf980 %l 0x8205050 0x205050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_STATUS1 (at 0x508)"
      tindex ezaxi:0xfc4cf980 %l 0x8205080 0x205080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_STATUS2 (at 0x509)"
      tindex ezaxi:0xfc4cf980 %l 0x8205090 0x205090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_INT_RESEND_ALL (at 0x540)"
      tindex ezaxi:0xfc4cf980 %l 0x8205400 0x205400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_EN_CTL1 (at 0x546)"
      tindex ezaxi:0xfc4cf980 %l 0x8205460 0x205460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_SEC_ACCESS (at 0x5d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8205d00 0x205d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL1 (at 0x5d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8205d80 0x205d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL2 (at 0x5d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8205d90 0x205d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL3 (at 0x5da)"
      tindex ezaxi:0xfc4cf980 %l 0x8205da0 0x205da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL4 (at 0x5db)"
      tindex ezaxi:0xfc4cf980 %l 0x8205db0 0x205db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_TEST1 (at 0x5e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8205e00 0x205e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LAB"
  tree "LAB"
    tree "LAB_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_REVISION1 (at 0x1de00)"
      tindex ezaxi:0xfc4cf980 %l 0x83de000 0x3de000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LAB_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_REVISION2 (at 0x1de01)"
      tindex ezaxi:0xfc4cf980 %l 0x83de010 0x3de010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LAB_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_REVISION3 (at 0x1de02)"
      tindex ezaxi:0xfc4cf980 %l 0x83de020 0x3de020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LAB_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_REVISION4 (at 0x1de03)"
      tindex ezaxi:0xfc4cf980 %l 0x83de030 0x3de030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LAB_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PERPH_TYPE (at 0x1de04)"
      tindex ezaxi:0xfc4cf980 %l 0x83de040 0x3de040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LAB_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PERPH_SUBTYPE (at 0x1de05)"
      tindex ezaxi:0xfc4cf980 %l 0x83de050 0x3de050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LAB_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_STATUS1 (at 0x1de08)"
      tindex ezaxi:0xfc4cf980 %l 0x83de080 0x3de080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_NOTOK),1 (VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SC_DETECT                                = " "0 (MODULE_SHORT_CIRCUIT),1 (MODULE_NO_SC_FAULT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LAB_STATUS                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "LAB_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_RT_STS (at 0x1de10)"
      tindex ezaxi:0xfc4cf980 %l 0x83de100 0x3de100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "LAB_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_SET_TYPE (at 0x1de11)"
      tindex ezaxi:0xfc4cf980 %l 0x83de110 0x3de110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LAB_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_POLARITY_HIGH (at 0x1de12)"
      tindex ezaxi:0xfc4cf980 %l 0x83de120 0x3de120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LAB_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_POLARITY_LOW (at 0x1de13)"
      tindex ezaxi:0xfc4cf980 %l 0x83de130 0x3de130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LAB_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_LATCHED_CLR (at 0x1de14)"
      tindex ezaxi:0xfc4cf980 %l 0x83de140 0x3de140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LAB_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_EN_SET (at 0x1de15)"
      tindex ezaxi:0xfc4cf980 %l 0x83de150 0x3de150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LAB_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_EN_CLR (at 0x1de16)"
      tindex ezaxi:0xfc4cf980 %l 0x83de160 0x3de160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LAB_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_LATCHED_STS (at 0x1de18)"
      tindex ezaxi:0xfc4cf980 %l 0x83de180 0x3de180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LAB_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_PENDING_STS (at 0x1de19)"
      tindex ezaxi:0xfc4cf980 %l 0x83de190 0x3de190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LAB_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_MID_SEL (at 0x1de1a)"
      tindex ezaxi:0xfc4cf980 %l 0x83de1a0 0x3de1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LAB_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_PRIORITY (at 0x1de1b)"
      tindex ezaxi:0xfc4cf980 %l 0x83de1b0 0x3de1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LAB_OUTPUT_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_OUTPUT_VOLTAGE (at 0x1de41)"
      tindex ezaxi:0xfc4cf980 %l 0x83de410 0x3de410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERRIDE_OUTPUT_VOLTAGE                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "LAB_RING_SUPPRESSION_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_RING_SUPPRESSION_CTL (at 0x1de42)"
      tindex ezaxi:0xfc4cf980 %l 0x83de420 0x3de420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RING_SUPPRESSION                  = " "0, 1"
    tree.end
    tree "LAB_VREF_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_VREF_SEL (at 0x1de43)"
      tindex ezaxi:0xfc4cf980 %l 0x83de430 0x3de430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_SEL                                 = " "0 (SUMMIT_BG),1 (PMIC_BG)"
    tree.end
    tree "LAB_LCD_AMOLED_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_LCD_AMOLED_SEL (at 0x1de44)"
      tindex ezaxi:0xfc4cf980 %l 0x83de440 0x3de440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LCD_AMOLED_SELECT                        = " "0 (LCD_MODE),1 (AMOLED_MODE)"
    tree.end
    tree "LAB_MODULE_RDY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_MODULE_RDY (at 0x1de45)"
      tindex ezaxi:0xfc4cf980 %l 0x83de450 0x3de450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_RDY                               = " "0 (LAB_NOT_RDY),1 (LAB_RDY)"
    tree.end
    tree "LAB_ENABLE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_ENABLE_CTL (at 0x1de46)"
      tindex ezaxi:0xfc4cf980 %l 0x83de460 0x3de460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_EN                                = " "0 (MODULE_DIS),1 (MODULE_EN)"
    tree.end
    tree "LAB_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PD_CTL (at 0x1de47)"
      tindex ezaxi:0xfc4cf980 %l 0x83de470 0x3de470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PULLDOWN                             = " "0 (EN_PD),1 (DIS_PD)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PD_STRENGTH                              = " "0 (PD_WEAK),1 (PD_STRONG)"
    tree.end
    tree "LAB_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_CLK_DIV (at 0x1de48)"
      tindex ezaxi:0xfc4cf980 %l 0x83de480 0x3de480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "LAB_IBB_EN_RDY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_IBB_EN_RDY (at 0x1de49)"
      tindex ezaxi:0xfc4cf980 %l 0x83de490 0x3de490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IBB_EN_RDY                               = " "0 (IBB_EN_NOT_RDY),1 (IBB_EN_RDY)"
    tree.end
    tree "LAB_CURRENT_LIMIT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_CURRENT_LIMIT (at 0x1de4b)"
      tindex ezaxi:0xfc4cf980 %l 0x83de4b0 0x3de4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OVERRIDE_CURRENT_MAX                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SET_CURRENT_MAX                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LAB_CURRENT_SENSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_CURRENT_SENSE (at 0x1de4c)"
      tindex ezaxi:0xfc4cf980 %l 0x83de4c0 0x3de4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ISENSE_TAP                               = " "0 (X0P8),1 (X0P9),2 (X1),3 (X1P1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ISENSE_GAIN                              = " "0 (X0P5),1 (X1),2 (X1P5),3 (X2)"
    tree.end
    tree "LAB_LOOP_COMP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_LOOP_COMP_CTL (at 0x1de4d)"
      tindex ezaxi:0xfc4cf980 %l 0x83de4d0 0x3de4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LOOP_COMP_CAP                            = " "0 (COMP_CAP_16PF),1 (COMP_CAP_24PF),2 (COMP_CAP_32PF),3 (COMP_CAP_40PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOOP_COMP_RES                            = " "0 (COMP_RES_100K),1 (COMP_RES_200K),2 (COMP_RES_500K),3 (COMP_RES_600K)"
    tree.end
    tree "LAB_SLOPE_COMP_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_SLOPE_COMP_CURRENT (at 0x1de4e)"
      tindex ezaxi:0xfc4cf980 %l 0x83de4e0 0x3de4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   SLOPE_COMP_CURRENT                       = " "0 (COMP_CURR_4P5UA),1 (COMP_CURR_4UA),2 (COMP_CURR_3P5UA),3 (COMP_CURR_3UA),4 (COMP_CURR_2P5UA),5 (COMP_CURR_2UA),6 (COMP_CURR_1P5UA),7 (COMP_CURR_1UA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLOPE_COMP_DOUBLER                       = " "0 (DO_NOT_DOUBLE),1 (DOUBLE)"
    tree.end
    tree "LAB_IP_ZERO_DETECTOR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_IP_ZERO_DETECTOR (at 0x1de4f)"
      tindex ezaxi:0xfc4cf980 %l 0x83de4f0 0x3de4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VOLTAGE_OFFSET                           = " "0 (VOFF_0MV),1 (VOFF_1P5MV),2 (VOFF_3MV),3 (VOFF_4P5MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_DETECT_ON                             = " "0 (IPZERODET_ZERO),1 (IPZERODET_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTOZERO_ON                              = " "0 (AUTO_ZERORING_DISABLED),1 (AUTO_ZEROING_ENABLED)"
    tree.end
    tree "LAB_PS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PS_CTL (at 0x1de50)"
      tindex ezaxi:0xfc4cf980 %l 0x83de500 0x3de500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PS                                    = " "0 (PWM),1 (PULSE_SKIP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SEL_DIG_PS                               = " "0 (ANALOG_PS),1 (DIGITAL_PS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SEL_PS_TABLE                             = " "0 (PS_TABLE_0),1 (PS_TABLE_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PS_THRESHOLD                             = " "0 (MA20),1 (MA30),2 (MA40),3 (MA50)"
    tree.end
    tree "LAB_PWM_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PWM_CTL_1 (at 0x1de51)"
      tindex ezaxi:0xfc4cf980 %l 0x83de510 0x3de510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MAX_DUTY_CYCLE                        = " "0 (DIS_MAX_DUTY),1 (EN_MAX_DUTY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_D_MODULATION                          = " "0 (DIS_D_MODULATION),1 (EN_D_MODULATION)"
    tree.end
    tree "LAB_PWM_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PWM_CTL_2 (at 0x1de52)"
      tindex ezaxi:0xfc4cf980 %l 0x83de520 0x3de520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ERR_AMP_GAIN                             = " "0 (LOW_GAIN),1 (HIGH_GAIN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_AUTO_ASYNC                            = " "0 (DIS_AUTO_AYSNC),1 (EN_AUTO_ASYNC)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BLANK_TIME                               = " "0 (NS5),1 (NS10),2 (NS20),3 (NS35)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIN_DUTY_CYCLE                           = " "0 (PCT3P9),1 (PCT5P8),2 (PCT7P7),3 (PCT9P2)"
    tree.end
    tree "LAB_RDSON_MNGMNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_RDSON_MNGMNT (at 0x1de53)"
      tindex ezaxi:0xfc4cf980 %l 0x83de530 0x3de530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   NFET_SLEW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFET_SLEW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NFET_SW_SIZE                             = " "0 (RDSON_QUARTER),1 (RDSON_HALF),2 (RDSON_THREE_FOURTH),3 (RDSON_FULLSIZE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFET_SW_SIZE                             = " "0 (RDSON_QUARTER),1 (RDSON_HALF),2 (RDSON_THREE_FOURTH),3 (RDSON_FULLSIZE)"
    tree.end
    tree "LAB_SHORT_CIRCUIT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_SHORT_CIRCUIT_CTL (at 0x1de54)"
      tindex ezaxi:0xfc4cf980 %l 0x83de540 0x3de540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SHORT_CIRCUIT_DEB                        = " "0 (US2),1 (US4),2 (US16),3 (US32)"
    tree.end
    tree "LAB_VREG_OK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_VREG_OK_CTL (at 0x1de55)"
      tindex ezaxi:0xfc4cf980 %l 0x83de550 0x3de550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_DEB                              = " "0 (US10),1 (US20),2 (US30),3 (US40)"
    tree.end
    tree "LAB_AFVC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_AFVC (at 0x1de5d)"
      tindex ezaxi:0xfc4cf980 %l 0x83de5d0 0x3de5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFVC_ENABLE                              = " "0 (AFVC_DIS),1 (AFVC_EN)"
    tree.end
    tree "LAB_PRECHARGE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PRECHARGE_CTL (at 0x1de5e)"
      tindex ezaxi:0xfc4cf980 %l 0x83de5e0 0x3de5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FAST_PRECHARGE                           = " "0 (SLOW_PRECHARGE),1 (FAST_PRECHARGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SELECT_THE_MAX_PRECHARGE_TIME            = " "0 (US200),1 (US300),2 (US400),3 (US500)"
    tree.end
    tree "LAB_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_SOFT_START_CTL (at 0x1de5f)"
      tindex ezaxi:0xfc4cf980 %l 0x83de5f0 0x3de5f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SELECT_THE_MAX_SOFT_START_TIME           = " "0 (US200),1 (US400),2 (US600),3 (US800)"
    tree.end
    tree "LAB_SPARE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_SPARE_CTL (at 0x1de60)"
      tindex ezaxi:0xfc4cf980 %l 0x83de600 0x3de600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   SPARES                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_SHORT_CIRCUIT_PROTECTION             = " "0 (EN_SCP),1 (DIS_SCP)"
    tree.end
    tree "LAB_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_SEC_ACCESS (at 0x1ded0)"
      tindex ezaxi:0xfc4cf980 %l 0x83ded00 0x3ded00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LAB_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PERPH_RESET_CTL1 (at 0x1ded8)"
      tindex ezaxi:0xfc4cf980 %l 0x83ded80 0x3ded80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LAB_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PERPH_RESET_CTL2 (at 0x1ded9)"
      tindex ezaxi:0xfc4cf980 %l 0x83ded90 0x3ded90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LAB_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PERPH_RESET_CTL3 (at 0x1deda)"
      tindex ezaxi:0xfc4cf980 %l 0x83deda0 0x3deda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LAB_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_PERPH_RESET_CTL4 (at 0x1dedb)"
      tindex ezaxi:0xfc4cf980 %l 0x83dedb0 0x3dedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LAB_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_TEST1 (at 0x1dee0)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee00 0x3dee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LAB_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_INT_TEST_VAL (at 0x1dee1)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee10 0x3dee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LAB_DTEST1_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_DTEST1_ACCESS (at 0x1dee2)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee20 0x3dee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (CURR_COMP),2 (DUTYCYCLE_COMP),3 (D0P3_COMP),4 (VREG_OK_COMP),5 (LAB_EN),6 (SHORT_ALARM),7 (PULSESKIP_COMP)"
    tree.end
    tree "LAB_DTEST2_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_DTEST2_ACCESS (at 0x1dee3)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee30 0x3dee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (SWIRE_LAB_EN),2 (NGATE),3 (CLOCK_19P2M),4 (ZX_COMP),5 (DIG_PS_2),6 (PRECHARGE_TIMEOUT),7 (PSLOW_COMP)"
    tree.end
    tree "LAB_DTEST3_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_DTEST3_ACCESS (at 0x1dee4)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee40 0x3dee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (EN_RISEDLY),2 (PGATE),3 (SENSE_SW_CNT),4 (SSEND_COMP),5 (DIG_PS_1),6 (CLK_19P2M_REQ),7 (CLK_DLY)"
    tree.end
    tree "LAB_DTEST4_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_DTEST4_ACCESS (at 0x1dee5)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee50 0x3dee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (VOK_DEBOUNCE),2 (SHORT_ALARM_DEBOUNCE),3 (DIS_CHG_FNC),4 (ILIMIT_COMP),5 (DIG_PS_0),6 (CLK_MASK),7 (MAXD)"
    tree.end
    tree "LAB_ATEST1_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_ATEST1_ACCESS (at 0x1dee6)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee60 0x3dee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (ERRAMP_OUT),2 (VREF1P25_BUF),3 (PFET_D),4 (VBSP_UNTRIM),5 (VC_TRIM_OUT),6 (PVDD_DIV_D0P3),7 (NO_SIGNAL_2)"
    tree.end
    tree "LAB_ATEST2_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_ATEST2_ACCESS (at 0x1dee7)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee70 0x3dee70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (VOUT_DIV),2 (VOUT_DIV_VOKCOMP),3 (PVDD_DIV_DUTYLOW),4 (VOUT_1P25),5 (PVDD_DIV_CURR),6 (PGND),7 (VREF_ERRAMP)"
    tree.end
    tree "LAB_ATEST3_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_ATEST3_ACCESS (at 0x1dee8)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee80 0x3dee80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (VREF_EA_SS),2 (VREF_PS),3 (NFET_DSNS)"
    tree.end
    tree "LAB_ATEST4_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_ATEST4_ACCESS (at 0x1dee9)"
      tindex ezaxi:0xfc4cf980 %l 0x83dee90 0x3dee90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (VREF_SSEND_COMP),2 (PFET_S),3 (IMAX_VREF)"
    tree.end
    tree "LAB_TEST_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_TEST_CTL (at 0x1deea)"
      tindex ezaxi:0xfc4cf980 %l 0x83deea0 0x3deea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_NFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_OFF_WIRTE_ONCE                     = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODULE_FORCE_ON                          = " "0 (NOT_FORCE_ON),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SCALE_ILIM                               = " "0 (X1),1 (X0P5),2 (X0P33),3 (X0P25)"
    tree.end
    tree "LAB_DEBOUNCER_OVERRIDE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_DEBOUNCER_OVERRIDE (at 0x1deeb)"
      tindex ezaxi:0xfc4cf980 %l 0x83deeb0 0x3deeb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEB_VREG_OK                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEB_SC                                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LAB_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_TRIM_NUM (at 0x1def0)"
      tindex ezaxi:0xfc4cf980 %l 0x83def00 0x3def00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LAB_TRIM_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LAB_TRIM_CTL1 (at 0x1def1)"
      tindex ezaxi:0xfc4cf980 %l 0x83def10 0x3def10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIM_EN                                  = " "0 (TRIM_ENB),1 (TRIM_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIM_VALUE_SIGN                          = " "0 (NEG_OFFS_ADDING),1 (POS_OFFS_ADDING)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ERR_AMP_OFFSET_TRIM                      = "
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION1 (at 0x14000)"
      tindex ezaxi:0xfc4cf980 %l 0x8340000 0x340000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION2 (at 0x14001)"
      tindex ezaxi:0xfc4cf980 %l 0x8340010 0x340010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION3 (at 0x14002)"
      tindex ezaxi:0xfc4cf980 %l 0x8340020 0x340020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION4 (at 0x14003)"
      tindex ezaxi:0xfc4cf980 %l 0x8340030 0x340030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_TYPE (at 0x14004)"
      tindex ezaxi:0xfc4cf980 %l 0x8340040 0x340040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_SUBTYPE (at 0x14005)"
      tindex ezaxi:0xfc4cf980 %l 0x8340050 0x340050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_STATUS1 (at 0x14008)"
      tindex ezaxi:0xfc4cf980 %l 0x8340080 0x340080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO1_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_STATUS2 (at 0x14009)"
      tindex ezaxi:0xfc4cf980 %l 0x8340090 0x340090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO1_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_STATUS3 (at 0x1400a)"
      tindex ezaxi:0xfc4cf980 %l 0x83400a0 0x3400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_RT_STS (at 0x14010)"
      tindex ezaxi:0xfc4cf980 %l 0x8340100 0x340100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_SET_TYPE (at 0x14011)"
      tindex ezaxi:0xfc4cf980 %l 0x8340110 0x340110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_POLARITY_HIGH (at 0x14012)"
      tindex ezaxi:0xfc4cf980 %l 0x8340120 0x340120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_POLARITY_LOW (at 0x14013)"
      tindex ezaxi:0xfc4cf980 %l 0x8340130 0x340130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_LATCHED_CLR (at 0x14014)"
      tindex ezaxi:0xfc4cf980 %l 0x8340140 0x340140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_EN_SET (at 0x14015)"
      tindex ezaxi:0xfc4cf980 %l 0x8340150 0x340150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_EN_CLR (at 0x14016)"
      tindex ezaxi:0xfc4cf980 %l 0x8340160 0x340160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_LATCHED_STS (at 0x14018)"
      tindex ezaxi:0xfc4cf980 %l 0x8340180 0x340180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_PENDING_STS (at 0x14019)"
      tindex ezaxi:0xfc4cf980 %l 0x8340190 0x340190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_MID_SEL (at 0x1401a)"
      tindex ezaxi:0xfc4cf980 %l 0x83401a0 0x3401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_PRIORITY (at 0x1401b)"
      tindex ezaxi:0xfc4cf980 %l 0x83401b0 0x3401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO1_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_VOLTAGE_CTL1 (at 0x14040)"
      tindex ezaxi:0xfc4cf980 %l 0x8340400 0x340400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_VOLTAGE_CTL2 (at 0x14041)"
      tindex ezaxi:0xfc4cf980 %l 0x8340410 0x340410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_MODE_CTL2 (at 0x14045)"
      tindex ezaxi:0xfc4cf980 %l 0x8340450 0x340450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_EN_CTL (at 0x14046)"
      tindex ezaxi:0xfc4cf980 %l 0x8340460 0x340460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PD_CTL (at 0x14048)"
      tindex ezaxi:0xfc4cf980 %l 0x8340480 0x340480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO1_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_CURRENT_LIM_CTL (at 0x1404a)"
      tindex ezaxi:0xfc4cf980 %l 0x83404a0 0x3404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_SOFT_START_CTL (at 0x1404c)"
      tindex ezaxi:0xfc4cf980 %l 0x83404c0 0x3404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO1_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_CONFIG_CTL (at 0x14052)"
      tindex ezaxi:0xfc4cf980 %l 0x8340520 0x340520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_LL_VOLTAGE_CTL1 (at 0x14068)"
      tindex ezaxi:0xfc4cf980 %l 0x8340680 0x340680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_LL_VOLTAGE_CTL2 (at 0x14069)"
      tindex ezaxi:0xfc4cf980 %l 0x8340690 0x340690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_UL_VOLTAGE_CTL1 (at 0x1406a)"
      tindex ezaxi:0xfc4cf980 %l 0x83406a0 0x3406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_UL_VOLTAGE_CTL2 (at 0x1406b)"
      tindex ezaxi:0xfc4cf980 %l 0x83406b0 0x3406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_SEC_ACCESS (at 0x140d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8340d00 0x340d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8340d80 0x340d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8340d90 0x340d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
      tindex ezaxi:0xfc4cf980 %l 0x8340da0 0x340da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
      tindex ezaxi:0xfc4cf980 %l 0x8340db0 0x340db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_TEST1 (at 0x140e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8340e00 0x340e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_TEST_VAL (at 0x140e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8340e10 0x340e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TEST1 (at 0x140e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8340e20 0x340e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TEST2 (at 0x140e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8340e30 0x340e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO1_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TRIM_NUM (at 0x140f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8340f00 0x340f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TRIM_CTRL (at 0x140f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8340f10 0x340f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LPG_CHAN1"
  tree "LPG_CHAN1"
    tree "LPG_CHAN1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_REVISION1 (at 0x1b100)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1000 0x3b1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_REVISION2 (at 0x1b101)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1010 0x3b1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_TYPE (at 0x1b104)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1040 0x3b1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_SUBTYPE (at 0x1b105)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1050 0x3b1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_RT_STS (at 0x1b110)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1100 0x3b1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_SET_TYPE (at 0x1b111)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1110 0x3b1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_POLARITY_HIGH (at 0x1b112)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1120 0x3b1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_POLARITY_LOW (at 0x1b113)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1130 0x3b1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_LATCHED_CLR (at 0x1b114)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1140 0x3b1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_EN_SET (at 0x1b115)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1150 0x3b1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_EN_CLR (at 0x1b116)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1160 0x3b1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_LATCHED_STS (at 0x1b118)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1180 0x3b1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_PENDING_STS (at 0x1b119)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1190 0x3b1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_MID_SEL (at 0x1b11a)"
      tindex ezaxi:0xfc4cf980 %l 0x83b11a0 0x3b11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_PRIORITY (at 0x1b11b)"
      tindex ezaxi:0xfc4cf980 %l 0x83b11b0 0x3b11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN1_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PATTERN_CONFIG (at 0x1b140)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1400 0x3b1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PWM_SIZE_CLK (at 0x1b141)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1410 0x3b1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b142)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1420 0x3b1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PWM_TYPE_CONFIG (at 0x1b143)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1430 0x3b1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PWM_VALUE_LSB (at 0x1b144)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1440 0x3b1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PWM_VALUE_MSB (at 0x1b145)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1450 0x3b1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN1_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_ENABLE_CONTROL (at 0x1b146)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1460 0x3b1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN1_PWM_SYNC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PWM_SYNC (at 0x1b147)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1470 0x3b1470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_RAMP_STEP_DURATION_LSB (at 0x1b150)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1500 0x3b1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_RAMP_STEP_DURATION_MSB (at 0x1b151)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1510 0x3b1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN1_PAUSE_HI_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PAUSE_HI_MULTIPLIER (at 0x1b152)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1520 0x3b1520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN1_PAUSE_LO_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PAUSE_LO_MULTIPLIER (at 0x1b154)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1540 0x3b1540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN1_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_HI_INDEX (at 0x1b156)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1560 0x3b1560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LO_INDEX (at 0x1b157)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1570 0x3b1570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_SEC_ACCESS (at 0x1b1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1d00 0x3b1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_RESET_CTL2 (at 0x1b1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1d90 0x3b1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_RESET_CTL3 (at 0x1b1da)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1da0 0x3b1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_RESET_CTL4 (at 0x1b1db)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1db0 0x3b1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_TEST1 (at 0x1b1e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1e00 0x3b1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_TEST_VAL (at 0x1b1e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1e10 0x3b1e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST1 (at 0x1b1e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1e20 0x3b1e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN1_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST2 (at 0x1b1e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1e30 0x3b1e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN1_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST3 (at 0x1b1e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1e40 0x3b1e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN1_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST4 (at 0x1b1e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83b1e50 0x3b1e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN2"
  tree "LPG_CHAN2"
    tree "LPG_CHAN2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_REVISION1 (at 0x1b200)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2000 0x3b2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_REVISION2 (at 0x1b201)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2010 0x3b2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_TYPE (at 0x1b204)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2040 0x3b2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_SUBTYPE (at 0x1b205)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2050 0x3b2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_RT_STS (at 0x1b210)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2100 0x3b2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_SET_TYPE (at 0x1b211)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2110 0x3b2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_POLARITY_HIGH (at 0x1b212)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2120 0x3b2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_POLARITY_LOW (at 0x1b213)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2130 0x3b2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_LATCHED_CLR (at 0x1b214)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2140 0x3b2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_EN_SET (at 0x1b215)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2150 0x3b2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_EN_CLR (at 0x1b216)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2160 0x3b2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_LATCHED_STS (at 0x1b218)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2180 0x3b2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_PENDING_STS (at 0x1b219)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2190 0x3b2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_MID_SEL (at 0x1b21a)"
      tindex ezaxi:0xfc4cf980 %l 0x83b21a0 0x3b21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_PRIORITY (at 0x1b21b)"
      tindex ezaxi:0xfc4cf980 %l 0x83b21b0 0x3b21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN2_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PATTERN_CONFIG (at 0x1b240)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2400 0x3b2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PWM_SIZE_CLK (at 0x1b241)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2410 0x3b2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b242)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2420 0x3b2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PWM_TYPE_CONFIG (at 0x1b243)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2430 0x3b2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PWM_VALUE_LSB (at 0x1b244)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2440 0x3b2440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PWM_VALUE_MSB (at 0x1b245)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2450 0x3b2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN2_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_ENABLE_CONTROL (at 0x1b246)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2460 0x3b2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN2_PWM_SYNC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PWM_SYNC (at 0x1b247)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2470 0x3b2470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_RAMP_STEP_DURATION_LSB (at 0x1b250)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2500 0x3b2500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_RAMP_STEP_DURATION_MSB (at 0x1b251)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2510 0x3b2510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN2_PAUSE_HI_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PAUSE_HI_MULTIPLIER (at 0x1b252)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2520 0x3b2520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN2_PAUSE_LO_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PAUSE_LO_MULTIPLIER (at 0x1b254)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2540 0x3b2540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN2_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_HI_INDEX (at 0x1b256)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2560 0x3b2560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LO_INDEX (at 0x1b257)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2570 0x3b2570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_SEC_ACCESS (at 0x1b2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2d00 0x3b2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_RESET_CTL2 (at 0x1b2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2d90 0x3b2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_RESET_CTL3 (at 0x1b2da)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2da0 0x3b2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_RESET_CTL4 (at 0x1b2db)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2db0 0x3b2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_TEST1 (at 0x1b2e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2e00 0x3b2e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_TEST_VAL (at 0x1b2e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2e10 0x3b2e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN2_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST1 (at 0x1b2e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2e20 0x3b2e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN2_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST2 (at 0x1b2e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2e30 0x3b2e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN2_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST3 (at 0x1b2e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2e40 0x3b2e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN2_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST4 (at 0x1b2e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83b2e50 0x3b2e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN3"
  tree "LPG_CHAN3"
    tree "LPG_CHAN3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_REVISION1 (at 0x1b300)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3000 0x3b3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_REVISION2 (at 0x1b301)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3010 0x3b3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_TYPE (at 0x1b304)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3040 0x3b3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_SUBTYPE (at 0x1b305)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3050 0x3b3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_RT_STS (at 0x1b310)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3100 0x3b3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_SET_TYPE (at 0x1b311)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3110 0x3b3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_POLARITY_HIGH (at 0x1b312)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3120 0x3b3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_POLARITY_LOW (at 0x1b313)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3130 0x3b3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_LATCHED_CLR (at 0x1b314)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3140 0x3b3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_EN_SET (at 0x1b315)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3150 0x3b3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_EN_CLR (at 0x1b316)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3160 0x3b3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_LATCHED_STS (at 0x1b318)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3180 0x3b3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_PENDING_STS (at 0x1b319)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3190 0x3b3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_MID_SEL (at 0x1b31a)"
      tindex ezaxi:0xfc4cf980 %l 0x83b31a0 0x3b31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_PRIORITY (at 0x1b31b)"
      tindex ezaxi:0xfc4cf980 %l 0x83b31b0 0x3b31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN3_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PATTERN_CONFIG (at 0x1b340)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3400 0x3b3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PWM_SIZE_CLK (at 0x1b341)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3410 0x3b3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b342)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3420 0x3b3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PWM_TYPE_CONFIG (at 0x1b343)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3430 0x3b3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PWM_VALUE_LSB (at 0x1b344)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3440 0x3b3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PWM_VALUE_MSB (at 0x1b345)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3450 0x3b3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN3_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_ENABLE_CONTROL (at 0x1b346)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3460 0x3b3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN3_PWM_SYNC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PWM_SYNC (at 0x1b347)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3470 0x3b3470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_RAMP_STEP_DURATION_LSB (at 0x1b350)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3500 0x3b3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_RAMP_STEP_DURATION_MSB (at 0x1b351)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3510 0x3b3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN3_PAUSE_HI_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PAUSE_HI_MULTIPLIER (at 0x1b352)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3520 0x3b3520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN3_PAUSE_LO_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PAUSE_LO_MULTIPLIER (at 0x1b354)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3540 0x3b3540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN3_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_HI_INDEX (at 0x1b356)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3560 0x3b3560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LO_INDEX (at 0x1b357)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3570 0x3b3570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_SEC_ACCESS (at 0x1b3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3d00 0x3b3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_RESET_CTL2 (at 0x1b3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3d90 0x3b3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_RESET_CTL3 (at 0x1b3da)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3da0 0x3b3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_RESET_CTL4 (at 0x1b3db)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3db0 0x3b3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_TEST1 (at 0x1b3e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3e00 0x3b3e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_TEST_VAL (at 0x1b3e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3e10 0x3b3e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN3_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST1 (at 0x1b3e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3e20 0x3b3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN3_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST2 (at 0x1b3e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3e30 0x3b3e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN3_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST3 (at 0x1b3e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3e40 0x3b3e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN3_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST4 (at 0x1b3e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83b3e50 0x3b3e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN4"
  tree "LPG_CHAN4"
    tree "LPG_CHAN4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_REVISION1 (at 0x1b400)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4000 0x3b4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_REVISION2 (at 0x1b401)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4010 0x3b4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_TYPE (at 0x1b404)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4040 0x3b4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_SUBTYPE (at 0x1b405)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4050 0x3b4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_RT_STS (at 0x1b410)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4100 0x3b4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_SET_TYPE (at 0x1b411)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4110 0x3b4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_POLARITY_HIGH (at 0x1b412)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4120 0x3b4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_POLARITY_LOW (at 0x1b413)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4130 0x3b4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_LATCHED_CLR (at 0x1b414)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4140 0x3b4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_EN_SET (at 0x1b415)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4150 0x3b4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_EN_CLR (at 0x1b416)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4160 0x3b4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_LATCHED_STS (at 0x1b418)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4180 0x3b4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_PENDING_STS (at 0x1b419)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4190 0x3b4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_MID_SEL (at 0x1b41a)"
      tindex ezaxi:0xfc4cf980 %l 0x83b41a0 0x3b41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_PRIORITY (at 0x1b41b)"
      tindex ezaxi:0xfc4cf980 %l 0x83b41b0 0x3b41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN4_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PATTERN_CONFIG (at 0x1b440)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4400 0x3b4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PWM_SIZE_CLK (at 0x1b441)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4410 0x3b4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b442)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4420 0x3b4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PWM_TYPE_CONFIG (at 0x1b443)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4430 0x3b4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PWM_VALUE_LSB (at 0x1b444)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4440 0x3b4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PWM_VALUE_MSB (at 0x1b445)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4450 0x3b4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN4_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_ENABLE_CONTROL (at 0x1b446)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4460 0x3b4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN4_PWM_SYNC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PWM_SYNC (at 0x1b447)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4470 0x3b4470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_RAMP_STEP_DURATION_LSB (at 0x1b450)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4500 0x3b4500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_RAMP_STEP_DURATION_MSB (at 0x1b451)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4510 0x3b4510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN4_PAUSE_HI_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PAUSE_HI_MULTIPLIER (at 0x1b452)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4520 0x3b4520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN4_PAUSE_LO_MULTIPLIER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PAUSE_LO_MULTIPLIER (at 0x1b454)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4540 0x3b4540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN4_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_HI_INDEX (at 0x1b456)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4560 0x3b4560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LO_INDEX (at 0x1b457)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4570 0x3b4570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_SEC_ACCESS (at 0x1b4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4d00 0x3b4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_RESET_CTL2 (at 0x1b4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4d90 0x3b4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_RESET_CTL3 (at 0x1b4da)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4da0 0x3b4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_RESET_CTL4 (at 0x1b4db)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4db0 0x3b4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_TEST1 (at 0x1b4e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4e00 0x3b4e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_TEST_VAL (at 0x1b4e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4e10 0x3b4e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN4_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST1 (at 0x1b4e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4e20 0x3b4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN4_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST2 (at 0x1b4e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4e30 0x3b4e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN4_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST3 (at 0x1b4e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4e40 0x3b4e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN4_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST4 (at 0x1b4e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83b4e50 0x3b4e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_LUT"
  tree "LPG_LUT"
    tree "LPG_LUT_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_REVISION1 (at 0x1b000)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0000 0x3b0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_LUT_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_REVISION2 (at 0x1b001)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0010 0x3b0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_LUT_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_TYPE (at 0x1b004)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0040 0x3b0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_LUT_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_SUBTYPE (at 0x1b005)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0050 0x3b0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_LUT_LUT0_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT0_LSB (at 0x1b040)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0400 0x3b0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT0_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT0_MSB (at 0x1b041)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0410 0x3b0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT1_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT1_LSB (at 0x1b042)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0420 0x3b0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT1_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT1_MSB (at 0x1b043)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0430 0x3b0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT2_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT2_LSB (at 0x1b044)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0440 0x3b0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT2_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT2_MSB (at 0x1b045)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0450 0x3b0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT3_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT3_LSB (at 0x1b046)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0460 0x3b0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT3_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT3_MSB (at 0x1b047)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0470 0x3b0470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT4_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT4_LSB (at 0x1b048)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0480 0x3b0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT4_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT4_MSB (at 0x1b049)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0490 0x3b0490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT5_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT5_LSB (at 0x1b04a)"
      tindex ezaxi:0xfc4cf980 %l 0x83b04a0 0x3b04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT5_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT5_MSB (at 0x1b04b)"
      tindex ezaxi:0xfc4cf980 %l 0x83b04b0 0x3b04b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT6_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT6_LSB (at 0x1b04c)"
      tindex ezaxi:0xfc4cf980 %l 0x83b04c0 0x3b04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT6_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT6_MSB (at 0x1b04d)"
      tindex ezaxi:0xfc4cf980 %l 0x83b04d0 0x3b04d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT7_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT7_LSB (at 0x1b04e)"
      tindex ezaxi:0xfc4cf980 %l 0x83b04e0 0x3b04e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT7_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT7_MSB (at 0x1b04f)"
      tindex ezaxi:0xfc4cf980 %l 0x83b04f0 0x3b04f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT8_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT8_LSB (at 0x1b050)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0500 0x3b0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT8_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT8_MSB (at 0x1b051)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0510 0x3b0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT9_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT9_LSB (at 0x1b052)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0520 0x3b0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT9_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT9_MSB (at 0x1b053)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0530 0x3b0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT10_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT10_LSB (at 0x1b054)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0540 0x3b0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT10_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT10_MSB (at 0x1b055)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0550 0x3b0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT11_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT11_LSB (at 0x1b056)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0560 0x3b0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT11_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT11_MSB (at 0x1b057)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0570 0x3b0570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT12_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT12_LSB (at 0x1b058)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0580 0x3b0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT12_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT12_MSB (at 0x1b059)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0590 0x3b0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT13_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT13_LSB (at 0x1b05a)"
      tindex ezaxi:0xfc4cf980 %l 0x83b05a0 0x3b05a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT13_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT13_MSB (at 0x1b05b)"
      tindex ezaxi:0xfc4cf980 %l 0x83b05b0 0x3b05b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT14_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT14_LSB (at 0x1b05c)"
      tindex ezaxi:0xfc4cf980 %l 0x83b05c0 0x3b05c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT14_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT14_MSB (at 0x1b05d)"
      tindex ezaxi:0xfc4cf980 %l 0x83b05d0 0x3b05d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT15_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT15_LSB (at 0x1b05e)"
      tindex ezaxi:0xfc4cf980 %l 0x83b05e0 0x3b05e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT15_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT15_MSB (at 0x1b05f)"
      tindex ezaxi:0xfc4cf980 %l 0x83b05f0 0x3b05f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT16_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT16_LSB (at 0x1b060)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0600 0x3b0600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT16_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT16_MSB (at 0x1b061)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0610 0x3b0610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT17_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT17_LSB (at 0x1b062)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0620 0x3b0620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT17_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT17_MSB (at 0x1b063)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0630 0x3b0630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT18_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT18_LSB (at 0x1b064)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0640 0x3b0640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT18_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT18_MSB (at 0x1b065)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0650 0x3b0650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT19_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT19_LSB (at 0x1b066)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0660 0x3b0660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT19_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT19_MSB (at 0x1b067)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0670 0x3b0670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT20_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT20_LSB (at 0x1b068)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0680 0x3b0680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT20_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT20_MSB (at 0x1b069)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0690 0x3b0690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT21_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT21_LSB (at 0x1b06a)"
      tindex ezaxi:0xfc4cf980 %l 0x83b06a0 0x3b06a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT21_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT21_MSB (at 0x1b06b)"
      tindex ezaxi:0xfc4cf980 %l 0x83b06b0 0x3b06b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT22_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT22_LSB (at 0x1b06c)"
      tindex ezaxi:0xfc4cf980 %l 0x83b06c0 0x3b06c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT22_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT22_MSB (at 0x1b06d)"
      tindex ezaxi:0xfc4cf980 %l 0x83b06d0 0x3b06d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT23_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT23_LSB (at 0x1b06e)"
      tindex ezaxi:0xfc4cf980 %l 0x83b06e0 0x3b06e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT23_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT23_MSB (at 0x1b06f)"
      tindex ezaxi:0xfc4cf980 %l 0x83b06f0 0x3b06f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT24_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT24_LSB (at 0x1b070)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0700 0x3b0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT24_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT24_MSB (at 0x1b071)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0710 0x3b0710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_RAMP_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_RAMP_CONTROL (at 0x1b0c8)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0c80 0x3b0c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S8_RAMP_START                            = " "0 (S8_RAMP_DIS),1 (S8_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   S7_RAMP_START                            = " "0 (S7_RAMP_DIS),1 (S7_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   S6_RAMP_START                            = " "0 (S6_RAMP_DIS),1 (S6_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   S5_RAMP_START                            = " "0 (S5_RAMP_DIS),1 (S5_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   S4_RAMP_START                            = " "0 (S4_RAMP_DIS),1 (S4_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   S3_RAMP_START                            = " "0 (S3_RAMP_DIS),1 (S3_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   S2_RAMP_START                            = " "0 (S2_RAMP_DIS),1 (S2_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   S1_RAMP_START                            = " "0 (S1_RAMP_DIS),1 (S1_RAMP_START)"
    tree.end
    tree "LPG_LUT_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_SEC_ACCESS (at 0x1b0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0d00 0x3b0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_RESET_CTL2 (at 0x1b0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0d90 0x3b0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_RESET_CTL3 (at 0x1b0da)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0da0 0x3b0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_RESET_CTL4 (at 0x1b0db)"
      tindex ezaxi:0xfc4cf980 %l 0x83b0db0 0x3b0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION1 (at 0x2c00)"
      tindex ezaxi:0xfc4cf980 %l 0x822c000 0x22c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION2 (at 0x2c01)"
      tindex ezaxi:0xfc4cf980 %l 0x822c010 0x22c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION3 (at 0x2c02)"
      tindex ezaxi:0xfc4cf980 %l 0x822c020 0x22c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION4 (at 0x2c03)"
      tindex ezaxi:0xfc4cf980 %l 0x822c030 0x22c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_TYPE (at 0x2c04)"
      tindex ezaxi:0xfc4cf980 %l 0x822c040 0x22c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_SUBTYPE (at 0x2c05)"
      tindex ezaxi:0xfc4cf980 %l 0x822c050 0x22c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_STATUS1 (at 0x2c08)"
      tindex ezaxi:0xfc4cf980 %l 0x822c080 0x22c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MODE_CTRL (at 0x2c44)"
      tindex ezaxi:0xfc4cf980 %l 0x822c440 0x22c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_EN_CTL (at 0x2c46)"
      tindex ezaxi:0xfc4cf980 %l 0x822c460 0x22c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_SEC_ACCESS (at 0x2cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x822cd00 0x22cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x822cd80 0x22cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x822cd90 0x22cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
      tindex ezaxi:0xfc4cf980 %l 0x822cda0 0x22cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x822cdb0 0x22cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_TEST1 (at 0x2ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x822ce20 0x22ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_TEST2 (at 0x2ce3)"
      tindex ezaxi:0xfc4cf980 %l 0x822ce30 0x22ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_TRIM_NUM (at 0x2cf0)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf00 0x22cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM1 (at 0x2cf1)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf10 0x22cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM2 (at 0x2cf2)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf20 0x22cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM3 (at 0x2cf3)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf30 0x22cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM4 (at 0x2cf4)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf40 0x22cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM5 (at 0x2cf5)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf50 0x22cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM6 (at 0x2cf6)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf60 0x22cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM7 (at 0x2cf7)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf70 0x22cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM8 (at 0x2cf8)"
      tindex ezaxi:0xfc4cf980 %l 0x822cf80 0x22cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION1 (at 0x900)"
      tindex ezaxi:0xfc4cf980 %l 0x8209000 0x209000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION2 (at 0x901)"
      tindex ezaxi:0xfc4cf980 %l 0x8209010 0x209010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION3 (at 0x902)"
      tindex ezaxi:0xfc4cf980 %l 0x8209020 0x209020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION4 (at 0x903)"
      tindex ezaxi:0xfc4cf980 %l 0x8209030 0x209030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_TYPE (at 0x904)"
      tindex ezaxi:0xfc4cf980 %l 0x8209040 0x209040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_SUBTYPE (at 0x905)"
      tindex ezaxi:0xfc4cf980 %l 0x8209050 0x209050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_STATUS2 (at 0x909)"
      tindex ezaxi:0xfc4cf980 %l 0x8209090 0x209090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
      tindex ezaxi:0xfc4cf980 %l 0x8209420 0x209420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XVDD_DVDD_SRC_CTRL                       = " "0 (USE_LDO),1 (reserved),2 (DO_NOT_USE_LDO),3 (reserved)"
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_DTEST_DRV_CTL (at 0x943)"
      tindex ezaxi:0xfc4cf980 %l 0x8209430 0x209430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_DRV_EN                             = "
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_DTEST_DRV_VAL (at 0x944)"
      tindex ezaxi:0xfc4cf980 %l 0x8209440 0x209440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_VAL                                = "
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_BUCK_CMN_CTL1 (at 0x945)"
      tindex ezaxi:0xfc4cf980 %l 0x8209450 0x209450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   VPRE_CHARGE_SEL                          = " "0 (VPRE_CHARGE_LOW_RANGE_0P35V),1 (VPRE_CHARGE_LOW_RANGE_0P40V),2 (VPRE_CHARGE_LOW_RANGE_0P45V),3 (VPRE_CHARGE_LOW_RANGE_0P50V)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0 (BYPASS_IBG_DLY_DISABLED),1 (BYPASS_IBG_DLY_ENABLED)"
    tree.end
    tree "MISC_MISC_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_MISC_CTL1 (at 0x946)"
      tindex ezaxi:0xfc4cf980 %l 0x8209460 0x209460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MISC_CTL                                 = "
    tree.end
    tree "MISC_LED_IZTC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_LED_IZTC_CTL (at 0x947)"
      tindex ezaxi:0xfc4cf980 %l 0x8209470 0x209470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ATEST_LED_IZTC                        = " "0 (ATEST_IZTC_DISABLED),1 (ATEST_IZTC_ENABLED)"
    tree.end
    tree "MISC_TX_GTR_THRES_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_TX_GTR_THRES_CTL (at 0x94a)"
      tindex ezaxi:0xfc4cf980 %l 0x82094a0 0x2094a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TX_GTR_THRES_REG                         = " "0 (TRANSMIT_OVER),1 (GSM_TRANSMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_GTR_THRES_SEL                         = " "0, 1"
    tree.end
    tree "MISC_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_SEC_ACCESS (at 0x9d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8209d00 0x209d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8209d90 0x209d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_RESET_CTL3 (at 0x9da)"
      tindex ezaxi:0xfc4cf980 %l 0x8209da0 0x209da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_RESET_CTL4 (at 0x9db)"
      tindex ezaxi:0xfc4cf980 %l 0x8209db0 0x209db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_TEST_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_TEST_ACCESS (at 0x9e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8209e00 0x209e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (TEST_ACCESS_DISABLED),1 (TEST_ACCESS_ENABLED)"
    tree.end
    tree "MISC_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_TRIM_NUM (at 0x9f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8209f00 0x209f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "MISC_IZTC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_IZTC_TRIM (at 0x9f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8209f10 0x209f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IZTC_TRIM                                = "
    tree.end
    tree "MISC_IZTC_TRIM_PROCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_IZTC_TRIM_PROCESS (at 0x9f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8209f20 0x209f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IZTC_TRIM_PROCESS                        = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION1 (at 0xa000)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0000 0x2a0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION2 (at 0xa001)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0010 0x2a0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION3 (at 0xa002)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0020 0x2a0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION4 (at 0xa003)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0030 0x2a0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_TYPE (at 0xa004)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0040 0x2a0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_SUBTYPE (at 0xa005)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0050 0x2a0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_STATUS1 (at 0xa008)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0080 0x2a0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_RT_STS (at 0xa010)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0100 0x2a0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_SET_TYPE (at 0xa011)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0110 0x2a0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_POLARITY_HIGH (at 0xa012)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0120 0x2a0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_POLARITY_LOW (at 0xa013)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0130 0x2a0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_LATCHED_CLR (at 0xa014)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0140 0x2a0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_EN_SET (at 0xa015)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0150 0x2a0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_EN_CLR (at 0xa016)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0160 0x2a0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_LATCHED_STS (at 0xa018)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0180 0x2a0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_PENDING_STS (at 0xa019)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0190 0x2a0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_MID_SEL (at 0xa01a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a01a0 0x2a01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_PRIORITY (at 0xa01b)"
      tindex ezaxi:0xfc4cf980 %l 0x82a01b0 0x2a01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_MODE_CTL (at 0xa040)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0400 0x2a0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_DIG_VIN_CTL (at 0xa041)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0410 0x2a0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_DIG_PULL_CTL (at 0xa042)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0420 0x2a0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_DIG_IN_CTL (at 0xa043)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0430 0x2a0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_EN_CTL (at 0xa046)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0460 0x2a0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_ANA_OUT_CTL (at 0xa048)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0480 0x2a0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_ANA_IN_CTL (at 0xa04a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a04a0 0x2a04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_SINK_CTL (at 0xa04c)"
      tindex ezaxi:0xfc4cf980 %l 0x82a04c0 0x2a04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_SEC_ACCESS (at 0xa0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0d00 0x2a0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0d80 0x2a0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0d90 0x2a0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0da0 0x2a0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
      tindex ezaxi:0xfc4cf980 %l 0x82a0db0 0x2a0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION1 (at 0xa100)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1000 0x2a1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION2 (at 0xa101)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1010 0x2a1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION3 (at 0xa102)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1020 0x2a1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION4 (at 0xa103)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1030 0x2a1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_TYPE (at 0xa104)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1040 0x2a1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_SUBTYPE (at 0xa105)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1050 0x2a1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_STATUS1 (at 0xa108)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1080 0x2a1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_RT_STS (at 0xa110)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1100 0x2a1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_SET_TYPE (at 0xa111)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1110 0x2a1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_POLARITY_HIGH (at 0xa112)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1120 0x2a1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_POLARITY_LOW (at 0xa113)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1130 0x2a1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_LATCHED_CLR (at 0xa114)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1140 0x2a1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_EN_SET (at 0xa115)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1150 0x2a1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_EN_CLR (at 0xa116)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1160 0x2a1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_LATCHED_STS (at 0xa118)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1180 0x2a1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_PENDING_STS (at 0xa119)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1190 0x2a1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_MID_SEL (at 0xa11a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a11a0 0x2a11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_PRIORITY (at 0xa11b)"
      tindex ezaxi:0xfc4cf980 %l 0x82a11b0 0x2a11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_MODE_CTL (at 0xa140)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1400 0x2a1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_DIG_VIN_CTL (at 0xa141)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1410 0x2a1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_DIG_PULL_CTL (at 0xa142)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1420 0x2a1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_DIG_IN_CTL (at 0xa143)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1430 0x2a1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_EN_CTL (at 0xa146)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1460 0x2a1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_ANA_OUT_CTL (at 0xa148)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1480 0x2a1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_ANA_IN_CTL (at 0xa14a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a14a0 0x2a14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_SINK_CTL (at 0xa14c)"
      tindex ezaxi:0xfc4cf980 %l 0x82a14c0 0x2a14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_SEC_ACCESS (at 0xa1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1d00 0x2a1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1d80 0x2a1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1d90 0x2a1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1da0 0x2a1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
      tindex ezaxi:0xfc4cf980 %l 0x82a1db0 0x2a1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION1 (at 0xa200)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2000 0x2a2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION2 (at 0xa201)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2010 0x2a2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION3 (at 0xa202)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2020 0x2a2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION4 (at 0xa203)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2030 0x2a2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_TYPE (at 0xa204)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2040 0x2a2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_SUBTYPE (at 0xa205)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2050 0x2a2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_STATUS1 (at 0xa208)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2080 0x2a2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_RT_STS (at 0xa210)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2100 0x2a2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_SET_TYPE (at 0xa211)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2110 0x2a2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_POLARITY_HIGH (at 0xa212)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2120 0x2a2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_POLARITY_LOW (at 0xa213)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2130 0x2a2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_LATCHED_CLR (at 0xa214)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2140 0x2a2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_EN_SET (at 0xa215)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2150 0x2a2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_EN_CLR (at 0xa216)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2160 0x2a2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_LATCHED_STS (at 0xa218)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2180 0x2a2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_PENDING_STS (at 0xa219)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2190 0x2a2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_MID_SEL (at 0xa21a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a21a0 0x2a21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_PRIORITY (at 0xa21b)"
      tindex ezaxi:0xfc4cf980 %l 0x82a21b0 0x2a21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_MODE_CTL (at 0xa240)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2400 0x2a2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_DIG_VIN_CTL (at 0xa241)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2410 0x2a2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_DIG_PULL_CTL (at 0xa242)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2420 0x2a2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_DIG_IN_CTL (at 0xa243)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2430 0x2a2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_EN_CTL (at 0xa246)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2460 0x2a2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_ANA_OUT_CTL (at 0xa248)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2480 0x2a2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_ANA_IN_CTL (at 0xa24a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a24a0 0x2a24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_SINK_CTL (at 0xa24c)"
      tindex ezaxi:0xfc4cf980 %l 0x82a24c0 0x2a24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_SEC_ACCESS (at 0xa2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2d00 0x2a2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2d80 0x2a2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2d90 0x2a2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2da0 0x2a2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
      tindex ezaxi:0xfc4cf980 %l 0x82a2db0 0x2a2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION1 (at 0xa300)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3000 0x2a3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION2 (at 0xa301)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3010 0x2a3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION3 (at 0xa302)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3020 0x2a3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION4 (at 0xa303)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3030 0x2a3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_TYPE (at 0xa304)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3040 0x2a3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_SUBTYPE (at 0xa305)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3050 0x2a3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_STATUS1 (at 0xa308)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3080 0x2a3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_RT_STS (at 0xa310)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3100 0x2a3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_SET_TYPE (at 0xa311)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3110 0x2a3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_POLARITY_HIGH (at 0xa312)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3120 0x2a3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_POLARITY_LOW (at 0xa313)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3130 0x2a3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_LATCHED_CLR (at 0xa314)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3140 0x2a3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_EN_SET (at 0xa315)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3150 0x2a3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_EN_CLR (at 0xa316)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3160 0x2a3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_LATCHED_STS (at 0xa318)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3180 0x2a3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_PENDING_STS (at 0xa319)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3190 0x2a3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_MID_SEL (at 0xa31a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a31a0 0x2a31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_PRIORITY (at 0xa31b)"
      tindex ezaxi:0xfc4cf980 %l 0x82a31b0 0x2a31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_MODE_CTL (at 0xa340)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3400 0x2a3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_DIG_VIN_CTL (at 0xa341)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3410 0x2a3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_DIG_PULL_CTL (at 0xa342)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3420 0x2a3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_DIG_IN_CTL (at 0xa343)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3430 0x2a3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_EN_CTL (at 0xa346)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3460 0x2a3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_ANA_OUT_CTL (at 0xa348)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3480 0x2a3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_ANA_IN_CTL (at 0xa34a)"
      tindex ezaxi:0xfc4cf980 %l 0x82a34a0 0x2a34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_SINK_CTL (at 0xa34c)"
      tindex ezaxi:0xfc4cf980 %l 0x82a34c0 0x2a34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_SEC_ACCESS (at 0xa3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3d00 0x2a3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3d80 0x2a3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3d90 0x2a3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3da0 0x2a3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
      tindex ezaxi:0xfc4cf980 %l 0x82a3db0 0x2a3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION1 (at 0x7100)"
      tindex ezaxi:0xfc4cf980 %l 0x8271000 0x271000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION2 (at 0x7101)"
      tindex ezaxi:0xfc4cf980 %l 0x8271010 0x271010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION3 (at 0x7102)"
      tindex ezaxi:0xfc4cf980 %l 0x8271020 0x271020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION4 (at 0x7103)"
      tindex ezaxi:0xfc4cf980 %l 0x8271030 0x271030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
      tindex ezaxi:0xfc4cf980 %l 0x8271040 0x271040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
      tindex ezaxi:0xfc4cf980 %l 0x8271050 0x271050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_STATUS0 (at 0x7108)"
      tindex ezaxi:0xfc4cf980 %l 0x8271080 0x271080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_STATUS1 (at 0x7109)"
      tindex ezaxi:0xfc4cf980 %l 0x8271090 0x271090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
      tindex ezaxi:0xfc4cf980 %l 0x8271100 0x271100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
      tindex ezaxi:0xfc4cf980 %l 0x8271110 0x271110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
      tindex ezaxi:0xfc4cf980 %l 0x8271120 0x271120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
      tindex ezaxi:0xfc4cf980 %l 0x8271130 0x271130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
      tindex ezaxi:0xfc4cf980 %l 0x8271140 0x271140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
      tindex ezaxi:0xfc4cf980 %l 0x8271150 0x271150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
      tindex ezaxi:0xfc4cf980 %l 0x8271160 0x271160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
      tindex ezaxi:0xfc4cf980 %l 0x8271180 0x271180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
      tindex ezaxi:0xfc4cf980 %l 0x8271190 0x271190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
      tindex ezaxi:0xfc4cf980 %l 0x82711a0 0x2711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
      tindex ezaxi:0xfc4cf980 %l 0x82711b0 0x2711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
      tindex ezaxi:0xfc4cf980 %l 0x8271400 0x271400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
      tindex ezaxi:0xfc4cf980 %l 0x8271420 0x271420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_EN_CTL (at 0x7146)"
      tindex ezaxi:0xfc4cf980 %l 0x8271460 0x271460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8271d00 0x271d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8271d80 0x271d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8271d90 0x271d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
      tindex ezaxi:0xfc4cf980 %l 0x8271da0 0x271da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
      tindex ezaxi:0xfc4cf980 %l 0x8271db0 0x271db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8271e00 0x271e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8271e10 0x271e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION1 (at 0x7200)"
      tindex ezaxi:0xfc4cf980 %l 0x8272000 0x272000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION2 (at 0x7201)"
      tindex ezaxi:0xfc4cf980 %l 0x8272010 0x272010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION3 (at 0x7202)"
      tindex ezaxi:0xfc4cf980 %l 0x8272020 0x272020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION4 (at 0x7203)"
      tindex ezaxi:0xfc4cf980 %l 0x8272030 0x272030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
      tindex ezaxi:0xfc4cf980 %l 0x8272040 0x272040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
      tindex ezaxi:0xfc4cf980 %l 0x8272050 0x272050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_STATUS0 (at 0x7208)"
      tindex ezaxi:0xfc4cf980 %l 0x8272080 0x272080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_STATUS1 (at 0x7209)"
      tindex ezaxi:0xfc4cf980 %l 0x8272090 0x272090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
      tindex ezaxi:0xfc4cf980 %l 0x8272100 0x272100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
      tindex ezaxi:0xfc4cf980 %l 0x8272110 0x272110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
      tindex ezaxi:0xfc4cf980 %l 0x8272120 0x272120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
      tindex ezaxi:0xfc4cf980 %l 0x8272130 0x272130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
      tindex ezaxi:0xfc4cf980 %l 0x8272140 0x272140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
      tindex ezaxi:0xfc4cf980 %l 0x8272150 0x272150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
      tindex ezaxi:0xfc4cf980 %l 0x8272160 0x272160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
      tindex ezaxi:0xfc4cf980 %l 0x8272180 0x272180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
      tindex ezaxi:0xfc4cf980 %l 0x8272190 0x272190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
      tindex ezaxi:0xfc4cf980 %l 0x82721a0 0x2721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
      tindex ezaxi:0xfc4cf980 %l 0x82721b0 0x2721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
      tindex ezaxi:0xfc4cf980 %l 0x8272400 0x272400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
      tindex ezaxi:0xfc4cf980 %l 0x8272420 0x272420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_EN_CTL (at 0x7246)"
      tindex ezaxi:0xfc4cf980 %l 0x8272460 0x272460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8272d00 0x272d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8272d80 0x272d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8272d90 0x272d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
      tindex ezaxi:0xfc4cf980 %l 0x8272da0 0x272da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
      tindex ezaxi:0xfc4cf980 %l 0x8272db0 0x272db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8272e00 0x272e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8272e10 0x272e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT10"
  tree "PBS_CLIENT10"
    tree "PBS_CLIENT10_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION1 (at 0x7b00)"
      tindex ezaxi:0xfc4cf980 %l 0x827b000 0x27b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION2 (at 0x7b01)"
      tindex ezaxi:0xfc4cf980 %l 0x827b010 0x27b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION3 (at 0x7b02)"
      tindex ezaxi:0xfc4cf980 %l 0x827b020 0x27b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION4 (at 0x7b03)"
      tindex ezaxi:0xfc4cf980 %l 0x827b030 0x27b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_TYPE (at 0x7b04)"
      tindex ezaxi:0xfc4cf980 %l 0x827b040 0x27b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT10_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_SUBTYPE (at 0x7b05)"
      tindex ezaxi:0xfc4cf980 %l 0x827b050 0x27b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT10_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_STATUS0 (at 0x7b08)"
      tindex ezaxi:0xfc4cf980 %l 0x827b080 0x27b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_STATUS1 (at 0x7b09)"
      tindex ezaxi:0xfc4cf980 %l 0x827b090 0x27b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT10_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_RT_STS (at 0x7b10)"
      tindex ezaxi:0xfc4cf980 %l 0x827b100 0x27b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT10_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_SET_TYPE (at 0x7b11)"
      tindex ezaxi:0xfc4cf980 %l 0x827b110 0x27b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_POLARITY_HIGH (at 0x7b12)"
      tindex ezaxi:0xfc4cf980 %l 0x827b120 0x27b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_POLARITY_LOW (at 0x7b13)"
      tindex ezaxi:0xfc4cf980 %l 0x827b130 0x27b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_LATCHED_CLR (at 0x7b14)"
      tindex ezaxi:0xfc4cf980 %l 0x827b140 0x27b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_EN_SET (at 0x7b15)"
      tindex ezaxi:0xfc4cf980 %l 0x827b150 0x27b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_EN_CLR (at 0x7b16)"
      tindex ezaxi:0xfc4cf980 %l 0x827b160 0x27b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_LATCHED_STS (at 0x7b18)"
      tindex ezaxi:0xfc4cf980 %l 0x827b180 0x27b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT10_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_PENDING_STS (at 0x7b19)"
      tindex ezaxi:0xfc4cf980 %l 0x827b190 0x27b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT10_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_MID_SEL (at 0x7b1a)"
      tindex ezaxi:0xfc4cf980 %l 0x827b1a0 0x27b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT10_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_PRIORITY (at 0x7b1b)"
      tindex ezaxi:0xfc4cf980 %l 0x827b1b0 0x27b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_TRIG_CFG (at 0x7b40)"
      tindex ezaxi:0xfc4cf980 %l 0x827b400 0x27b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT10_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_TRIG_CTL (at 0x7b42)"
      tindex ezaxi:0xfc4cf980 %l 0x827b420 0x27b420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_EN_CTL (at 0x7b46)"
      tindex ezaxi:0xfc4cf980 %l 0x827b460 0x27b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_SEC_ACCESS (at 0x7bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x827bd00 0x27bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL1 (at 0x7bd8)"
      tindex ezaxi:0xfc4cf980 %l 0x827bd80 0x27bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL2 (at 0x7bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x827bd90 0x27bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL3 (at 0x7bda)"
      tindex ezaxi:0xfc4cf980 %l 0x827bda0 0x27bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL4 (at 0x7bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x827bdb0 0x27bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_TEST1 (at 0x7be0)"
      tindex ezaxi:0xfc4cf980 %l 0x827be00 0x27be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_TEST_VAL (at 0x7be1)"
      tindex ezaxi:0xfc4cf980 %l 0x827be10 0x27be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT11"
  tree "PBS_CLIENT11"
    tree "PBS_CLIENT11_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION1 (at 0x7c00)"
      tindex ezaxi:0xfc4cf980 %l 0x827c000 0x27c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION2 (at 0x7c01)"
      tindex ezaxi:0xfc4cf980 %l 0x827c010 0x27c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION3 (at 0x7c02)"
      tindex ezaxi:0xfc4cf980 %l 0x827c020 0x27c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION4 (at 0x7c03)"
      tindex ezaxi:0xfc4cf980 %l 0x827c030 0x27c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_TYPE (at 0x7c04)"
      tindex ezaxi:0xfc4cf980 %l 0x827c040 0x27c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT11_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_SUBTYPE (at 0x7c05)"
      tindex ezaxi:0xfc4cf980 %l 0x827c050 0x27c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT11_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_STATUS0 (at 0x7c08)"
      tindex ezaxi:0xfc4cf980 %l 0x827c080 0x27c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_STATUS1 (at 0x7c09)"
      tindex ezaxi:0xfc4cf980 %l 0x827c090 0x27c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT11_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_RT_STS (at 0x7c10)"
      tindex ezaxi:0xfc4cf980 %l 0x827c100 0x27c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT11_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_SET_TYPE (at 0x7c11)"
      tindex ezaxi:0xfc4cf980 %l 0x827c110 0x27c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_POLARITY_HIGH (at 0x7c12)"
      tindex ezaxi:0xfc4cf980 %l 0x827c120 0x27c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_POLARITY_LOW (at 0x7c13)"
      tindex ezaxi:0xfc4cf980 %l 0x827c130 0x27c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_LATCHED_CLR (at 0x7c14)"
      tindex ezaxi:0xfc4cf980 %l 0x827c140 0x27c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_EN_SET (at 0x7c15)"
      tindex ezaxi:0xfc4cf980 %l 0x827c150 0x27c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_EN_CLR (at 0x7c16)"
      tindex ezaxi:0xfc4cf980 %l 0x827c160 0x27c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_LATCHED_STS (at 0x7c18)"
      tindex ezaxi:0xfc4cf980 %l 0x827c180 0x27c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT11_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_PENDING_STS (at 0x7c19)"
      tindex ezaxi:0xfc4cf980 %l 0x827c190 0x27c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT11_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_MID_SEL (at 0x7c1a)"
      tindex ezaxi:0xfc4cf980 %l 0x827c1a0 0x27c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT11_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_PRIORITY (at 0x7c1b)"
      tindex ezaxi:0xfc4cf980 %l 0x827c1b0 0x27c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_TRIG_CFG (at 0x7c40)"
      tindex ezaxi:0xfc4cf980 %l 0x827c400 0x27c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT11_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_TRIG_CTL (at 0x7c42)"
      tindex ezaxi:0xfc4cf980 %l 0x827c420 0x27c420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_EN_CTL (at 0x7c46)"
      tindex ezaxi:0xfc4cf980 %l 0x827c460 0x27c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_SEC_ACCESS (at 0x7cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x827cd00 0x27cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL1 (at 0x7cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x827cd80 0x27cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL2 (at 0x7cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x827cd90 0x27cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL3 (at 0x7cda)"
      tindex ezaxi:0xfc4cf980 %l 0x827cda0 0x27cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL4 (at 0x7cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x827cdb0 0x27cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_TEST1 (at 0x7ce0)"
      tindex ezaxi:0xfc4cf980 %l 0x827ce00 0x27ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_TEST_VAL (at 0x7ce1)"
      tindex ezaxi:0xfc4cf980 %l 0x827ce10 0x27ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION1 (at 0x7300)"
      tindex ezaxi:0xfc4cf980 %l 0x8273000 0x273000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION2 (at 0x7301)"
      tindex ezaxi:0xfc4cf980 %l 0x8273010 0x273010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION3 (at 0x7302)"
      tindex ezaxi:0xfc4cf980 %l 0x8273020 0x273020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION4 (at 0x7303)"
      tindex ezaxi:0xfc4cf980 %l 0x8273030 0x273030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
      tindex ezaxi:0xfc4cf980 %l 0x8273040 0x273040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
      tindex ezaxi:0xfc4cf980 %l 0x8273050 0x273050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_STATUS0 (at 0x7308)"
      tindex ezaxi:0xfc4cf980 %l 0x8273080 0x273080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_STATUS1 (at 0x7309)"
      tindex ezaxi:0xfc4cf980 %l 0x8273090 0x273090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
      tindex ezaxi:0xfc4cf980 %l 0x8273100 0x273100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
      tindex ezaxi:0xfc4cf980 %l 0x8273110 0x273110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
      tindex ezaxi:0xfc4cf980 %l 0x8273120 0x273120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
      tindex ezaxi:0xfc4cf980 %l 0x8273130 0x273130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
      tindex ezaxi:0xfc4cf980 %l 0x8273140 0x273140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
      tindex ezaxi:0xfc4cf980 %l 0x8273150 0x273150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
      tindex ezaxi:0xfc4cf980 %l 0x8273160 0x273160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
      tindex ezaxi:0xfc4cf980 %l 0x8273180 0x273180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
      tindex ezaxi:0xfc4cf980 %l 0x8273190 0x273190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
      tindex ezaxi:0xfc4cf980 %l 0x82731a0 0x2731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
      tindex ezaxi:0xfc4cf980 %l 0x82731b0 0x2731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
      tindex ezaxi:0xfc4cf980 %l 0x8273400 0x273400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
      tindex ezaxi:0xfc4cf980 %l 0x8273420 0x273420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_EN_CTL (at 0x7346)"
      tindex ezaxi:0xfc4cf980 %l 0x8273460 0x273460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8273d00 0x273d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8273d80 0x273d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8273d90 0x273d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
      tindex ezaxi:0xfc4cf980 %l 0x8273da0 0x273da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
      tindex ezaxi:0xfc4cf980 %l 0x8273db0 0x273db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8273e00 0x273e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8273e10 0x273e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION1 (at 0x7400)"
      tindex ezaxi:0xfc4cf980 %l 0x8274000 0x274000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION2 (at 0x7401)"
      tindex ezaxi:0xfc4cf980 %l 0x8274010 0x274010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION3 (at 0x7402)"
      tindex ezaxi:0xfc4cf980 %l 0x8274020 0x274020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION4 (at 0x7403)"
      tindex ezaxi:0xfc4cf980 %l 0x8274030 0x274030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
      tindex ezaxi:0xfc4cf980 %l 0x8274040 0x274040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
      tindex ezaxi:0xfc4cf980 %l 0x8274050 0x274050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_STATUS0 (at 0x7408)"
      tindex ezaxi:0xfc4cf980 %l 0x8274080 0x274080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_STATUS1 (at 0x7409)"
      tindex ezaxi:0xfc4cf980 %l 0x8274090 0x274090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
      tindex ezaxi:0xfc4cf980 %l 0x8274100 0x274100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
      tindex ezaxi:0xfc4cf980 %l 0x8274110 0x274110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
      tindex ezaxi:0xfc4cf980 %l 0x8274120 0x274120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
      tindex ezaxi:0xfc4cf980 %l 0x8274130 0x274130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
      tindex ezaxi:0xfc4cf980 %l 0x8274140 0x274140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
      tindex ezaxi:0xfc4cf980 %l 0x8274150 0x274150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
      tindex ezaxi:0xfc4cf980 %l 0x8274160 0x274160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
      tindex ezaxi:0xfc4cf980 %l 0x8274180 0x274180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
      tindex ezaxi:0xfc4cf980 %l 0x8274190 0x274190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
      tindex ezaxi:0xfc4cf980 %l 0x82741a0 0x2741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
      tindex ezaxi:0xfc4cf980 %l 0x82741b0 0x2741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
      tindex ezaxi:0xfc4cf980 %l 0x8274400 0x274400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
      tindex ezaxi:0xfc4cf980 %l 0x8274420 0x274420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_EN_CTL (at 0x7446)"
      tindex ezaxi:0xfc4cf980 %l 0x8274460 0x274460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8274d00 0x274d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8274d80 0x274d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8274d90 0x274d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
      tindex ezaxi:0xfc4cf980 %l 0x8274da0 0x274da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
      tindex ezaxi:0xfc4cf980 %l 0x8274db0 0x274db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8274e00 0x274e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8274e10 0x274e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION1 (at 0x7500)"
      tindex ezaxi:0xfc4cf980 %l 0x8275000 0x275000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION2 (at 0x7501)"
      tindex ezaxi:0xfc4cf980 %l 0x8275010 0x275010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION3 (at 0x7502)"
      tindex ezaxi:0xfc4cf980 %l 0x8275020 0x275020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION4 (at 0x7503)"
      tindex ezaxi:0xfc4cf980 %l 0x8275030 0x275030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
      tindex ezaxi:0xfc4cf980 %l 0x8275040 0x275040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
      tindex ezaxi:0xfc4cf980 %l 0x8275050 0x275050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_STATUS0 (at 0x7508)"
      tindex ezaxi:0xfc4cf980 %l 0x8275080 0x275080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_STATUS1 (at 0x7509)"
      tindex ezaxi:0xfc4cf980 %l 0x8275090 0x275090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
      tindex ezaxi:0xfc4cf980 %l 0x8275100 0x275100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
      tindex ezaxi:0xfc4cf980 %l 0x8275110 0x275110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
      tindex ezaxi:0xfc4cf980 %l 0x8275120 0x275120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
      tindex ezaxi:0xfc4cf980 %l 0x8275130 0x275130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
      tindex ezaxi:0xfc4cf980 %l 0x8275140 0x275140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
      tindex ezaxi:0xfc4cf980 %l 0x8275150 0x275150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
      tindex ezaxi:0xfc4cf980 %l 0x8275160 0x275160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
      tindex ezaxi:0xfc4cf980 %l 0x8275180 0x275180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
      tindex ezaxi:0xfc4cf980 %l 0x8275190 0x275190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
      tindex ezaxi:0xfc4cf980 %l 0x82751a0 0x2751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
      tindex ezaxi:0xfc4cf980 %l 0x82751b0 0x2751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
      tindex ezaxi:0xfc4cf980 %l 0x8275400 0x275400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
      tindex ezaxi:0xfc4cf980 %l 0x8275420 0x275420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_EN_CTL (at 0x7546)"
      tindex ezaxi:0xfc4cf980 %l 0x8275460 0x275460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8275d00 0x275d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8275d80 0x275d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8275d90 0x275d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
      tindex ezaxi:0xfc4cf980 %l 0x8275da0 0x275da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
      tindex ezaxi:0xfc4cf980 %l 0x8275db0 0x275db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8275e00 0x275e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8275e10 0x275e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION1 (at 0x7600)"
      tindex ezaxi:0xfc4cf980 %l 0x8276000 0x276000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION2 (at 0x7601)"
      tindex ezaxi:0xfc4cf980 %l 0x8276010 0x276010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION3 (at 0x7602)"
      tindex ezaxi:0xfc4cf980 %l 0x8276020 0x276020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION4 (at 0x7603)"
      tindex ezaxi:0xfc4cf980 %l 0x8276030 0x276030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
      tindex ezaxi:0xfc4cf980 %l 0x8276040 0x276040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
      tindex ezaxi:0xfc4cf980 %l 0x8276050 0x276050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_STATUS0 (at 0x7608)"
      tindex ezaxi:0xfc4cf980 %l 0x8276080 0x276080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_STATUS1 (at 0x7609)"
      tindex ezaxi:0xfc4cf980 %l 0x8276090 0x276090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
      tindex ezaxi:0xfc4cf980 %l 0x8276100 0x276100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
      tindex ezaxi:0xfc4cf980 %l 0x8276110 0x276110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
      tindex ezaxi:0xfc4cf980 %l 0x8276120 0x276120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
      tindex ezaxi:0xfc4cf980 %l 0x8276130 0x276130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
      tindex ezaxi:0xfc4cf980 %l 0x8276140 0x276140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
      tindex ezaxi:0xfc4cf980 %l 0x8276150 0x276150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
      tindex ezaxi:0xfc4cf980 %l 0x8276160 0x276160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
      tindex ezaxi:0xfc4cf980 %l 0x8276180 0x276180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
      tindex ezaxi:0xfc4cf980 %l 0x8276190 0x276190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
      tindex ezaxi:0xfc4cf980 %l 0x82761a0 0x2761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
      tindex ezaxi:0xfc4cf980 %l 0x82761b0 0x2761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
      tindex ezaxi:0xfc4cf980 %l 0x8276400 0x276400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
      tindex ezaxi:0xfc4cf980 %l 0x8276420 0x276420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_EN_CTL (at 0x7646)"
      tindex ezaxi:0xfc4cf980 %l 0x8276460 0x276460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8276d00 0x276d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8276d80 0x276d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8276d90 0x276d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
      tindex ezaxi:0xfc4cf980 %l 0x8276da0 0x276da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
      tindex ezaxi:0xfc4cf980 %l 0x8276db0 0x276db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8276e00 0x276e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8276e10 0x276e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION1 (at 0x7700)"
      tindex ezaxi:0xfc4cf980 %l 0x8277000 0x277000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION2 (at 0x7701)"
      tindex ezaxi:0xfc4cf980 %l 0x8277010 0x277010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION3 (at 0x7702)"
      tindex ezaxi:0xfc4cf980 %l 0x8277020 0x277020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION4 (at 0x7703)"
      tindex ezaxi:0xfc4cf980 %l 0x8277030 0x277030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
      tindex ezaxi:0xfc4cf980 %l 0x8277040 0x277040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
      tindex ezaxi:0xfc4cf980 %l 0x8277050 0x277050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_STATUS0 (at 0x7708)"
      tindex ezaxi:0xfc4cf980 %l 0x8277080 0x277080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_STATUS1 (at 0x7709)"
      tindex ezaxi:0xfc4cf980 %l 0x8277090 0x277090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
      tindex ezaxi:0xfc4cf980 %l 0x8277100 0x277100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
      tindex ezaxi:0xfc4cf980 %l 0x8277110 0x277110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
      tindex ezaxi:0xfc4cf980 %l 0x8277120 0x277120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
      tindex ezaxi:0xfc4cf980 %l 0x8277130 0x277130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
      tindex ezaxi:0xfc4cf980 %l 0x8277140 0x277140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
      tindex ezaxi:0xfc4cf980 %l 0x8277150 0x277150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
      tindex ezaxi:0xfc4cf980 %l 0x8277160 0x277160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
      tindex ezaxi:0xfc4cf980 %l 0x8277180 0x277180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
      tindex ezaxi:0xfc4cf980 %l 0x8277190 0x277190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
      tindex ezaxi:0xfc4cf980 %l 0x82771a0 0x2771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
      tindex ezaxi:0xfc4cf980 %l 0x82771b0 0x2771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
      tindex ezaxi:0xfc4cf980 %l 0x8277400 0x277400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
      tindex ezaxi:0xfc4cf980 %l 0x8277420 0x277420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_EN_CTL (at 0x7746)"
      tindex ezaxi:0xfc4cf980 %l 0x8277460 0x277460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8277d00 0x277d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8277d80 0x277d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8277d90 0x277d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
      tindex ezaxi:0xfc4cf980 %l 0x8277da0 0x277da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
      tindex ezaxi:0xfc4cf980 %l 0x8277db0 0x277db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8277e00 0x277e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8277e10 0x277e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION1 (at 0x7800)"
      tindex ezaxi:0xfc4cf980 %l 0x8278000 0x278000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION2 (at 0x7801)"
      tindex ezaxi:0xfc4cf980 %l 0x8278010 0x278010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION3 (at 0x7802)"
      tindex ezaxi:0xfc4cf980 %l 0x8278020 0x278020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION4 (at 0x7803)"
      tindex ezaxi:0xfc4cf980 %l 0x8278030 0x278030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
      tindex ezaxi:0xfc4cf980 %l 0x8278040 0x278040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
      tindex ezaxi:0xfc4cf980 %l 0x8278050 0x278050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_STATUS0 (at 0x7808)"
      tindex ezaxi:0xfc4cf980 %l 0x8278080 0x278080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_STATUS1 (at 0x7809)"
      tindex ezaxi:0xfc4cf980 %l 0x8278090 0x278090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
      tindex ezaxi:0xfc4cf980 %l 0x8278100 0x278100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
      tindex ezaxi:0xfc4cf980 %l 0x8278110 0x278110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
      tindex ezaxi:0xfc4cf980 %l 0x8278120 0x278120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
      tindex ezaxi:0xfc4cf980 %l 0x8278130 0x278130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
      tindex ezaxi:0xfc4cf980 %l 0x8278140 0x278140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
      tindex ezaxi:0xfc4cf980 %l 0x8278150 0x278150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
      tindex ezaxi:0xfc4cf980 %l 0x8278160 0x278160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
      tindex ezaxi:0xfc4cf980 %l 0x8278180 0x278180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
      tindex ezaxi:0xfc4cf980 %l 0x8278190 0x278190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
      tindex ezaxi:0xfc4cf980 %l 0x82781a0 0x2781a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
      tindex ezaxi:0xfc4cf980 %l 0x82781b0 0x2781b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
      tindex ezaxi:0xfc4cf980 %l 0x8278400 0x278400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
      tindex ezaxi:0xfc4cf980 %l 0x8278420 0x278420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_EN_CTL (at 0x7846)"
      tindex ezaxi:0xfc4cf980 %l 0x8278460 0x278460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8278d00 0x278d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8278d80 0x278d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8278d90 0x278d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
      tindex ezaxi:0xfc4cf980 %l 0x8278da0 0x278da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
      tindex ezaxi:0xfc4cf980 %l 0x8278db0 0x278db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8278e00 0x278e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8278e10 0x278e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT8"
  tree "PBS_CLIENT8"
    tree "PBS_CLIENT8_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION1 (at 0x7900)"
      tindex ezaxi:0xfc4cf980 %l 0x8279000 0x279000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION2 (at 0x7901)"
      tindex ezaxi:0xfc4cf980 %l 0x8279010 0x279010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION3 (at 0x7902)"
      tindex ezaxi:0xfc4cf980 %l 0x8279020 0x279020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION4 (at 0x7903)"
      tindex ezaxi:0xfc4cf980 %l 0x8279030 0x279030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_TYPE (at 0x7904)"
      tindex ezaxi:0xfc4cf980 %l 0x8279040 0x279040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT8_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_SUBTYPE (at 0x7905)"
      tindex ezaxi:0xfc4cf980 %l 0x8279050 0x279050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT8_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_STATUS0 (at 0x7908)"
      tindex ezaxi:0xfc4cf980 %l 0x8279080 0x279080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_STATUS1 (at 0x7909)"
      tindex ezaxi:0xfc4cf980 %l 0x8279090 0x279090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT8_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_RT_STS (at 0x7910)"
      tindex ezaxi:0xfc4cf980 %l 0x8279100 0x279100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT8_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_SET_TYPE (at 0x7911)"
      tindex ezaxi:0xfc4cf980 %l 0x8279110 0x279110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_POLARITY_HIGH (at 0x7912)"
      tindex ezaxi:0xfc4cf980 %l 0x8279120 0x279120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_POLARITY_LOW (at 0x7913)"
      tindex ezaxi:0xfc4cf980 %l 0x8279130 0x279130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_LATCHED_CLR (at 0x7914)"
      tindex ezaxi:0xfc4cf980 %l 0x8279140 0x279140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_EN_SET (at 0x7915)"
      tindex ezaxi:0xfc4cf980 %l 0x8279150 0x279150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_EN_CLR (at 0x7916)"
      tindex ezaxi:0xfc4cf980 %l 0x8279160 0x279160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_LATCHED_STS (at 0x7918)"
      tindex ezaxi:0xfc4cf980 %l 0x8279180 0x279180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT8_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_PENDING_STS (at 0x7919)"
      tindex ezaxi:0xfc4cf980 %l 0x8279190 0x279190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT8_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_MID_SEL (at 0x791a)"
      tindex ezaxi:0xfc4cf980 %l 0x82791a0 0x2791a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT8_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_PRIORITY (at 0x791b)"
      tindex ezaxi:0xfc4cf980 %l 0x82791b0 0x2791b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_TRIG_CFG (at 0x7940)"
      tindex ezaxi:0xfc4cf980 %l 0x8279400 0x279400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT8_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_TRIG_CTL (at 0x7942)"
      tindex ezaxi:0xfc4cf980 %l 0x8279420 0x279420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_EN_CTL (at 0x7946)"
      tindex ezaxi:0xfc4cf980 %l 0x8279460 0x279460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_SEC_ACCESS (at 0x79d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8279d00 0x279d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL1 (at 0x79d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8279d80 0x279d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL2 (at 0x79d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8279d90 0x279d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL3 (at 0x79da)"
      tindex ezaxi:0xfc4cf980 %l 0x8279da0 0x279da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL4 (at 0x79db)"
      tindex ezaxi:0xfc4cf980 %l 0x8279db0 0x279db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_TEST1 (at 0x79e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8279e00 0x279e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_TEST_VAL (at 0x79e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8279e10 0x279e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT9"
  tree "PBS_CLIENT9"
    tree "PBS_CLIENT9_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION1 (at 0x7a00)"
      tindex ezaxi:0xfc4cf980 %l 0x827a000 0x27a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION2 (at 0x7a01)"
      tindex ezaxi:0xfc4cf980 %l 0x827a010 0x27a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION3 (at 0x7a02)"
      tindex ezaxi:0xfc4cf980 %l 0x827a020 0x27a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION4 (at 0x7a03)"
      tindex ezaxi:0xfc4cf980 %l 0x827a030 0x27a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_TYPE (at 0x7a04)"
      tindex ezaxi:0xfc4cf980 %l 0x827a040 0x27a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT9_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_SUBTYPE (at 0x7a05)"
      tindex ezaxi:0xfc4cf980 %l 0x827a050 0x27a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT9_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_STATUS0 (at 0x7a08)"
      tindex ezaxi:0xfc4cf980 %l 0x827a080 0x27a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_STATUS1 (at 0x7a09)"
      tindex ezaxi:0xfc4cf980 %l 0x827a090 0x27a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT9_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_RT_STS (at 0x7a10)"
      tindex ezaxi:0xfc4cf980 %l 0x827a100 0x27a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT9_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_SET_TYPE (at 0x7a11)"
      tindex ezaxi:0xfc4cf980 %l 0x827a110 0x27a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_POLARITY_HIGH (at 0x7a12)"
      tindex ezaxi:0xfc4cf980 %l 0x827a120 0x27a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_POLARITY_LOW (at 0x7a13)"
      tindex ezaxi:0xfc4cf980 %l 0x827a130 0x27a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_LATCHED_CLR (at 0x7a14)"
      tindex ezaxi:0xfc4cf980 %l 0x827a140 0x27a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_EN_SET (at 0x7a15)"
      tindex ezaxi:0xfc4cf980 %l 0x827a150 0x27a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_EN_CLR (at 0x7a16)"
      tindex ezaxi:0xfc4cf980 %l 0x827a160 0x27a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_LATCHED_STS (at 0x7a18)"
      tindex ezaxi:0xfc4cf980 %l 0x827a180 0x27a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT9_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_PENDING_STS (at 0x7a19)"
      tindex ezaxi:0xfc4cf980 %l 0x827a190 0x27a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT9_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_MID_SEL (at 0x7a1a)"
      tindex ezaxi:0xfc4cf980 %l 0x827a1a0 0x27a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT9_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_PRIORITY (at 0x7a1b)"
      tindex ezaxi:0xfc4cf980 %l 0x827a1b0 0x27a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_TRIG_CFG (at 0x7a40)"
      tindex ezaxi:0xfc4cf980 %l 0x827a400 0x27a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT9_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_TRIG_CTL (at 0x7a42)"
      tindex ezaxi:0xfc4cf980 %l 0x827a420 0x27a420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_EN_CTL (at 0x7a46)"
      tindex ezaxi:0xfc4cf980 %l 0x827a460 0x27a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_SEC_ACCESS (at 0x7ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x827ad00 0x27ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL1 (at 0x7ad8)"
      tindex ezaxi:0xfc4cf980 %l 0x827ad80 0x27ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL2 (at 0x7ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x827ad90 0x27ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL3 (at 0x7ada)"
      tindex ezaxi:0xfc4cf980 %l 0x827ada0 0x27ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL4 (at 0x7adb)"
      tindex ezaxi:0xfc4cf980 %l 0x827adb0 0x27adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_TEST1 (at 0x7ae0)"
      tindex ezaxi:0xfc4cf980 %l 0x827ae00 0x27ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_TEST_VAL (at 0x7ae1)"
      tindex ezaxi:0xfc4cf980 %l 0x827ae10 0x27ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION1 (at 0x7000)"
      tindex ezaxi:0xfc4cf980 %l 0x8270000 0x270000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION2 (at 0x7001)"
      tindex ezaxi:0xfc4cf980 %l 0x8270010 0x270010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION3 (at 0x7002)"
      tindex ezaxi:0xfc4cf980 %l 0x8270020 0x270020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION4 (at 0x7003)"
      tindex ezaxi:0xfc4cf980 %l 0x8270030 0x270030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_TYPE (at 0x7004)"
      tindex ezaxi:0xfc4cf980 %l 0x8270040 0x270040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
      tindex ezaxi:0xfc4cf980 %l 0x8270050 0x270050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
      tindex ezaxi:0xfc4cf980 %l 0x8270080 0x270080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
      tindex ezaxi:0xfc4cf980 %l 0x8270090 0x270090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
      tindex ezaxi:0xfc4cf980 %l 0x82700a0 0x2700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
      tindex ezaxi:0xfc4cf980 %l 0x82700b0 0x2700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
      tindex ezaxi:0xfc4cf980 %l 0x82700c0 0x2700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
      tindex ezaxi:0xfc4cf980 %l 0x82700d0 0x2700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
      tindex ezaxi:0xfc4cf980 %l 0x82700e0 0x2700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
      tindex ezaxi:0xfc4cf980 %l 0x82700f0 0x2700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
      tindex ezaxi:0xfc4cf980 %l 0x8270400 0x270400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
      tindex ezaxi:0xfc4cf980 %l 0x8270410 0x270410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
      tindex ezaxi:0xfc4cf980 %l 0x8270420 0x270420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
      tindex ezaxi:0xfc4cf980 %l 0x8270430 0x270430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
      tindex ezaxi:0xfc4cf980 %l 0x8270480 0x270480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
      tindex ezaxi:0xfc4cf980 %l 0x8270490 0x270490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
      tindex ezaxi:0xfc4cf980 %l 0x82704a0 0x2704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
      tindex ezaxi:0xfc4cf980 %l 0x82704b0 0x2704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
      tindex ezaxi:0xfc4cf980 %l 0x82704c0 0x2704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
      tindex ezaxi:0xfc4cf980 %l 0x82704d0 0x2704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
      tindex ezaxi:0xfc4cf980 %l 0x82704e0 0x2704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
      tindex ezaxi:0xfc4cf980 %l 0x82704f0 0x2704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
      tindex ezaxi:0xfc4cf980 %l 0x8270500 0x270500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
      tindex ezaxi:0xfc4cf980 %l 0x8270510 0x270510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
      tindex ezaxi:0xfc4cf980 %l 0x8270540 0x270540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
      tindex ezaxi:0xfc4cf980 %l 0x8270550 0x270550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
      tindex ezaxi:0xfc4cf980 %l 0x8270580 0x270580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
      tindex ezaxi:0xfc4cf980 %l 0x8270590 0x270590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
      tindex ezaxi:0xfc4cf980 %l 0x82705c0 0x2705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
      tindex ezaxi:0xfc4cf980 %l 0x82705d0 0x2705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
      tindex ezaxi:0xfc4cf980 %l 0x8270600 0x270600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
      tindex ezaxi:0xfc4cf980 %l 0x8270610 0x270610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
      tindex ezaxi:0xfc4cf980 %l 0x8270640 0x270640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
      tindex ezaxi:0xfc4cf980 %l 0x8270650 0x270650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
      tindex ezaxi:0xfc4cf980 %l 0x8270680 0x270680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
      tindex ezaxi:0xfc4cf980 %l 0x8270690 0x270690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
      tindex ezaxi:0xfc4cf980 %l 0x82706c0 0x2706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
      tindex ezaxi:0xfc4cf980 %l 0x82706d0 0x2706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
      tindex ezaxi:0xfc4cf980 %l 0x8270700 0x270700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
      tindex ezaxi:0xfc4cf980 %l 0x8270710 0x270710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
      tindex ezaxi:0xfc4cf980 %l 0x8270740 0x270740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
      tindex ezaxi:0xfc4cf980 %l 0x8270750 0x270750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
      tindex ezaxi:0xfc4cf980 %l 0x8270780 0x270780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
      tindex ezaxi:0xfc4cf980 %l 0x8270790 0x270790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
      tindex ezaxi:0xfc4cf980 %l 0x82707c0 0x2707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
      tindex ezaxi:0xfc4cf980 %l 0x82707d0 0x2707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
      tindex ezaxi:0xfc4cf980 %l 0x8270800 0x270800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
      tindex ezaxi:0xfc4cf980 %l 0x8270810 0x270810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
      tindex ezaxi:0xfc4cf980 %l 0x8270840 0x270840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
      tindex ezaxi:0xfc4cf980 %l 0x8270850 0x270850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
      tindex ezaxi:0xfc4cf980 %l 0x8270880 0x270880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
      tindex ezaxi:0xfc4cf980 %l 0x8270890 0x270890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
      tindex ezaxi:0xfc4cf980 %l 0x82708c0 0x2708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
      tindex ezaxi:0xfc4cf980 %l 0x82708d0 0x2708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
      tindex ezaxi:0xfc4cf980 %l 0x8270900 0x270900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
      tindex ezaxi:0xfc4cf980 %l 0x8270910 0x270910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
      tindex ezaxi:0xfc4cf980 %l 0x8270920 0x270920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
      tindex ezaxi:0xfc4cf980 %l 0x8270930 0x270930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
      tindex ezaxi:0xfc4cf980 %l 0x8270940 0x270940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
      tindex ezaxi:0xfc4cf980 %l 0x8270950 0x270950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
      tindex ezaxi:0xfc4cf980 %l 0x8270960 0x270960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
      tindex ezaxi:0xfc4cf980 %l 0x8270970 0x270970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEC_ACCESS (at 0x70d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8270d00 0x270d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8270d90 0x270d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
      tindex ezaxi:0xfc4cf980 %l 0x8270da0 0x270da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
      tindex ezaxi:0xfc4cf980 %l 0x8270db0 0x270db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8270e00 0x270e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8270e10 0x270e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_OTP_CFG1 (at 0x70e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8270e20 0x270e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_OTP_CFG2 (at 0x70e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8270e30 0x270e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TEST1 (at 0x70e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8270e40 0x270e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION1 (at 0x800)"
      tindex ezaxi:0xfc4cf980 %l 0x8208000 0x208000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION2 (at 0x801)"
      tindex ezaxi:0xfc4cf980 %l 0x8208010 0x208010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION3 (at 0x802)"
      tindex ezaxi:0xfc4cf980 %l 0x8208020 0x208020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION4 (at 0x803)"
      tindex ezaxi:0xfc4cf980 %l 0x8208030 0x208030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_TYPE (at 0x804)"
      tindex ezaxi:0xfc4cf980 %l 0x8208040 0x208040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_SUBTYPE (at 0x805)"
      tindex ezaxi:0xfc4cf980 %l 0x8208050 0x208050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_PBL_STATUS (at 0x807)"
      tindex ezaxi:0xfc4cf980 %l 0x8208070 0x208070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   POFF_FAULT_OCCURRED                      = " "0 (NO_FAULT),1 (FAULT_OCCURRED)"
    tree.end
    tree "PON_PON_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_REASON1 (at 0x808)"
      tindex ezaxi:0xfc4cf980 %l 0x8208080 0x208080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_WARM_RESET_REASON1 (at 0x80a)"
      tindex ezaxi:0xfc4cf980 %l 0x82080a0 0x2080a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_WARM_RESET_REASON2 (at 0x80b)"
      tindex ezaxi:0xfc4cf980 %l 0x82080b0 0x2080b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_POFF_REASON1 (at 0x80c)"
      tindex ezaxi:0xfc4cf980 %l 0x82080c0 0x2080c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_POFF_REASON2 (at 0x80d)"
      tindex ezaxi:0xfc4cf980 %l 0x82080d0 0x2080d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SOFT_RESET_REASON1 (at 0x80e)"
      tindex ezaxi:0xfc4cf980 %l 0x82080e0 0x2080e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SOFT_RESET_REASON2 (at 0x80f)"
      tindex ezaxi:0xfc4cf980 %l 0x82080f0 0x2080f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_RT_STS (at 0x810)"
      tindex ezaxi:0xfc4cf980 %l 0x8208100 0x208100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_SET_TYPE (at 0x811)"
      tindex ezaxi:0xfc4cf980 %l 0x8208110 0x208110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_POLARITY_HIGH (at 0x812)"
      tindex ezaxi:0xfc4cf980 %l 0x8208120 0x208120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_POLARITY_LOW (at 0x813)"
      tindex ezaxi:0xfc4cf980 %l 0x8208130 0x208130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_LATCHED_CLR (at 0x814)"
      tindex ezaxi:0xfc4cf980 %l 0x8208140 0x208140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_EN_SET (at 0x815)"
      tindex ezaxi:0xfc4cf980 %l 0x8208150 0x208150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_EN_CLR (at 0x816)"
      tindex ezaxi:0xfc4cf980 %l 0x8208160 0x208160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_LATCHED_STS (at 0x818)"
      tindex ezaxi:0xfc4cf980 %l 0x8208180 0x208180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_PENDING_STS (at 0x819)"
      tindex ezaxi:0xfc4cf980 %l 0x8208190 0x208190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_MID_SEL (at 0x81a)"
      tindex ezaxi:0xfc4cf980 %l 0x82081a0 0x2081a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_PRIORITY (at 0x81b)"
      tindex ezaxi:0xfc4cf980 %l 0x82081b0 0x2081b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
      tindex ezaxi:0xfc4cf980 %l 0x8208400 0x208400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
      tindex ezaxi:0xfc4cf980 %l 0x8208410 0x208410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
      tindex ezaxi:0xfc4cf980 %l 0x8208420 0x208420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
      tindex ezaxi:0xfc4cf980 %l 0x8208430 0x208430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
      tindex ezaxi:0xfc4cf980 %l 0x8208440 0x208440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
      tindex ezaxi:0xfc4cf980 %l 0x8208450 0x208450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
      tindex ezaxi:0xfc4cf980 %l 0x8208460 0x208460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
      tindex ezaxi:0xfc4cf980 %l 0x8208470 0x208470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
      tindex ezaxi:0xfc4cf980 %l 0x8208480 0x208480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
      tindex ezaxi:0xfc4cf980 %l 0x8208490 0x208490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
      tindex ezaxi:0xfc4cf980 %l 0x82084a0 0x2084a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
      tindex ezaxi:0xfc4cf980 %l 0x82084b0 0x2084b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S1_TIMER (at 0x84c)"
      tindex ezaxi:0xfc4cf980 %l 0x82084c0 0x2084c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S2_TIMER (at 0x84d)"
      tindex ezaxi:0xfc4cf980 %l 0x82084d0 0x2084d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S2_CTL (at 0x84e)"
      tindex ezaxi:0xfc4cf980 %l 0x82084e0 0x2084e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
      tindex ezaxi:0xfc4cf980 %l 0x82084f0 0x2084f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S1_TIMER (at 0x850)"
      tindex ezaxi:0xfc4cf980 %l 0x8208500 0x208500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S2_TIMER (at 0x851)"
      tindex ezaxi:0xfc4cf980 %l 0x8208510 0x208510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S2_CTL (at 0x852)"
      tindex ezaxi:0xfc4cf980 %l 0x8208520 0x208520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S2_CTL2 (at 0x853)"
      tindex ezaxi:0xfc4cf980 %l 0x8208530 0x208530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
      tindex ezaxi:0xfc4cf980 %l 0x8208540 0x208540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
      tindex ezaxi:0xfc4cf980 %l 0x8208550 0x208550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
      tindex ezaxi:0xfc4cf980 %l 0x8208560 0x208560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
      tindex ezaxi:0xfc4cf980 %l 0x8208570 0x208570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_PET (at 0x858)"
      tindex ezaxi:0xfc4cf980 %l 0x8208580 0x208580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PS_HOLD_RESET_CTL (at 0x85a)"
      tindex ezaxi:0xfc4cf980 %l 0x82085a0 0x2085a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
      tindex ezaxi:0xfc4cf980 %l 0x82085b0 0x2085b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SW_RESET_S2_CTL (at 0x862)"
      tindex ezaxi:0xfc4cf980 %l 0x8208620 0x208620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SW_RESET_S2_CTL2 (at 0x863)"
      tindex ezaxi:0xfc4cf980 %l 0x8208630 0x208630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SW_RESET_GO (at 0x864)"
      tindex ezaxi:0xfc4cf980 %l 0x8208640 0x208640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_OVERTEMP_RESET_CTL (at 0x866)"
      tindex ezaxi:0xfc4cf980 %l 0x8208660 0x208660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
      tindex ezaxi:0xfc4cf980 %l 0x8208670 0x208670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESERVED_FAULT_RESET_CTL (at 0x868)"
      tindex ezaxi:0xfc4cf980 %l 0x8208680 0x208680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESERVED_FAULT_RESET_CTL2 (at 0x869)"
      tindex ezaxi:0xfc4cf980 %l 0x8208690 0x208690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TFT_RESET_CTL (at 0x86a)"
      tindex ezaxi:0xfc4cf980 %l 0x82086a0 0x2086a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TFT_RESET_CTL2 (at 0x86b)"
      tindex ezaxi:0xfc4cf980 %l 0x82086b0 0x2086b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PULL_CTL (at 0x870)"
      tindex ezaxi:0xfc4cf980 %l 0x8208700 0x208700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DEBOUNCE_CTL (at 0x871)"
      tindex ezaxi:0xfc4cf980 %l 0x8208710 0x208710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_DEBOUNCE                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESET_S3_SRC (at 0x874)"
      tindex ezaxi:0xfc4cf980 %l 0x8208740 0x208740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESET_S3_TIMER (at 0x875)"
      tindex ezaxi:0xfc4cf980 %l 0x8208750 0x208750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_TRIGGER_EN (at 0x880)"
      tindex ezaxi:0xfc4cf980 %l 0x8208800 0x208800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_OPTION_BITS (at 0x882)"
      tindex ezaxi:0xfc4cf980 %l 0x8208820 0x208820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_DEBOUNCE_DLY                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_WATCHDOG_LOCK (at 0x883)"
      tindex ezaxi:0xfc4cf980 %l 0x8208830 0x208830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_UVLO (at 0x888)"
      tindex ezaxi:0xfc4cf980 %l 0x8208880 0x208880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_UVLO_DLY                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_AVDD_VPH (at 0x88a)"
      tindex ezaxi:0xfc4cf980 %l 0x82088a0 0x2088a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   AVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_DVDD_VPH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DVDD_VPH (at 0x88b)"
      tindex ezaxi:0xfc4cf980 %l 0x82088b0 0x2088b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   XVDD_DVDD_SRC_CTRL                       = " "0 (DVDD_SRC_FROM_LDO),1 (DVDD_SRC_FROM_SMPS),2 (DVDD_SRC_FROM_PON_DVDDREG),3 (DVDD_SRC_FROM_PON_DVDDREG1)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RB_SPARE (at 0x88c)"
      tindex ezaxi:0xfc4cf980 %l 0x82088c0 0x2088c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DVDD_RB_SPARE (at 0x88d)"
      tindex ezaxi:0xfc4cf980 %l 0x82088d0 0x2088d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_XVDD_RB_SPARE (at 0x88e)"
      tindex ezaxi:0xfc4cf980 %l 0x82088e0 0x2088e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SOFT_RB_SPARE (at 0x88f)"
      tindex ezaxi:0xfc4cf980 %l 0x82088f0 0x2088f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON1_INTERFACE (at 0x890)"
      tindex ezaxi:0xfc4cf980 %l 0x8208900 0x208900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PBS_INTERFACE (at 0x891)"
      tindex ezaxi:0xfc4cf980 %l 0x8208910 0x208910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_DEBUG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DEBUG_CTL (at 0x894)"
      tindex ezaxi:0xfc4cf980 %l 0x8208940 0x208940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEBUG_CLOCK                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEBUG_CLOCK_SRC                          = " "0 (RESIN_N),1 (CLK_50K)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_DEBUG                                = "
    tree.end
    tree "PON_DEBUG_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DEBUG_STATUS (at 0x895)"
      tindex ezaxi:0xfc4cf980 %l 0x8208950 0x208950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEBUG_STATE                              = "
    tree.end
    tree "PON_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SEC_ACCESS (at 0x8d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8208d00 0x208d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RESET_CTL2 (at 0x8d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8208d90 0x208d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RESET_CTL3 (at 0x8da)"
      tindex ezaxi:0xfc4cf980 %l 0x8208da0 0x208da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RESET_CTL4 (at 0x8db)"
      tindex ezaxi:0xfc4cf980 %l 0x8208db0 0x208db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_TEST1 (at 0x8e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e00 0x208e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_TEST_VAL (at 0x8e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e10 0x208e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST1 (at 0x8e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e20 0x208e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST2 (at 0x8e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e30 0x208e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST2_DVDD_INT                          = " "0, 1"
    tree.end
    tree "PON_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST3 (at 0x8e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e40 0x208e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST4 (at 0x8e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e50 0x208e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_ATEST1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_TEST5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST5 (at 0x8e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e60 0x208e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_VMAX_SEL (at 0x8e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8208e70 0x208e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TRIM_NUM (at 0x8f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8208f00 0x208f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_TRIM (at 0x8f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8208f10 0x208f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_CNTL_2_TRIM (at 0x8f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8208f20 0x208f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_3_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_CNTL_3_TRIM (at 0x8f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8208f30 0x208f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_4_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_CNTL_4_TRIM (at 0x8f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8208f40 0x208f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RZ_HPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   RZ_LPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION1 (at 0x100)"
      tindex ezaxi:0xfc4cf980 %l 0x8201000 0x201000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION2 (at 0x101)"
      tindex ezaxi:0xfc4cf980 %l 0x8201010 0x201010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION3 (at 0x102)"
      tindex ezaxi:0xfc4cf980 %l 0x8201020 0x201020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION4 (at 0x103)"
      tindex ezaxi:0xfc4cf980 %l 0x8201030 0x201030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_PERPH_TYPE (at 0x104)"
      tindex ezaxi:0xfc4cf980 %l 0x8201040 0x201040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_PERPH_SUBTYPE (at 0x105)"
      tindex ezaxi:0xfc4cf980 %l 0x8201050 0x201050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_SEC_ACCESS (at 0x1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8201d00 0x201d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_TRIM_NUM (at 0x1f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f00 0x201f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "REVID_TP_REV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_TP_REV (at 0x1f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f10 0x201f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TP_REV                                   = "
    tree.end
    tree "REVID_FAB_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_FAB_ID (at 0x1f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f20 0x201f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FAB_ID                                   = "
    tree.end
    tree "REVID_WAFER_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_WAFER_ID (at 0x1f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f30 0x201f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   WAFER_ID                                 = "
    tree.end
    tree "REVID_X_COORD"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_X_COORD (at 0x1f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f40 0x201f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   X_COORD                                  = "
    tree.end
    tree "REVID_Y_COORD"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_Y_COORD (at 0x1f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f50 0x201f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   Y_COORD                                  = "
    tree.end
    tree "REVID_LOT_ID_11_10"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_11_10 (at 0x1f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f60 0x201f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_11_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_10_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_10_09"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_10_09 (at 0x1f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f70 0x201f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_10_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_09_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_09_08"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_09_08 (at 0x1f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f80 0x201f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_09_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_08_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_07_06"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_07_06 (at 0x1f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8201f90 0x201f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_07_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_06_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_06_05"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_06_05 (at 0x1fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8201fa0 0x201fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_06_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_05_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_05_04"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_05_04 (at 0x1fb)"
      tindex ezaxi:0xfc4cf980 %l 0x8201fb0 0x201fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_05_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_04_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_03_02"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_03_02 (at 0x1fc)"
      tindex ezaxi:0xfc4cf980 %l 0x8201fc0 0x201fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_03_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_02_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_02_01"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_02_01 (at 0x1fd)"
      tindex ezaxi:0xfc4cf980 %l 0x8201fd0 0x201fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_02_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_01_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_01_00"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_LOT_ID_01_00 (at 0x1fe)"
      tindex ezaxi:0xfc4cf980 %l 0x8201fe0 0x201fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_01_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_00_5_0                            = "
    tree.end
    tree "REVID_MFG_ID_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_MFG_ID_SPARE (at 0x1ff)"
      tindex ezaxi:0xfc4cf980 %l 0x8201ff0 0x201ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION1 (at 0x11400)"
      tindex ezaxi:0xfc4cf980 %l 0x8314000 0x314000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION2 (at 0x11401)"
      tindex ezaxi:0xfc4cf980 %l 0x8314010 0x314010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION3 (at 0x11402)"
      tindex ezaxi:0xfc4cf980 %l 0x8314020 0x314020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION4 (at 0x11403)"
      tindex ezaxi:0xfc4cf980 %l 0x8314030 0x314030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_TYPE (at 0x11404)"
      tindex ezaxi:0xfc4cf980 %l 0x8314040 0x314040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
      tindex ezaxi:0xfc4cf980 %l 0x8314050 0x314050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STATUS (at 0x11408)"
      tindex ezaxi:0xfc4cf980 %l 0x8314080 0x314080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_RT_STS (at 0x11410)"
      tindex ezaxi:0xfc4cf980 %l 0x8314100 0x314100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_SET_TYPE (at 0x11411)"
      tindex ezaxi:0xfc4cf980 %l 0x8314110 0x314110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
      tindex ezaxi:0xfc4cf980 %l 0x8314120 0x314120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
      tindex ezaxi:0xfc4cf980 %l 0x8314130 0x314130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
      tindex ezaxi:0xfc4cf980 %l 0x8314140 0x314140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_EN_SET (at 0x11415)"
      tindex ezaxi:0xfc4cf980 %l 0x8314150 0x314150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_EN_CLR (at 0x11416)"
      tindex ezaxi:0xfc4cf980 %l 0x8314160 0x314160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
      tindex ezaxi:0xfc4cf980 %l 0x8314180 0x314180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_PENDING_STS (at 0x11419)"
      tindex ezaxi:0xfc4cf980 %l 0x8314190 0x314190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_MID_SEL (at 0x1141a)"
      tindex ezaxi:0xfc4cf980 %l 0x83141a0 0x3141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_PRIORITY (at 0x1141b)"
      tindex ezaxi:0xfc4cf980 %l 0x83141b0 0x3141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VOLTAGE_CTL1 (at 0x11440)"
      tindex ezaxi:0xfc4cf980 %l 0x8314400 0x314400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
      tindex ezaxi:0xfc4cf980 %l 0x8314410 0x314410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_PFM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PFM_CTL (at 0x11444)"
      tindex ezaxi:0xfc4cf980 %l 0x8314440 0x314440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MODE_CTL (at 0x11445)"
      tindex ezaxi:0xfc4cf980 %l 0x8314450 0x314450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S1_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_EN_CTL (at 0x11446)"
      tindex ezaxi:0xfc4cf980 %l 0x8314460 0x314460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PD_CTL (at 0x11448)"
      tindex ezaxi:0xfc4cf980 %l 0x8314480 0x314480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S1_CTRL_COMP_CAP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_COMP_CAP_CTL (at 0x11451)"
      tindex ezaxi:0xfc4cf980 %l 0x8314510 0x314510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S1_CTRL_GM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_GM_CTL (at 0x11452)"
      tindex ezaxi:0xfc4cf980 %l 0x8314520 0x314520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S1_CTRL_RZ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_RZ_CTL (at 0x11453)"
      tindex ezaxi:0xfc4cf980 %l 0x8314530 0x314530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S1_CTRL_ISNS_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_ISNS_CTRL (at 0x11455)"
      tindex ezaxi:0xfc4cf980 %l 0x8314550 0x314550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S1_CTRL_SAW_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_SAW_CTL (at 0x11456)"
      tindex ezaxi:0xfc4cf980 %l 0x8314560 0x314560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S1_CTRL_DMAX_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_DMAX_CTL (at 0x11458)"
      tindex ezaxi:0xfc4cf980 %l 0x8314580 0x314580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PULSE_SKIP_CTL (at 0x11459)"
      tindex ezaxi:0xfc4cf980 %l 0x8314590 0x314590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_THRES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PULSE_SKIP_THRES (at 0x1145a)"
      tindex ezaxi:0xfc4cf980 %l 0x83145a0 0x3145a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S1_CTRL_AUTO_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_AUTO_MODE_CTL (at 0x1145b)"
      tindex ezaxi:0xfc4cf980 %l 0x83145b0 0x3145b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S1_CTRL_INZERO_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INZERO_COUNT_CTL (at 0x1145c)"
      tindex ezaxi:0xfc4cf980 %l 0x83145c0 0x3145c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PFM_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PFM_COUNT_CTL (at 0x1145d)"
      tindex ezaxi:0xfc4cf980 %l 0x83145d0 0x3145d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PS_VGA_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PS_VGA_CTL (at 0x1145e)"
      tindex ezaxi:0xfc4cf980 %l 0x83145e0 0x3145e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
      tindex ezaxi:0xfc4cf980 %l 0x8314600 0x314600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
      tindex ezaxi:0xfc4cf980 %l 0x8314610 0x314610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_FT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_FT_CTL (at 0x11462)"
      tindex ezaxi:0xfc4cf980 %l 0x8314620 0x314620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S1_CTRL_QMODE_SHADOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_QMODE_SHADOW (at 0x11463)"
      tindex ezaxi:0xfc4cf980 %l 0x8314630 0x314630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S1_CTRL_UL_LL_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_UL_LL_CTRL (at 0x11468)"
      tindex ezaxi:0xfc4cf980 %l 0x8314680 0x314680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S1_CTRL_UL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_UL_VOLTAGE (at 0x11469)"
      tindex ezaxi:0xfc4cf980 %l 0x8314690 0x314690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_LL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_LL_VOLTAGE (at 0x1146b)"
      tindex ezaxi:0xfc4cf980 %l 0x83146b0 0x3146b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_OCP (at 0x1146c)"
      tindex ezaxi:0xfc4cf980 %l 0x83146c0 0x3146c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S1_CTRL_CTLR_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CTLR_MISC (at 0x1147a)"
      tindex ezaxi:0xfc4cf980 %l 0x83147a0 0x3147a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_SEC_ACCESS (at 0x114d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8314d00 0x314d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8314d80 0x314d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8314d90 0x314d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
      tindex ezaxi:0xfc4cf980 %l 0x8314da0 0x314da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
      tindex ezaxi:0xfc4cf980 %l 0x8314db0 0x314db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_TEST1 (at 0x114e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8314e00 0x314e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8314e10 0x314e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S1_CTRL_CTLR_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CTLR_TEST (at 0x114e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8314e20 0x314e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_TRIM_NUM (at 0x114f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8314f00 0x314f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CTL_TRIM1 (at 0x114f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8314f10 0x314f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S1_CTRL_CTL_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CTL_TRIM2 (at 0x114f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8314f20 0x314f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S1_CTRL_CTL_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CTL_TRIM3 (at 0x114f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8314f30 0x314f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S1_CTRL_CTL_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CTL_TRIM4 (at 0x114f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8314f40 0x314f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_REVISION1 (at 0x11600)"
      tindex ezaxi:0xfc4cf980 %l 0x8316000 0x316000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_REVISION2 (at 0x11601)"
      tindex ezaxi:0xfc4cf980 %l 0x8316010 0x316010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_TYPE (at 0x11604)"
      tindex ezaxi:0xfc4cf980 %l 0x8316040 0x316040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
      tindex ezaxi:0xfc4cf980 %l 0x8316050 0x316050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_CLK_ENABLE (at 0x11646)"
      tindex ezaxi:0xfc4cf980 %l 0x8316460 0x316460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_CLK_DIV (at 0x11650)"
      tindex ezaxi:0xfc4cf980 %l 0x8316500 0x316500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_CLK_PHASE (at 0x11651)"
      tindex ezaxi:0xfc4cf980 %l 0x8316510 0x316510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_GANG_CTL1 (at 0x116c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8316c00 0x316c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_GANG_CTL2 (at 0x116c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8316c10 0x316c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_SEC_ACCESS (at 0x116d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8316d00 0x316d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8316d90 0x316d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
      tindex ezaxi:0xfc4cf980 %l 0x8316da0 0x316da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
      tindex ezaxi:0xfc4cf980 %l 0x8316db0 0x316db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S1_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_TEST1 (at 0x116e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8316e20 0x316e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION1 (at 0x11500)"
      tindex ezaxi:0xfc4cf980 %l 0x8315000 0x315000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION2 (at 0x11501)"
      tindex ezaxi:0xfc4cf980 %l 0x8315010 0x315010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION3 (at 0x11502)"
      tindex ezaxi:0xfc4cf980 %l 0x8315020 0x315020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION4 (at 0x11503)"
      tindex ezaxi:0xfc4cf980 %l 0x8315030 0x315030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_TYPE (at 0x11504)"
      tindex ezaxi:0xfc4cf980 %l 0x8315040 0x315040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_SUBTYPE (at 0x11505)"
      tindex ezaxi:0xfc4cf980 %l 0x8315050 0x315050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PWM_CURRENT_LIM_CTL (at 0x1154a)"
      tindex ezaxi:0xfc4cf980 %l 0x83154a0 0x3154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S1_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PFM_CURRENT_LIM_CTL (at 0x1154b)"
      tindex ezaxi:0xfc4cf980 %l 0x83154b0 0x3154b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S1_PS_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_SOFT_START_CTL (at 0x1154c)"
      tindex ezaxi:0xfc4cf980 %l 0x83154c0 0x3154c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
