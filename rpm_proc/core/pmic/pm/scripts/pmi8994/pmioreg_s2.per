      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S1_PS_SWITCH_SIZE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_SWITCH_SIZE_CTL (at 0x11570)"
      tindex ezaxi:0xfc4cf980 %l 0x8315700 0x315700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DEAD_TIME_CTRL1 (at 0x11571)"
      tindex ezaxi:0xfc4cf980 %l 0x8315710 0x315710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DEAD_TIME_CTRL2 (at 0x11572)"
      tindex ezaxi:0xfc4cf980 %l 0x8315720 0x315720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_BLNK_TIME_CTL (at 0x11573)"
      tindex ezaxi:0xfc4cf980 %l 0x8315730 0x315730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S1_PS_INZERO_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_INZERO_CTL (at 0x11574)"
      tindex ezaxi:0xfc4cf980 %l 0x8315740 0x315740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S1_PS_DIG_FSM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DIG_FSM_CTL (at 0x11575)"
      tindex ezaxi:0xfc4cf980 %l 0x8315750 0x315750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PWR_STG_MISC (at 0x11579)"
      tindex ezaxi:0xfc4cf980 %l 0x8315790 0x315790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_SEC_ACCESS (at 0x115d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8315d00 0x315d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8315d90 0x315d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
      tindex ezaxi:0xfc4cf980 %l 0x8315da0 0x315da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
      tindex ezaxi:0xfc4cf980 %l 0x8315db0 0x315db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_PS_FORCE_FET_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_FORCE_FET_TEST (at 0x115e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8315e30 0x315e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S1_PS_PWR_STG_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PWR_STG_TEST (at 0x115e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8315e40 0x315e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_TRIM_NUM (at 0x115f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8315f00 0x315f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PS_TRIM1 (at 0x115f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8315f10 0x315f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PS_TRIM2 (at 0x115f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8315f20 0x315f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION1 (at 0x11700)"
      tindex ezaxi:0xfc4cf980 %l 0x8317000 0x317000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION2 (at 0x11701)"
      tindex ezaxi:0xfc4cf980 %l 0x8317010 0x317010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION3 (at 0x11702)"
      tindex ezaxi:0xfc4cf980 %l 0x8317020 0x317020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION4 (at 0x11703)"
      tindex ezaxi:0xfc4cf980 %l 0x8317030 0x317030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_TYPE (at 0x11704)"
      tindex ezaxi:0xfc4cf980 %l 0x8317040 0x317040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
      tindex ezaxi:0xfc4cf980 %l 0x8317050 0x317050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_1 (at 0x11708)"
      tindex ezaxi:0xfc4cf980 %l 0x8317080 0x317080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_2 (at 0x11709)"
      tindex ezaxi:0xfc4cf980 %l 0x8317090 0x317090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_3 (at 0x1170a)"
      tindex ezaxi:0xfc4cf980 %l 0x83170a0 0x3170a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_4 (at 0x1170b)"
      tindex ezaxi:0xfc4cf980 %l 0x83170b0 0x3170b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S2_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_5 (at 0x1170c)"
      tindex ezaxi:0xfc4cf980 %l 0x83170c0 0x3170c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_RT_STS (at 0x11710)"
      tindex ezaxi:0xfc4cf980 %l 0x8317100 0x317100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_SET_TYPE (at 0x11711)"
      tindex ezaxi:0xfc4cf980 %l 0x8317110 0x317110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
      tindex ezaxi:0xfc4cf980 %l 0x8317120 0x317120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
      tindex ezaxi:0xfc4cf980 %l 0x8317130 0x317130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
      tindex ezaxi:0xfc4cf980 %l 0x8317140 0x317140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_EN_SET (at 0x11715)"
      tindex ezaxi:0xfc4cf980 %l 0x8317150 0x317150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_EN_CLR (at 0x11716)"
      tindex ezaxi:0xfc4cf980 %l 0x8317160 0x317160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
      tindex ezaxi:0xfc4cf980 %l 0x8317180 0x317180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_PENDING_STS (at 0x11719)"
      tindex ezaxi:0xfc4cf980 %l 0x8317190 0x317190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_MID_SEL (at 0x1171a)"
      tindex ezaxi:0xfc4cf980 %l 0x83171a0 0x3171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_PRIORITY (at 0x1171b)"
      tindex ezaxi:0xfc4cf980 %l 0x83171b0 0x3171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VOLTAGE_CTL1 (at 0x11740)"
      tindex ezaxi:0xfc4cf980 %l 0x8317400 0x317400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
      tindex ezaxi:0xfc4cf980 %l 0x8317410 0x317410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VSET_VALID (at 0x11742)"
      tindex ezaxi:0xfc4cf980 %l 0x8317420 0x317420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S2_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MPPFM_VOFFSET (at 0x11744)"
      tindex ezaxi:0xfc4cf980 %l 0x8317440 0x317440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_CTL (at 0x11745)"
      tindex ezaxi:0xfc4cf980 %l 0x8317450 0x317450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S2_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_EN_CTL (at 0x11746)"
      tindex ezaxi:0xfc4cf980 %l 0x8317460 0x317460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S2_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PD_CTL (at 0x11748)"
      tindex ezaxi:0xfc4cf980 %l 0x8317480 0x317480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S2_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_FREQ_CTL (at 0x11750)"
      tindex ezaxi:0xfc4cf980 %l 0x8317500 0x317500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MULTIPHASE_CTL (at 0x11751)"
      tindex ezaxi:0xfc4cf980 %l 0x8317510 0x317510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S2_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PHASE_CTL (at 0x11752)"
      tindex ezaxi:0xfc4cf980 %l 0x8317520 0x317520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PHASE_ID (at 0x11753)"
      tindex ezaxi:0xfc4cf980 %l 0x8317530 0x317530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S2_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PHASE_CNT_MAX (at 0x11754)"
      tindex ezaxi:0xfc4cf980 %l 0x8317540 0x317540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S2_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PH_READY (at 0x11755)"
      tindex ezaxi:0xfc4cf980 %l 0x8317550 0x317550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S2_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_SS_CTL (at 0x11760)"
      tindex ezaxi:0xfc4cf980 %l 0x8317600 0x317600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VS_CTL (at 0x11761)"
      tindex ezaxi:0xfc4cf980 %l 0x8317610 0x317610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CORR_CFG (at 0x11762)"
      tindex ezaxi:0xfc4cf980 %l 0x8317620 0x317620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S2_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_RAMP_CFG (at 0x11763)"
      tindex ezaxi:0xfc4cf980 %l 0x8317630 0x317630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S2_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_COMPENS_CFG (at 0x11764)"
      tindex ezaxi:0xfc4cf980 %l 0x8317640 0x317640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S2_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_VREG_MON (at 0x11765)"
      tindex ezaxi:0xfc4cf980 %l 0x8317650 0x317650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S2_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_VREG_OCP (at 0x11766)"
      tindex ezaxi:0xfc4cf980 %l 0x8317660 0x317660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_PFM_COMP (at 0x11767)"
      tindex ezaxi:0xfc4cf980 %l 0x8317670 0x317670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S2_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_UL_LL_CTL (at 0x11768)"
      tindex ezaxi:0xfc4cf980 %l 0x8317680 0x317680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S2_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VSET_ULS (at 0x11769)"
      tindex ezaxi:0xfc4cf980 %l 0x8317690 0x317690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S2_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_ULS_VALID (at 0x1176a)"
      tindex ezaxi:0xfc4cf980 %l 0x83176a0 0x3176a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S2_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VSET_LLS (at 0x1176b)"
      tindex ezaxi:0xfc4cf980 %l 0x83176b0 0x3176b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S2_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_LLS_VALID (at 0x1176c)"
      tindex ezaxi:0xfc4cf980 %l 0x83176c0 0x3176c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S2_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GPL_HI (at 0x1176d)"
      tindex ezaxi:0xfc4cf980 %l 0x83176d0 0x3176d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S2_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GPL_LO (at 0x1176e)"
      tindex ezaxi:0xfc4cf980 %l 0x83176e0 0x3176e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S2_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_FB_FILT_CFG (at 0x1176f)"
      tindex ezaxi:0xfc4cf980 %l 0x83176f0 0x3176f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S2_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VDIP_CFG (at 0x11771)"
      tindex ezaxi:0xfc4cf980 %l 0x8317710 0x317710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S2_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MPH_STROBE (at 0x11779)"
      tindex ezaxi:0xfc4cf980 %l 0x8317790 0x317790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S2_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_FSM_MASK (at 0x117a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a00 0x317a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S2_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_FSM_WAITS_1 (at 0x117a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a10 0x317a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S2_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_FSM_WAIT_2 (at 0x117a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a20 0x317a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S2_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GATE_DRV_MUX (at 0x117a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a30 0x317a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S2_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CORR_DUTY_MUX (at 0x117a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a40 0x317a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_EN_OPTIONS_DFT_1 (at 0x117a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a50 0x317a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_EN_OPTIONS_DFT_2 (at 0x117a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a60 0x317a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S2_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MPHASE_IDAC (at 0x117a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8317a70 0x317a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S2_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_ANTI_ESL_CFG_1 (at 0x117ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8317ac0 0x317ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_ANTI_ESL_CFG_2 (at 0x117ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8317ad0 0x317ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S2_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST1 (at 0x117b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b00 0x317b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S2_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST2 (at 0x117b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b10 0x317b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S2_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST3 (at 0x117b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b20 0x317b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S2_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST4 (at 0x117b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b30 0x317b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S2_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST1 (at 0x117b4)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b40 0x317b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST2 (at 0x117b5)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b50 0x317b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST3 (at 0x117b6)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b60 0x317b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST4 (at 0x117b7)"
      tindex ezaxi:0xfc4cf980 %l 0x8317b70 0x317b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S2_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GANG_CTL1 (at 0x117c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8317c00 0x317c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GANG_CTL2 (at 0x117c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8317c10 0x317c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_SEC_ACCESS (at 0x117d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8317d00 0x317d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8317d80 0x317d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8317d90 0x317d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
      tindex ezaxi:0xfc4cf980 %l 0x8317da0 0x317da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
      tindex ezaxi:0xfc4cf980 %l 0x8317db0 0x317db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_TEST1 (at 0x117e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8317e00 0x317e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8317e10 0x317e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S2_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CAL_REQUEST (at 0x117e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8317e20 0x317e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S2_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CAL_CTL_1 (at 0x117e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8317e30 0x317e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CAL_CTL_2 (at 0x117e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8317e40 0x317e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MAN_CAL_VAL (at 0x117e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8317e50 0x317e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REFDAC_CAL_VAL (at 0x117ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8317ea0 0x317ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S2_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VDIP_CAL_VAL (at 0x117eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8317eb0 0x317eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_IDAC_CAL_VAL (at 0x117ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8317ec0 0x317ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CORR_CAL_VAL (at 0x117ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8317ed0 0x317ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PWM_CAL_VAL (at 0x117ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8317ee0 0x317ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PFM_CAL_VAL (at 0x117ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8317ef0 0x317ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_TRIM_NUM (at 0x117f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8317f00 0x317f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REFDAC_TRIM (at 0x117f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8317f10 0x317f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S2_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_RAMP_TRIM (at 0x117f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8317f20 0x317f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_REVISION1 (at 0x11900)"
      tindex ezaxi:0xfc4cf980 %l 0x8319000 0x319000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_REVISION2 (at 0x11901)"
      tindex ezaxi:0xfc4cf980 %l 0x8319010 0x319010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_TYPE (at 0x11904)"
      tindex ezaxi:0xfc4cf980 %l 0x8319040 0x319040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
      tindex ezaxi:0xfc4cf980 %l 0x8319050 0x319050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_CLK_ENABLE (at 0x11946)"
      tindex ezaxi:0xfc4cf980 %l 0x8319460 0x319460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_CLK_DIV (at 0x11950)"
      tindex ezaxi:0xfc4cf980 %l 0x8319500 0x319500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_CLK_PHASE (at 0x11951)"
      tindex ezaxi:0xfc4cf980 %l 0x8319510 0x319510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_GANG_CTL1 (at 0x119c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8319c00 0x319c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_GANG_CTL2 (at 0x119c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8319c10 0x319c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_SEC_ACCESS (at 0x119d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8319d00 0x319d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8319d90 0x319d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
      tindex ezaxi:0xfc4cf980 %l 0x8319da0 0x319da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
      tindex ezaxi:0xfc4cf980 %l 0x8319db0 0x319db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S2_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_TEST1 (at 0x119e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8319e20 0x319e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION1 (at 0x11800)"
      tindex ezaxi:0xfc4cf980 %l 0x8318000 0x318000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION2 (at 0x11801)"
      tindex ezaxi:0xfc4cf980 %l 0x8318010 0x318010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION3 (at 0x11802)"
      tindex ezaxi:0xfc4cf980 %l 0x8318020 0x318020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION4 (at 0x11803)"
      tindex ezaxi:0xfc4cf980 %l 0x8318030 0x318030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_TYPE (at 0x11804)"
      tindex ezaxi:0xfc4cf980 %l 0x8318040 0x318040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_SUBTYPE (at 0x11805)"
      tindex ezaxi:0xfc4cf980 %l 0x8318050 0x318050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_STATUS_1 (at 0x11808)"
      tindex ezaxi:0xfc4cf980 %l 0x8318080 0x318080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S2_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_STATUS_2 (at 0x11809)"
      tindex ezaxi:0xfc4cf980 %l 0x8318090 0x318090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S2_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_VOLTAGE_CTL1 (at 0x11840)"
      tindex ezaxi:0xfc4cf980 %l 0x8318400 0x318400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S2_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_VOLTAGE_CTL2 (at 0x11841)"
      tindex ezaxi:0xfc4cf980 %l 0x8318410 0x318410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MODE_CTL (at 0x11845)"
      tindex ezaxi:0xfc4cf980 %l 0x8318450 0x318450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S2_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_FREQ_CTL (at 0x11850)"
      tindex ezaxi:0xfc4cf980 %l 0x8318500 0x318500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MULTIPHASE_CTL (at 0x11851)"
      tindex ezaxi:0xfc4cf980 %l 0x8318510 0x318510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S2_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PHASE_CTL (at 0x11852)"
      tindex ezaxi:0xfc4cf980 %l 0x8318520 0x318520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PHASE_ID (at 0x11853)"
      tindex ezaxi:0xfc4cf980 %l 0x8318530 0x318530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S2_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PHASE_CNT_MAX (at 0x11854)"
      tindex ezaxi:0xfc4cf980 %l 0x8318540 0x318540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S2_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PWM_CL_CTL (at 0x11860)"
      tindex ezaxi:0xfc4cf980 %l 0x8318600 0x318600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S2_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_CL_CTL (at 0x11861)"
      tindex ezaxi:0xfc4cf980 %l 0x8318610 0x318610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S2_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_AUTO_CTL_1 (at 0x11862)"
      tindex ezaxi:0xfc4cf980 %l 0x8318620 0x318620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S2_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_ADC_VAL (at 0x11863)"
      tindex ezaxi:0xfc4cf980 %l 0x8318630 0x318630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S2_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_ADC_CTL (at 0x11864)"
      tindex ezaxi:0xfc4cf980 %l 0x8318640 0x318640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ACTIVITY_DETECT (at 0x11865)"
      tindex ezaxi:0xfc4cf980 %l 0x8318650 0x318650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_CFG (at 0x11868)"
      tindex ezaxi:0xfc4cf980 %l 0x8318680 0x318680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S2_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_FSM_MINON_CFG (at 0x11870)"
      tindex ezaxi:0xfc4cf980 %l 0x8318700 0x318700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S2_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_CAL_CFG (at 0x11873)"
      tindex ezaxi:0xfc4cf980 %l 0x8318730 0x318730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S2_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_NONOVLAP_CFG (at 0x11874)"
      tindex ezaxi:0xfc4cf980 %l 0x8318740 0x318740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S2_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_FRONT_CFG (at 0x11875)"
      tindex ezaxi:0xfc4cf980 %l 0x8318750 0x318750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_P0_LUT_IN (at 0x11878)"
      tindex ezaxi:0xfc4cf980 %l 0x8318780 0x318780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S2_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPH_STROBE (at 0x11879)"
      tindex ezaxi:0xfc4cf980 %l 0x8318790 0x318790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S2_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_OUT (at 0x1187a)"
      tindex ezaxi:0xfc4cf980 %l 0x83187a0 0x3187a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S2_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_OUT (at 0x1187b)"
      tindex ezaxi:0xfc4cf980 %l 0x83187b0 0x3187b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S2_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_FRC (at 0x1187c)"
      tindex ezaxi:0xfc4cf980 %l 0x83187c0 0x3187c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S2_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MP_CORR_DFT (at 0x1187d)"
      tindex ezaxi:0xfc4cf980 %l 0x83187d0 0x3187d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S2_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DAC_DATA (at 0x1187e)"
      tindex ezaxi:0xfc4cf980 %l 0x83187e0 0x3187e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S2_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DAC_FRC (at 0x1187f)"
      tindex ezaxi:0xfc4cf980 %l 0x83187f0 0x3187f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_0 (at 0x11880)"
      tindex ezaxi:0xfc4cf980 %l 0x8318800 0x318800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_1 (at 0x11881)"
      tindex ezaxi:0xfc4cf980 %l 0x8318810 0x318810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_2 (at 0x11882)"
      tindex ezaxi:0xfc4cf980 %l 0x8318820 0x318820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_3 (at 0x11883)"
      tindex ezaxi:0xfc4cf980 %l 0x8318830 0x318830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_ADC_PT_1 (at 0x11887)"
      tindex ezaxi:0xfc4cf980 %l 0x8318870 0x318870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_ADC_PT_2 (at 0x11888)"
      tindex ezaxi:0xfc4cf980 %l 0x8318880 0x318880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_ADC_PT_3 (at 0x11889)"
      tindex ezaxi:0xfc4cf980 %l 0x8318890 0x318890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_HI_0 (at 0x1188c)"
      tindex ezaxi:0xfc4cf980 %l 0x83188c0 0x3188c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_LO_0 (at 0x1188d)"
      tindex ezaxi:0xfc4cf980 %l 0x83188d0 0x3188d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_HI_1 (at 0x1188e)"
      tindex ezaxi:0xfc4cf980 %l 0x83188e0 0x3188e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_LO_1 (at 0x1188f)"
      tindex ezaxi:0xfc4cf980 %l 0x83188f0 0x3188f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_HI_2 (at 0x11890)"
      tindex ezaxi:0xfc4cf980 %l 0x8318900 0x318900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_LO_2 (at 0x11891)"
      tindex ezaxi:0xfc4cf980 %l 0x8318910 0x318910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPHASE_PI_CFG1 (at 0x11896)"
      tindex ezaxi:0xfc4cf980 %l 0x8318960 0x318960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPHASE_PI_CFG4 (at 0x11897)"
      tindex ezaxi:0xfc4cf980 %l 0x8318970 0x318970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S2_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPHASE_PHASE_CNT (at 0x11898)"
      tindex ezaxi:0xfc4cf980 %l 0x8318980 0x318980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_EN_OPTIONS_DFT_1 (at 0x118a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8318a80 0x318a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S2_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_EN_OPTIONS_DFT_2 (at 0x118a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8318a90 0x318a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S2_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_ADAPT_CTL (at 0x118aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8318aa0 0x318aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S2_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_ADAPT_VAL (at 0x118ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8318ab0 0x318ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S2_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_CLK_CTL (at 0x118ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8318ac0 0x318ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S2_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ATEST12 (at 0x118b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8318b00 0x318b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S2_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ATEST34 (at 0x118b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8318b10 0x318b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S2_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DTEST12 (at 0x118b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8318b20 0x318b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S2_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DTEST43 (at 0x118b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8318b30 0x318b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S2_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_GANG_CTL1 (at 0x118c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8318c00 0x318c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_GANG_CTL2 (at 0x118c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8318c10 0x318c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_SEC_ACCESS (at 0x118d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8318d00 0x318d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8318d90 0x318d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
      tindex ezaxi:0xfc4cf980 %l 0x8318da0 0x318da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
      tindex ezaxi:0xfc4cf980 %l 0x8318db0 0x318db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CAL_REQUEST (at 0x118e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8318e20 0x318e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S2_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MAN_CAL_VAL (at 0x118e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8318e50 0x318e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S2_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REPLICA_CFG (at 0x118e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8318e60 0x318e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S2_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CAL_CTL_1 (at 0x118e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8318e70 0x318e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CAL_CTL_2 (at 0x118e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8318e80 0x318e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REPLICA_CAL_VAL (at 0x118ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8318ea0 0x318ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S2_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DACMID_BUF_CAL_VAL (at 0x118ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8318ec0 0x318ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S2_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_FRONT_BUF_CAL_VAL (at 0x118ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8318ed0 0x318ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S2_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CL_CAL_VAL (at 0x118ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8318ee0 0x318ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S2_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_CAL_VAL (at 0x118ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8318ef0 0x318ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S2_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_TRIM_NUM (at 0x118f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8318f00 0x318f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_TRIM (at 0x118f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8318f10 0x318f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S2_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CL_TRIM (at 0x118f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8318f20 0x318f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S2_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REPLICA_TRIM (at 0x118f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8318f30 0x318f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION1 (at 0x11a00)"
      tindex ezaxi:0xfc4cf980 %l 0x831a000 0x31a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION2 (at 0x11a01)"
      tindex ezaxi:0xfc4cf980 %l 0x831a010 0x31a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION3 (at 0x11a02)"
      tindex ezaxi:0xfc4cf980 %l 0x831a020 0x31a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION4 (at 0x11a03)"
      tindex ezaxi:0xfc4cf980 %l 0x831a030 0x31a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_TYPE (at 0x11a04)"
      tindex ezaxi:0xfc4cf980 %l 0x831a040 0x31a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
      tindex ezaxi:0xfc4cf980 %l 0x831a050 0x31a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STATUS_1 (at 0x11a08)"
      tindex ezaxi:0xfc4cf980 %l 0x831a080 0x31a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S3_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STATUS_2 (at 0x11a09)"
      tindex ezaxi:0xfc4cf980 %l 0x831a090 0x31a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S3_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STATUS_3 (at 0x11a0a)"
      tindex ezaxi:0xfc4cf980 %l 0x831a0a0 0x31a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S3_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STATUS_4 (at 0x11a0b)"
      tindex ezaxi:0xfc4cf980 %l 0x831a0b0 0x31a0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S3_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STATUS_5 (at 0x11a0c)"
      tindex ezaxi:0xfc4cf980 %l 0x831a0c0 0x31a0c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_RT_STS (at 0x11a10)"
      tindex ezaxi:0xfc4cf980 %l 0x831a100 0x31a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
      tindex ezaxi:0xfc4cf980 %l 0x831a110 0x31a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
      tindex ezaxi:0xfc4cf980 %l 0x831a120 0x31a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
      tindex ezaxi:0xfc4cf980 %l 0x831a130 0x31a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
      tindex ezaxi:0xfc4cf980 %l 0x831a140 0x31a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_EN_SET (at 0x11a15)"
      tindex ezaxi:0xfc4cf980 %l 0x831a150 0x31a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_EN_CLR (at 0x11a16)"
      tindex ezaxi:0xfc4cf980 %l 0x831a160 0x31a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
      tindex ezaxi:0xfc4cf980 %l 0x831a180 0x31a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
      tindex ezaxi:0xfc4cf980 %l 0x831a190 0x31a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
      tindex ezaxi:0xfc4cf980 %l 0x831a1a0 0x31a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
      tindex ezaxi:0xfc4cf980 %l 0x831a1b0 0x31a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VOLTAGE_CTL1 (at 0x11a40)"
      tindex ezaxi:0xfc4cf980 %l 0x831a400 0x31a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VOLTAGE_CTL2 (at 0x11a41)"
      tindex ezaxi:0xfc4cf980 %l 0x831a410 0x31a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S3_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VSET_VALID (at 0x11a42)"
      tindex ezaxi:0xfc4cf980 %l 0x831a420 0x31a420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S3_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MPPFM_VOFFSET (at 0x11a44)"
      tindex ezaxi:0xfc4cf980 %l 0x831a440 0x31a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S3_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MODE_CTL (at 0x11a45)"
      tindex ezaxi:0xfc4cf980 %l 0x831a450 0x31a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S3_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_EN_CTL (at 0x11a46)"
      tindex ezaxi:0xfc4cf980 %l 0x831a460 0x31a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S3_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PD_CTL (at 0x11a48)"
      tindex ezaxi:0xfc4cf980 %l 0x831a480 0x31a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S3_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_FREQ_CTL (at 0x11a50)"
      tindex ezaxi:0xfc4cf980 %l 0x831a500 0x31a500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S3_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MULTIPHASE_CTL (at 0x11a51)"
      tindex ezaxi:0xfc4cf980 %l 0x831a510 0x31a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S3_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PHASE_CTL (at 0x11a52)"
      tindex ezaxi:0xfc4cf980 %l 0x831a520 0x31a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S3_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PHASE_ID (at 0x11a53)"
      tindex ezaxi:0xfc4cf980 %l 0x831a530 0x31a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S3_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PHASE_CNT_MAX (at 0x11a54)"
      tindex ezaxi:0xfc4cf980 %l 0x831a540 0x31a540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S3_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PH_READY (at 0x11a55)"
      tindex ezaxi:0xfc4cf980 %l 0x831a550 0x31a550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S3_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_SS_CTL (at 0x11a60)"
      tindex ezaxi:0xfc4cf980 %l 0x831a600 0x31a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S3_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VS_CTL (at 0x11a61)"
      tindex ezaxi:0xfc4cf980 %l 0x831a610 0x31a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S3_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CORR_CFG (at 0x11a62)"
      tindex ezaxi:0xfc4cf980 %l 0x831a620 0x31a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S3_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_RAMP_CFG (at 0x11a63)"
      tindex ezaxi:0xfc4cf980 %l 0x831a630 0x31a630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S3_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_COMPENS_CFG (at 0x11a64)"
      tindex ezaxi:0xfc4cf980 %l 0x831a640 0x31a640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S3_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_VREG_MON (at 0x11a65)"
      tindex ezaxi:0xfc4cf980 %l 0x831a650 0x31a650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S3_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_VREG_OCP (at 0x11a66)"
      tindex ezaxi:0xfc4cf980 %l 0x831a660 0x31a660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S3_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_PFM_COMP (at 0x11a67)"
      tindex ezaxi:0xfc4cf980 %l 0x831a670 0x31a670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S3_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_UL_LL_CTL (at 0x11a68)"
      tindex ezaxi:0xfc4cf980 %l 0x831a680 0x31a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S3_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VSET_ULS (at 0x11a69)"
      tindex ezaxi:0xfc4cf980 %l 0x831a690 0x31a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S3_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_ULS_VALID (at 0x11a6a)"
      tindex ezaxi:0xfc4cf980 %l 0x831a6a0 0x31a6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S3_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VSET_LLS (at 0x11a6b)"
      tindex ezaxi:0xfc4cf980 %l 0x831a6b0 0x31a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S3_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_LLS_VALID (at 0x11a6c)"
      tindex ezaxi:0xfc4cf980 %l 0x831a6c0 0x31a6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S3_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_GPL_HI (at 0x11a6d)"
      tindex ezaxi:0xfc4cf980 %l 0x831a6d0 0x31a6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S3_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_GPL_LO (at 0x11a6e)"
      tindex ezaxi:0xfc4cf980 %l 0x831a6e0 0x31a6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S3_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_FB_FILT_CFG (at 0x11a6f)"
      tindex ezaxi:0xfc4cf980 %l 0x831a6f0 0x31a6f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S3_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VDIP_CFG (at 0x11a71)"
      tindex ezaxi:0xfc4cf980 %l 0x831a710 0x31a710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S3_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MPH_STROBE (at 0x11a79)"
      tindex ezaxi:0xfc4cf980 %l 0x831a790 0x31a790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S3_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MODE_FSM_MASK (at 0x11aa0)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa00 0x31aa00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S3_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MODE_FSM_WAITS_1 (at 0x11aa1)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa10 0x31aa10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S3_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MODE_FSM_WAIT_2 (at 0x11aa2)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa20 0x31aa20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S3_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_GATE_DRV_MUX (at 0x11aa3)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa30 0x31aa30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S3_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CORR_DUTY_MUX (at 0x11aa4)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa40 0x31aa40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S3_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_EN_OPTIONS_DFT_1 (at 0x11aa5)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa50 0x31aa50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S3_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_EN_OPTIONS_DFT_2 (at 0x11aa6)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa60 0x31aa60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S3_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MPHASE_IDAC (at 0x11aa7)"
      tindex ezaxi:0xfc4cf980 %l 0x831aa70 0x31aa70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S3_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_ANTI_ESL_CFG_1 (at 0x11aac)"
      tindex ezaxi:0xfc4cf980 %l 0x831aac0 0x31aac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_ANTI_ESL_CFG_2 (at 0x11aad)"
      tindex ezaxi:0xfc4cf980 %l 0x831aad0 0x31aad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S3_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_ATEST1 (at 0x11ab0)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab00 0x31ab00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S3_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_ATEST2 (at 0x11ab1)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab10 0x31ab10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S3_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_ATEST3 (at 0x11ab2)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab20 0x31ab20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S3_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_ATEST4 (at 0x11ab3)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab30 0x31ab30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S3_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_DTEST1 (at 0x11ab4)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab40 0x31ab40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S3_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_DTEST2 (at 0x11ab5)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab50 0x31ab50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S3_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_DTEST3 (at 0x11ab6)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab60 0x31ab60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S3_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CFG_DTEST4 (at 0x11ab7)"
      tindex ezaxi:0xfc4cf980 %l 0x831ab70 0x31ab70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S3_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_GANG_CTL1 (at 0x11ac0)"
      tindex ezaxi:0xfc4cf980 %l 0x831ac00 0x31ac00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_GANG_CTL2 (at 0x11ac1)"
      tindex ezaxi:0xfc4cf980 %l 0x831ac10 0x31ac10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S3_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_SEC_ACCESS (at 0x11ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x831ad00 0x31ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
      tindex ezaxi:0xfc4cf980 %l 0x831ad80 0x31ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x831ad90 0x31ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
      tindex ezaxi:0xfc4cf980 %l 0x831ada0 0x31ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
      tindex ezaxi:0xfc4cf980 %l 0x831adb0 0x31adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_TEST1 (at 0x11ae0)"
      tindex ezaxi:0xfc4cf980 %l 0x831ae00 0x31ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
      tindex ezaxi:0xfc4cf980 %l 0x831ae10 0x31ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S3_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CAL_REQUEST (at 0x11ae2)"
      tindex ezaxi:0xfc4cf980 %l 0x831ae20 0x31ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S3_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CAL_CTL_1 (at 0x11ae3)"
      tindex ezaxi:0xfc4cf980 %l 0x831ae30 0x31ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S3_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CAL_CTL_2 (at 0x11ae4)"
      tindex ezaxi:0xfc4cf980 %l 0x831ae40 0x31ae40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S3_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MAN_CAL_VAL (at 0x11ae5)"
      tindex ezaxi:0xfc4cf980 %l 0x831ae50 0x31ae50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S3_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REFDAC_CAL_VAL (at 0x11aea)"
      tindex ezaxi:0xfc4cf980 %l 0x831aea0 0x31aea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S3_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VDIP_CAL_VAL (at 0x11aeb)"
      tindex ezaxi:0xfc4cf980 %l 0x831aeb0 0x31aeb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S3_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_IDAC_CAL_VAL (at 0x11aec)"
      tindex ezaxi:0xfc4cf980 %l 0x831aec0 0x31aec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S3_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CORR_CAL_VAL (at 0x11aed)"
      tindex ezaxi:0xfc4cf980 %l 0x831aed0 0x31aed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S3_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PWM_CAL_VAL (at 0x11aee)"
      tindex ezaxi:0xfc4cf980 %l 0x831aee0 0x31aee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S3_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PFM_CAL_VAL (at 0x11aef)"
      tindex ezaxi:0xfc4cf980 %l 0x831aef0 0x31aef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_TRIM_NUM (at 0x11af0)"
      tindex ezaxi:0xfc4cf980 %l 0x831af00 0x31af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S3_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REFDAC_TRIM (at 0x11af1)"
      tindex ezaxi:0xfc4cf980 %l 0x831af10 0x31af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S3_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_RAMP_TRIM (at 0x11af2)"
      tindex ezaxi:0xfc4cf980 %l 0x831af20 0x31af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_REVISION1 (at 0x11c00)"
      tindex ezaxi:0xfc4cf980 %l 0x831c000 0x31c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_REVISION2 (at 0x11c01)"
      tindex ezaxi:0xfc4cf980 %l 0x831c010 0x31c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_TYPE (at 0x11c04)"
      tindex ezaxi:0xfc4cf980 %l 0x831c040 0x31c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
      tindex ezaxi:0xfc4cf980 %l 0x831c050 0x31c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_CLK_ENABLE (at 0x11c46)"
      tindex ezaxi:0xfc4cf980 %l 0x831c460 0x31c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_CLK_DIV (at 0x11c50)"
      tindex ezaxi:0xfc4cf980 %l 0x831c500 0x31c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_CLK_PHASE (at 0x11c51)"
      tindex ezaxi:0xfc4cf980 %l 0x831c510 0x31c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
      tindex ezaxi:0xfc4cf980 %l 0x831cc00 0x31cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
      tindex ezaxi:0xfc4cf980 %l 0x831cc10 0x31cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x831cd00 0x31cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x831cd90 0x31cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
      tindex ezaxi:0xfc4cf980 %l 0x831cda0 0x31cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x831cdb0 0x31cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S3_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_TEST1 (at 0x11ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x831ce20 0x31ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION1 (at 0x11b00)"
      tindex ezaxi:0xfc4cf980 %l 0x831b000 0x31b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION2 (at 0x11b01)"
      tindex ezaxi:0xfc4cf980 %l 0x831b010 0x31b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION3 (at 0x11b02)"
      tindex ezaxi:0xfc4cf980 %l 0x831b020 0x31b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION4 (at 0x11b03)"
      tindex ezaxi:0xfc4cf980 %l 0x831b030 0x31b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_TYPE (at 0x11b04)"
      tindex ezaxi:0xfc4cf980 %l 0x831b040 0x31b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
      tindex ezaxi:0xfc4cf980 %l 0x831b050 0x31b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_STATUS_1 (at 0x11b08)"
      tindex ezaxi:0xfc4cf980 %l 0x831b080 0x31b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S3_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_STATUS_2 (at 0x11b09)"
      tindex ezaxi:0xfc4cf980 %l 0x831b090 0x31b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S3_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_VOLTAGE_CTL1 (at 0x11b40)"
      tindex ezaxi:0xfc4cf980 %l 0x831b400 0x31b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S3_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_VOLTAGE_CTL2 (at 0x11b41)"
      tindex ezaxi:0xfc4cf980 %l 0x831b410 0x31b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S3_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MODE_CTL (at 0x11b45)"
      tindex ezaxi:0xfc4cf980 %l 0x831b450 0x31b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S3_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_FREQ_CTL (at 0x11b50)"
      tindex ezaxi:0xfc4cf980 %l 0x831b500 0x31b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S3_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MULTIPHASE_CTL (at 0x11b51)"
      tindex ezaxi:0xfc4cf980 %l 0x831b510 0x31b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S3_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PHASE_CTL (at 0x11b52)"
      tindex ezaxi:0xfc4cf980 %l 0x831b520 0x31b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S3_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PHASE_ID (at 0x11b53)"
      tindex ezaxi:0xfc4cf980 %l 0x831b530 0x31b530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S3_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PHASE_CNT_MAX (at 0x11b54)"
      tindex ezaxi:0xfc4cf980 %l 0x831b540 0x31b540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S3_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PWM_CL_CTL (at 0x11b60)"
      tindex ezaxi:0xfc4cf980 %l 0x831b600 0x31b600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S3_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LPM_CL_CTL (at 0x11b61)"
      tindex ezaxi:0xfc4cf980 %l 0x831b610 0x31b610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S3_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_AUTO_CTL_1 (at 0x11b62)"
      tindex ezaxi:0xfc4cf980 %l 0x831b620 0x31b620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S3_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LPM_ADC_VAL (at 0x11b63)"
      tindex ezaxi:0xfc4cf980 %l 0x831b630 0x31b630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S3_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LPM_ADC_CTL (at 0x11b64)"
      tindex ezaxi:0xfc4cf980 %l 0x831b640 0x31b640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S3_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ACTIVITY_DETECT (at 0x11b65)"
      tindex ezaxi:0xfc4cf980 %l 0x831b650 0x31b650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S3_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LPM_CFG (at 0x11b68)"
      tindex ezaxi:0xfc4cf980 %l 0x831b680 0x31b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S3_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_FSM_MINON_CFG (at 0x11b70)"
      tindex ezaxi:0xfc4cf980 %l 0x831b700 0x31b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S3_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ZX_CAL_CFG (at 0x11b73)"
      tindex ezaxi:0xfc4cf980 %l 0x831b730 0x31b730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S3_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_NONOVLAP_CFG (at 0x11b74)"
      tindex ezaxi:0xfc4cf980 %l 0x831b740 0x31b740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S3_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ADC_FRONT_CFG (at 0x11b75)"
      tindex ezaxi:0xfc4cf980 %l 0x831b750 0x31b750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_P0_LUT_IN (at 0x11b78)"
      tindex ezaxi:0xfc4cf980 %l 0x831b780 0x31b780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S3_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MPH_STROBE (at 0x11b79)"
      tindex ezaxi:0xfc4cf980 %l 0x831b790 0x31b790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S3_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_OUT (at 0x11b7a)"
      tindex ezaxi:0xfc4cf980 %l 0x831b7a0 0x31b7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S3_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ADC_OUT (at 0x11b7b)"
      tindex ezaxi:0xfc4cf980 %l 0x831b7b0 0x31b7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S3_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ADC_FRC (at 0x11b7c)"
      tindex ezaxi:0xfc4cf980 %l 0x831b7c0 0x31b7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S3_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MP_CORR_DFT (at 0x11b7d)"
      tindex ezaxi:0xfc4cf980 %l 0x831b7d0 0x31b7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S3_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DAC_DATA (at 0x11b7e)"
      tindex ezaxi:0xfc4cf980 %l 0x831b7e0 0x31b7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S3_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DAC_FRC (at 0x11b7f)"
      tindex ezaxi:0xfc4cf980 %l 0x831b7f0 0x31b7f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S3_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_DAC_PT_0 (at 0x11b80)"
      tindex ezaxi:0xfc4cf980 %l 0x831b800 0x31b800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S3_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_DAC_PT_1 (at 0x11b81)"
      tindex ezaxi:0xfc4cf980 %l 0x831b810 0x31b810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S3_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_DAC_PT_2 (at 0x11b82)"
      tindex ezaxi:0xfc4cf980 %l 0x831b820 0x31b820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S3_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_DAC_PT_3 (at 0x11b83)"
      tindex ezaxi:0xfc4cf980 %l 0x831b830 0x31b830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S3_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_ADC_PT_1 (at 0x11b87)"
      tindex ezaxi:0xfc4cf980 %l 0x831b870 0x31b870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S3_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_ADC_PT_2 (at 0x11b88)"
      tindex ezaxi:0xfc4cf980 %l 0x831b880 0x31b880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S3_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_ADC_PT_3 (at 0x11b89)"
      tindex ezaxi:0xfc4cf980 %l 0x831b890 0x31b890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S3_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_SLOPE_HI_0 (at 0x11b8c)"
      tindex ezaxi:0xfc4cf980 %l 0x831b8c0 0x31b8c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S3_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_SLOPE_LO_0 (at 0x11b8d)"
      tindex ezaxi:0xfc4cf980 %l 0x831b8d0 0x31b8d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S3_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_SLOPE_HI_1 (at 0x11b8e)"
      tindex ezaxi:0xfc4cf980 %l 0x831b8e0 0x31b8e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S3_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_SLOPE_LO_1 (at 0x11b8f)"
      tindex ezaxi:0xfc4cf980 %l 0x831b8f0 0x31b8f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S3_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_SLOPE_HI_2 (at 0x11b90)"
      tindex ezaxi:0xfc4cf980 %l 0x831b900 0x31b900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S3_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_LUT_SLOPE_LO_2 (at 0x11b91)"
      tindex ezaxi:0xfc4cf980 %l 0x831b910 0x31b910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S3_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MPHASE_PI_CFG1 (at 0x11b96)"
      tindex ezaxi:0xfc4cf980 %l 0x831b960 0x31b960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S3_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MPHASE_PI_CFG4 (at 0x11b97)"
      tindex ezaxi:0xfc4cf980 %l 0x831b970 0x31b970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S3_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MPHASE_PHASE_CNT (at 0x11b98)"
      tindex ezaxi:0xfc4cf980 %l 0x831b980 0x31b980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S3_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_EN_OPTIONS_DFT_1 (at 0x11ba8)"
      tindex ezaxi:0xfc4cf980 %l 0x831ba80 0x31ba80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S3_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_EN_OPTIONS_DFT_2 (at 0x11ba9)"
      tindex ezaxi:0xfc4cf980 %l 0x831ba90 0x31ba90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S3_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ZX_ADAPT_CTL (at 0x11baa)"
      tindex ezaxi:0xfc4cf980 %l 0x831baa0 0x31baa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S3_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ZX_ADAPT_VAL (at 0x11bab)"
      tindex ezaxi:0xfc4cf980 %l 0x831bab0 0x31bab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S3_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ADC_CLK_CTL (at 0x11bac)"
      tindex ezaxi:0xfc4cf980 %l 0x831bac0 0x31bac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S3_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ATEST12 (at 0x11bb0)"
      tindex ezaxi:0xfc4cf980 %l 0x831bb00 0x31bb00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S3_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ATEST34 (at 0x11bb1)"
      tindex ezaxi:0xfc4cf980 %l 0x831bb10 0x31bb10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S3_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DTEST12 (at 0x11bb2)"
      tindex ezaxi:0xfc4cf980 %l 0x831bb20 0x31bb20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S3_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DTEST43 (at 0x11bb3)"
      tindex ezaxi:0xfc4cf980 %l 0x831bb30 0x31bb30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S3_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_GANG_CTL1 (at 0x11bc0)"
      tindex ezaxi:0xfc4cf980 %l 0x831bc00 0x31bc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_GANG_CTL2 (at 0x11bc1)"
      tindex ezaxi:0xfc4cf980 %l 0x831bc10 0x31bc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S3_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_SEC_ACCESS (at 0x11bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x831bd00 0x31bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x831bd90 0x31bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
      tindex ezaxi:0xfc4cf980 %l 0x831bda0 0x31bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x831bdb0 0x31bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S3_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_CAL_REQUEST (at 0x11be2)"
      tindex ezaxi:0xfc4cf980 %l 0x831be20 0x31be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S3_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_MAN_CAL_VAL (at 0x11be5)"
      tindex ezaxi:0xfc4cf980 %l 0x831be50 0x31be50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S3_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REPLICA_CFG (at 0x11be6)"
      tindex ezaxi:0xfc4cf980 %l 0x831be60 0x31be60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S3_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_CAL_CTL_1 (at 0x11be7)"
      tindex ezaxi:0xfc4cf980 %l 0x831be70 0x31be70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S3_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_CAL_CTL_2 (at 0x11be8)"
      tindex ezaxi:0xfc4cf980 %l 0x831be80 0x31be80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S3_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REPLICA_CAL_VAL (at 0x11bea)"
      tindex ezaxi:0xfc4cf980 %l 0x831bea0 0x31bea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S3_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DACMID_BUF_CAL_VAL (at 0x11bec)"
      tindex ezaxi:0xfc4cf980 %l 0x831bec0 0x31bec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S3_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_FRONT_BUF_CAL_VAL (at 0x11bed)"
      tindex ezaxi:0xfc4cf980 %l 0x831bed0 0x31bed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S3_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_CL_CAL_VAL (at 0x11bee)"
      tindex ezaxi:0xfc4cf980 %l 0x831bee0 0x31bee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S3_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ZX_CAL_VAL (at 0x11bef)"
      tindex ezaxi:0xfc4cf980 %l 0x831bef0 0x31bef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S3_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_TRIM_NUM (at 0x11bf0)"
      tindex ezaxi:0xfc4cf980 %l 0x831bf00 0x31bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S3_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_ZX_TRIM (at 0x11bf1)"
      tindex ezaxi:0xfc4cf980 %l 0x831bf10 0x31bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S3_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_CL_TRIM (at 0x11bf2)"
      tindex ezaxi:0xfc4cf980 %l 0x831bf20 0x31bf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S3_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REPLICA_TRIM (at 0x11bf3)"
      tindex ezaxi:0xfc4cf980 %l 0x831bf30 0x31bf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "SMBCHG_BAT_IF"
  tree "SMBCHG_BAT_IF"
    tree "SMBCHG_BAT_IF_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_PERPH_TYPE (at 0x1204)"
      tindex ezaxi:0xfc4cf980 %l 0x8212040 0x212040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_BAT_IF_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_PERPH_SUBTYPE (at 0x1205)"
      tindex ezaxi:0xfc4cf980 %l 0x8212050 0x212050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_BAT_IF_BAT_PRES_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_BAT_PRES_STATUS (at 0x1208)"
      tindex ezaxi:0xfc4cf980 %l 0x8212080 0x212080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_PRES                                 = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_RT_STS (at 0x1210)"
      tindex ezaxi:0xfc4cf980 %l 0x8212100 0x212100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_RT_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_RT_STS                  = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_SET_TYPE (at 0x1211)"
      tindex ezaxi:0xfc4cf980 %l 0x8212110 0x212110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_TYPE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_TYPE                    = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_POLARITY_HIGH (at 0x1212)"
      tindex ezaxi:0xfc4cf980 %l 0x8212120 0x212120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_HIGH                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_HIGH                    = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_POLARITY_LOW (at 0x1213)"
      tindex ezaxi:0xfc4cf980 %l 0x8212130 0x212130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LOW                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LOW                     = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_LATCHED_CLR (at 0x1214)"
      tindex ezaxi:0xfc4cf980 %l 0x8212140 0x212140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_EN_SET (at 0x1215)"
      tindex ezaxi:0xfc4cf980 %l 0x8212150 0x212150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_EN_SET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_EN_SET                  = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_EN_CLR (at 0x1216)"
      tindex ezaxi:0xfc4cf980 %l 0x8212160 0x212160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_EN_CLR                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_EN_CLR                  = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_LATCHED_STS (at 0x1218)"
      tindex ezaxi:0xfc4cf980 %l 0x8212180 0x212180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LATCHED_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LATCHED_STS             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_PENDING_STS (at 0x1219)"
      tindex ezaxi:0xfc4cf980 %l 0x8212190 0x212190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_PENDING_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_PENDNG_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_PENDING_STS             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_MID_SEL (at 0x121a)"
      tindex ezaxi:0xfc4cf980 %l 0x82121a0 0x2121a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_PRIORITY (at 0x121b)"
      tindex ezaxi:0xfc4cf980 %l 0x82121b0 0x2121b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_SHIP_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_SHIP_MODE (at 0x1240)"
      tindex ezaxi:0xfc4cf980 %l 0x8212400 0x212400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SHIP_MODE_ENB                            = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_CLR_DEAD_BAT_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_CLR_DEAD_BAT_TIMER (at 0x1241)"
      tindex ezaxi:0xfc4cf980 %l 0x8212410 0x212410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLR_DEAD_BAT_TIMER                       = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_CMD_CHG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_CMD_CHG (at 0x1242)"
      tindex ezaxi:0xfc4cf980 %l 0x8212420 0x212420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WIRELESS_CHG_DIS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   THERM_NTC_I_OVERRIDE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STAT_OUTPUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FC_COM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_BAT_CHG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_EN                                   = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_SEC_ACCESS (at 0x12d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8212d00 0x212d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_BAT_IF_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_PERPH_RESET_CTL2 (at 0x12d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8212d90 0x212d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_PERPH_RESET_CTL3 (at 0x12da)"
      tindex ezaxi:0xfc4cf980 %l 0x8212da0 0x212da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_PERPH_RESET_CTL4 (at 0x12db)"
      tindex ezaxi:0xfc4cf980 %l 0x8212db0 0x212db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_SPARE (at 0x12df)"
      tindex ezaxi:0xfc4cf980 %l 0x8212df0 0x212df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_BAT_IF_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_TEST1 (at 0x12e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8212e00 0x212e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_INT_TEST_VAL (at 0x12e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8212e10 0x212e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_INT_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_INT_VAL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_INT_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_INT_VAL                 = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_TRIM_NUM (at 0x12f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f00 0x212f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_BAT_IF_VBL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_VBL_CFG (at 0x12f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f10 0x212f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOW_BAT_THRESHOLD                        = "
    tree.end
    tree "SMBCHG_BAT_IF_VBL_SEL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_VBL_SEL_CFG (at 0x12f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f20 0x212f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBAT_LOW_STATE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_LOW_SRC                             = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_BM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_BM_CFG (at 0x12f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f30 0x212f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BMD_RMV_CFG                              = " "0 (BMD_RMV_80US),1 (BMD_RMV_160US),2 (BMD_RMV_320US),3 (BMD_RMV_640US)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_FET_CFG                              = " "0 (BATT_FET_NORMAL),1 (BATT_FET_OVERRIDE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_MISSING_INPUT_PLUGIN                 = " "0 (BMA_PLUG_IN_DIS),1 (BMA_PLUG_IN_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_MISSING_2S6_POLLER                   = " "0 (BMA_POLLER_DIS),1 (BMA_POLLER_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISSING_ALGORITHM                    = " "0 (BMA_DIS),1 (BMA_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_MISSING_PIN_SRC                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_CFG_SYSMIN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_CFG_SYSMIN (at 0x12f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f40 0x212f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SYSMIN                               = " "0 (SYSMIN_3P15),1 (SYSMIN_3P45),2 (SYSMIN_3P6),3 (SYSMIN_3P60)"
    tree.end
    tree "SMBCHG_BAT_IF_CFG_SYSTH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_CFG_SYSTH (at 0x12f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f50 0x212f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFG_EN_100M                              = " "0 (VSYS_VBATT_TRACK_200MV),1 (VSYS_VBATT_TRACK_100MV)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_SYSTH                                = " "0 (VSYS_VBATT_100MV),1 (VSYS_100MV_200MV)"
    tree.end
    tree "SMBCHG_BAT_IF_SS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_SS_CFG (at 0x12f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f60 0x212f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_NO_SS                                = " "0 (SS_EN),1 (SS_DIS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SS_SEL                               = " "0 (SS_SEL_0),1 (SS_SEL_DIV2),2 (SS_SEL_DIV4),3 (SS_SEL_DIV8)"
    tree.end
    tree "SMBCHG_BAT_IF_TRIM7"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_TRIM7 (at 0x12f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f70 0x212f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   TR_STDBYOSC_TEMP_TRIM                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_TLLS                                 = " "0 (CFG_TLLS_10),1 (CFG_TLLS_5)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFG_CLK2MHZ                              = " "0 (CLK_3MHZ_SEL),1 (CLK_2MHZ_SEL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_EN_FREQFOLD                          = " "0 (FREQ_FOLDBACK_DIS),1 (FREQ_FOLDBACK_EN)"
    tree.end
    tree "SMBCHG_BAT_IF_CFG_BB_CLMP_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_CFG_BB_CLMP_SEL (at 0x12f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f80 0x212f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   TR_STDBYOSC_MAIN_TRIM                    = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_BB_CLMP_SEL                          = " "0 (CFG_BB_CLMP_2P0),1 (CFG_BB_CLMP_2P2),2 (CFG_BB_CLMP_2P4),3 (reserved)"
    tree.end
    tree "SMBCHG_BAT_IF_TRIM9"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_TRIM9 (at 0x12f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8212f90 0x212f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_EN_OS_ZD                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CFG_ENB_SC                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_HI_BW                                = "
    tree.end
    tree "SMBCHG_BAT_IF_ISENSE_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_ISENSE_CFG1 (at 0x12fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8212fa0 0x212fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   ISENSE_DCHG_G                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_DCHG_TEMP                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_BAT_IF_ISENSE_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_ISENSE_CFG2 (at 0x12fb)"
      tindex ezaxi:0xfc4cf980 %l 0x8212fb0 0x212fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   ISENSE_CHG_G                             = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_CHG_TEMP                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_BAT_IF_ZIN_ICL_PT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_ZIN_ICL_PT (at 0x12fc)"
      tindex ezaxi:0xfc4cf980 %l 0x8212fc0 0x212fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ZIN_ICL_PT                               = "
    tree.end
    tree "SMBCHG_BAT_IF_ZIN_ICL_LV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_ZIN_ICL_LV (at 0x12fd)"
      tindex ezaxi:0xfc4cf980 %l 0x8212fd0 0x212fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ZIN_ICL_LV                               = "
    tree.end
    tree "SMBCHG_BAT_IF_ZIN_ICL_HV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_ZIN_ICL_HV (at 0x12fe)"
      tindex ezaxi:0xfc4cf980 %l 0x8212fe0 0x212fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ZIN_ICL_HV                               = "
    tree.end
    tree "SMBCHG_BAT_IF_WI_PWR_TMR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_BAT_IF_WI_PWR_TMR (at 0x12ff)"
      tindex ezaxi:0xfc4cf980 %l 0x8212ff0 0x212ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DIV2_DG_SEL                              = " "0 (DIV2_DG_0US),1 (DIV2_DG_150US),2 (DIV2_DG_250US),3 (DIV2_DG_500US)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WIPWR_IRQ_TMR                            = " "0 (WIPWR_IRQ_TMR_1S),1 (WIPWR_IRQ_TMR_1P5S),2 (WIPWR_IRQ_TMR_2S),3 (WIPWR_IRQ_TMR_2P5S),4 (WIPWR_IRQ_TMR_3S),5 (WIPWR_IRQ_TMR_3P5S),6 (WIPWR_IRQ_TMR_4S),7 (WIPWR_IRQ_TMR_4P5S)"
    tree.end
  tree.end
tree.end
tree "SMBCHG_CHGR"
  tree "SMBCHG_CHGR"
    tree "SMBCHG_CHGR_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_PERPH_TYPE (at 0x1004)"
      tindex ezaxi:0xfc4cf980 %l 0x8210040 0x210040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_CHGR_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_PERPH_SUBTYPE (at 0x1005)"
      tindex ezaxi:0xfc4cf980 %l 0x8210050 0x210050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_CHGR_CHG_OPTION"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CHG_OPTION (at 0x1008)"
      tindex ezaxi:0xfc4cf980 %l 0x8210080 0x210080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN                                      = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_VBAT_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_VBAT_STATUS (at 0x100b)"
      tindex ezaxi:0xfc4cf980 %l 0x82100b0 0x2100b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ABOVE_VBAT_WEAK                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_FV_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_FV_STS (at 0x100c)"
      tindex ezaxi:0xfc4cf980 %l 0x82100c0 0x2100c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_STS                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV_STS                                   = "
    tree.end
    tree "SMBCHG_CHGR_ICHG_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_ICHG_STS (at 0x100d)"
      tindex ezaxi:0xfc4cf980 %l 0x82100d0 0x2100d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   PCC_STS                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FCC_STS                                  = "
    tree.end
    tree "SMBCHG_CHGR_CHGR_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CHGR_STS (at 0x100e)"
      tindex ezaxi:0xfc4cf980 %l 0x82100e0 0x2100e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_I_STS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_FV_COMP_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DONE_STS                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATV_LT_2V                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HOLD_OFF_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CHARGING_STS                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHG_EN                                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_RT_STS (at 0x1010)"
      tindex ezaxi:0xfc4cf980 %l 0x8210100 0x210100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_RT_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_RT_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_RT_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_RT_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_RT_STS                        = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_SET_TYPE (at 0x1011)"
      tindex ezaxi:0xfc4cf980 %l 0x8210110 0x210110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_TYPE             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_TYPE            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_TYPE               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_TYPE                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_POLARITY_HIGH (at 0x1012)"
      tindex ezaxi:0xfc4cf980 %l 0x8210120 0x210120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_HIGH             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_HIGH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_HIGH            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_HIGH               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_HIGH                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_POLARITY_LOW (at 0x1013)"
      tindex ezaxi:0xfc4cf980 %l 0x8210130 0x210130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LOW              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LOW               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LOW             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LOW                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LOW                           = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_LATCHED_CLR (at 0x1014)"
      tindex ezaxi:0xfc4cf980 %l 0x8210140 0x210140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LATCHED_CLR      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LATCHED_CLR       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LATCHED_CLR     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_EN_SET (at 0x1015)"
      tindex ezaxi:0xfc4cf980 %l 0x8210150 0x210150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_EN_SET           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_EN_SET            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_EN_SET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_EN_SET             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_SET                        = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_EN_CLR (at 0x1016)"
      tindex ezaxi:0xfc4cf980 %l 0x8210160 0x210160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_EN_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_EN_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_EN_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_EN_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_CLR                        = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_LATCHED_STS (at 0x1018)"
      tindex ezaxi:0xfc4cf980 %l 0x8210180 0x210180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LATCHED_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LATCHED_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LATCHED_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LATCHED_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_PENDING_STS (at 0x1019)"
      tindex ezaxi:0xfc4cf980 %l 0x8210190 0x210190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_PENDING_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_PENDING_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_PENDING_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_PENDING_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_PENDING_STS                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_MID_SEL (at 0x101a)"
      tindex ezaxi:0xfc4cf980 %l 0x82101a0 0x2101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_CHGR_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_PRIORITY (at 0x101b)"
      tindex ezaxi:0xfc4cf980 %l 0x82101b0 0x2101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_SEC_ACCESS (at 0x10d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8210d00 0x210d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_CHGR_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_PERPH_RESET_CTL2 (at 0x10d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8210d90 0x210d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_PERPH_RESET_CTL3 (at 0x10da)"
      tindex ezaxi:0xfc4cf980 %l 0x8210da0 0x210da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_PERPH_RESET_CTL4 (at 0x10db)"
      tindex ezaxi:0xfc4cf980 %l 0x8210db0 0x210db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_SPARE (at 0x10df)"
      tindex ezaxi:0xfc4cf980 %l 0x8210df0 0x210df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_CHGR_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_TEST1 (at 0x10e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e00 0x210e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_INT_TEST_VAL (at 0x10e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e10 0x210e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_INT_VAL          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_INT_VAL           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_INT_VAL         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_INT_VAL            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_INT_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_INT_VAL                       = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_TEST_MODE1 (at 0x10e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e20 0x210e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_CHG_7_0                               = "
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_TEST_MODE2 (at 0x10e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e30 0x210e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TM_CHG_12_8                              = "
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_TEST_MODE3 (at 0x10e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e40 0x210e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TM_TLOOP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_NGATE                                 = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_TEST_MODE4 (at 0x10e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e50 0x210e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_START_COPY                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_TEST_15_8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_TEST_15_8 (at 0x10e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e60 0x210e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_15_8                                = "
    tree.end
    tree "SMBCHG_CHGR_TEST_7_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_TEST_7_0 (at 0x10e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8210e70 0x210e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_7_0                                 = "
    tree.end
    tree "SMBCHG_CHGR_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_TRIM_NUM (at 0x10f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f00 0x210f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_CHGR_PCC_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_PCC_CFG (at 0x10f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f10 0x210f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PCC                                      = " "0 (PCC_100MA),1 (PCC_150MA),2 (PCC_200MA),3 (PCC_250MA),4 (PCC_550MA),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SMBCHG_CHGR_FCC_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_FCC_CFG (at 0x10f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f20 0x210f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FCC                                      = "
    tree.end
    tree "SMBCHG_CHGR_FCC_CMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_FCC_CMP_CFG (at 0x10f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f30 0x210f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FCC_COMP                                 = " "0 (FCC_COMP_250MA),1 (FCC_COMP_700MA),2 (FCC_COMP_900MA),3 (FCC_COMP_1200MA)"
    tree.end
    tree "SMBCHG_CHGR_FV_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_FV_CFG (at 0x10f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f40 0x210f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV                                       = "
    tree.end
    tree "SMBCHG_CHGR_FV_CMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_FV_CMP_CFG (at 0x10f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f50 0x210f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV_COMP                                  = "
    tree.end
    tree "SMBCHG_CHGR_CFG_AFVC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CFG_AFVC (at 0x10f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f60 0x210f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CHGR_AUTO_FV_COMP                        = " "0 (AUTO_FV_COMP_DIS),1 (AUTO_FV_COMP_EN),2 (reserved),3 (reserved),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SMBCHG_CHGR_CFG_CHG_INHIB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CFG_CHG_INHIB (at 0x10f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f70 0x210f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHGR_INHIBIT_THRESHOLD                   = " "0 (INHIBIT_50MV),1 (INHIBIT_100MV),2 (INHIBIT_200MV),3 (INHIBIT_300MV)"
    tree.end
    tree "SMBCHG_CHGR_CFG_P2F"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CFG_P2F (at 0x10f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f80 0x210f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P2F_CHG_THRESHOLD                        = " "0 (P2F_2P4),1 (P2F_2P6),2 (P2F_2P8),3 (P2F_3P0)"
    tree.end
    tree "SMBCHG_CHGR_CFG_TCC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CFG_TCC (at 0x10f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8210f90 0x210f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CHG_TERM_I                               = " "0 (TERM_ANA_300MA),1 (TERM_ANA_50MA),2 (TERM_ANA_100MA),3 (TERM_ANA_150MA),4 (TERM_ANA_200MA),5 (TERM_ANA_250MA),6 (TERM_ANA_500MA),7 (TERM_ANA_600MA)"
    tree.end
    tree "SMBCHG_CHGR_CCMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CCMP_CFG (at 0x10fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8210fa0 0x210fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMP_MONITOR_ENABLE                      = " "0 (TEMP_MONITOR_DIS),1 (TEMP_MONITOR_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   JEITA_TEMP_HARD_LIMIT                    = " "0 (JEITA_TEMP_HARD_LIMIT_EN),1 (JEITA_TEMP_HARD_LIMIT_DIS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOAD_BAT                                 = " "0 (LOAD_BATT_FV_COMP_DIS),1 (LOAD_BATT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HOT_SL_FV_COMP                           = " "0 (HOT_SOFT_LIMIT_FV_COMP_DIS),1 (HOT_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_SL_FV_COMP                          = " "0 (COLD_SOFT_LIMIT_FV_COMP_DIS),1 (COLD_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_SL_CHG_I_COMP                        = " "0 (HOT_SOFT_LIMIT_CC_COMP_DIS),1 (HOT_SOFT_LIMIT_CC_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COLD_SL_CHG_I_COMP                       = " "0 (COLD_SOFT_LIMIT_CC_COMP_DIS),1 (COLD_SOFT_LIMIT_CC_COMP_EN)"
    tree.end
    tree "SMBCHG_CHGR_CHGR_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CHGR_CFG1 (at 0x10fb)"
      tindex ezaxi:0xfc4cf980 %l 0x8210fb0 0x210fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SYSOK_INOK_POL                           = " "0 (SYSOK_TABLE),1 (SYSOK_TABLE_N)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   SYSOK_OPTIONS                            = " "0 (INOK_OPT_1),1 (INOK_OPT_2),2 (SYSOK_OPT_A_1),3 (SYSOK_OPT_A_2),4 (SYSOK_OPT_BC_1),5 (SYSOK_OPT_BC_2),6 (CHG_DET_OPT_1),7 (CHG_DET_OPT_2)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EARLY_TERM_STATUS                        = " "0 (EARLY_CURRENT_TERM_DIS),1 (EARLY_CURRENT_TERM_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TERM_I_SRC                               = " "0 (TERM_SRC_ANA),1 (TERM_SRC_FG)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RECHG_THRESHOLD_SRC                      = " "0 (RCHG_SRC_ANA),1 (RCHG_SRC_FG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGING_HOLDOFF                         = " "0 (WAIT_FOR_FG),1 (NO_WAIT_FOR_FG)"
    tree.end
    tree "SMBCHG_CHGR_CHGR_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CHGR_CFG2 (at 0x10fc)"
      tindex ezaxi:0xfc4cf980 %l 0x8210fc0 0x210fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_EN_SRC                               = " "0 (CHG_EN_SRC_CMD),1 (CHG_EN_SRC_PIN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_EN_COMMAND                           = " "0 (CHG_EN_POL_HIGH),1 (CHG_EN_POL_LOW)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   P2F_CHG_TRAN                             = " "0 (PRE_FAST_AUTO),1 (PRE_FAST_CMD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_ECC                               = " "0 (BATT_OV_ENDS_CYCLE_DIS),1 (BATT_OV_ENDS_CYCLE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   I_TERM                                   = " "0 (CURRENT_TERM_EN),1 (CURRENT_TERM_DIS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTO_RECHG                               = " "0 (AUTO_RCHG_EN),1 (AUTO_RCHG_DIS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOLD_OFF_TIMER_CHARGING                  = " "0 (HOLDOFF_TMR_700US),1 (HOLDOFF_TMR_350MS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGER_INHIBIT                          = " "0 (CHG_INHIBIT_DIS),1 (CHG_INHIBIT_EN)"
    tree.end
    tree "SMBCHG_CHGR_SFT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_SFT_CFG (at 0x10fd)"
      tindex ezaxi:0xfc4cf980 %l 0x8210fd0 0x210fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SFT_EN                                   = " "0 (PC_EN_TC_EN),1 (PC_DIS_TC_EN),2 (PC_DIS_TC_DIS),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SFT_TIMEOUT                              = " "0 (TC_TMOUT_192MIN),1 (TC_TMOUT_384MIN),2 (TC_TMOUT_768MIN),3 (TC_TMOUT_1536MIN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRE_CHG_SFT_TIMEOUT                      = " "0 (PC_TMOUT_24MIN),1 (PC_TMOUT_48MIN),2 (PC_TMOUT_96MIN),3 (PC_TMOUT_192MIN)"
    tree.end
    tree "SMBCHG_CHGR_STAT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_STAT_CFG (at 0x10fe)"
      tindex ezaxi:0xfc4cf980 %l 0x8210fe0 0x210fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STAT_PIN_CONFIG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TEMP_CHG_ERROR_BLINKING_EN               = " "0 (STAT_BLINKING_DIS),1 (STAT_BLINKING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STAT_PIN_SRC                             = " "0 (STAT_CHG_STS),1 (STAT_USB_FAIL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STAT_PIN_OUTPUT_POL                      = " "0 (STAT_ACTIVE_LOW),1 (STAT_ACTIVE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAT_PIN_OUTPUT_EN                       = " "0 (STAT_OUTPUT_EN),1 (STAT_OUTPUT_DIS)"
    tree.end
    tree "SMBCHG_CHGR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_CHGR_CFG (at 0x10ff)"
      tindex ezaxi:0xfc4cf980 %l 0x8210ff0 0x210ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_OPTION_PIN_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CFG_VCHG_IIN                             = " "0 (VCHG_BATTERY_CURRENT),1 (VCHG_INPUT_CURRENT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_TAPER_DIS_AFVC                       = " "0 (AFVC_ACTIVE_IN_TAPER),1 (AFVC_DISABLE_IN_TAPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFG_VCHG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_RCHG_LVL                             = " "0 (RCHG_THRESH_100MV),1 (RCHG_THRESH_200MV)"
    tree.end
  tree.end
tree.end
tree "SMBCHG_DC_CHGPTH"
  tree "SMBCHG_DC_CHGPTH"
    tree "SMBCHG_DC_CHGPTH_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_PERPH_TYPE (at 0x1404)"
      tindex ezaxi:0xfc4cf980 %l 0x8214040 0x214040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_PERPH_SUBTYPE (at 0x1405)"
      tindex ezaxi:0xfc4cf980 %l 0x8214050 0x214050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_RT_STS (at 0x1410)"
      tindex ezaxi:0xfc4cf980 %l 0x8214100 0x214100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_RT_STS                           = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_SET_TYPE (at 0x1411)"
      tindex ezaxi:0xfc4cf980 %l 0x8214110 0x214110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_TYPE                             = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_POLARITY_HIGH (at 0x1412)"
      tindex ezaxi:0xfc4cf980 %l 0x8214120 0x214120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_HIGH                             = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_POLARITY_LOW (at 0x1413)"
      tindex ezaxi:0xfc4cf980 %l 0x8214130 0x214130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LOW                              = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_LATCHED_CLR (at 0x1414)"
      tindex ezaxi:0xfc4cf980 %l 0x8214140 0x214140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_EN_SET (at 0x1415)"
      tindex ezaxi:0xfc4cf980 %l 0x8214150 0x214150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_EN_SET                           = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_EN_CLR (at 0x1416)"
      tindex ezaxi:0xfc4cf980 %l 0x8214160 0x214160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_EN_CLR                           = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_LATCHED_STS (at 0x1418)"
      tindex ezaxi:0xfc4cf980 %l 0x8214180 0x214180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_PENDING_STS (at 0x1419)"
      tindex ezaxi:0xfc4cf980 %l 0x8214190 0x214190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_PENDING_STS                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_MID_SEL (at 0x141a)"
      tindex ezaxi:0xfc4cf980 %l 0x82141a0 0x2141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_PRIORITY (at 0x141b)"
      tindex ezaxi:0xfc4cf980 %l 0x82141b0 0x2141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_SEC_ACCESS (at 0x14d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8214d00 0x214d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL2 (at 0x14d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8214d90 0x214d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL3 (at 0x14da)"
      tindex ezaxi:0xfc4cf980 %l 0x8214da0 0x214da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL4 (at 0x14db)"
      tindex ezaxi:0xfc4cf980 %l 0x8214db0 0x214db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_SPARE (at 0x14df)"
      tindex ezaxi:0xfc4cf980 %l 0x8214df0 0x214df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_TEST1 (at 0x14e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8214e00 0x214e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_INT_TEST_VAL (at 0x14e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8214e10 0x214e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_INT_VAL                          = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TM_EN_ATEST_DCIN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TM_EN_ATEST_DCIN (at 0x14e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8214e20 0x214e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_EN_ATEST_DCIN                         = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TRIM_NUM (at 0x14f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f00 0x214f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_DCIN_CHGR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_DCIN_CHGR_CFG (at 0x14f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f10 0x214f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADAPTER_ALLOWANCE                        = " "0 (DCIN_ADAPTER_ALLOWANCE_5V),1 (DCIN_ADAPTER_ALLOWANCE_5V_9V),2 (DCIN_ADAPTER_ALLOWANCE_5V_TO_9V),3 (DCIN_ADAPTER_ALLOWANCE_9V),4 (DCIN_ADAPTER_ALLOWANCE_5V_UNREG),5 (DCIN_ADAPTER_ALLOWANCE_5V_9V_UNREG),6 (reserved),7 (reserved)"
    tree.end
    tree "SMBCHG_DC_CHGPTH_DCIN_IL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_DCIN_IL_CFG (at 0x14f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f20 0x214f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CURRENT_LIMIT                            = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_DC_AICL_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_DC_AICL_CFG1 (at 0x14f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f30 0x214f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OV_OPTION                                = " "0 (DC_OV_BLOCK),1 (DC_OV_NO_BLOCK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_9V_ADAPTER_EN                        = " "0 (DC_COLLAPSE_GF_NORMAL),1 (DC_COLLAPSE_GF_6P3)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEB_9V_ADAPTER_SEL                       = " "0 (DC_COLLAPSE_9VGF_20MS20MS),1 (DC_COLLAPSE_9VGF_15US20MS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEB_5V_ADAPTER_SEL                       = " "0 (DC_COLLAPSE_5VGF_20MS20MS),1 (DC_COLLAPSE_5VGF_15US20MS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL                                     = " "0 (DC_AICL_DISABLED),1 (DC_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEB_HV_ADAPTER                           = " "0 (DC_COLLAPSE_HV_FET_ON),1 (DC_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEB_LV_ADAPTER                           = " "0 (DC_COLLAPSE_LV_FET_ON),1 (DC_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SMBCHG_DC_CHGPTH_DC_AICL_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_DC_AICL_CFG2 (at 0x14f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f40 0x214f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DEB_UV                                   = " "0 (DC_UV_GF_20MS20MS),1 (DC_UV_GF_10US10MS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_THRESHOLD_5V_TO_9V                  = " "0 (DC_AICL_6P25_OR_4P25),1 (DC_AICL_6P75_OR_4P40)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AICL_THRESHOLD_5V                        = " "0 (DC_AICL_5V_4P25),1 (DC_AICL_5V_4P40)"
    tree.end
    tree "SMBCHG_DC_CHGPTH_AICL_WL_SEL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_AICL_WL_SEL_CFG (at 0x14f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f50 0x214f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AICL_RESTART_TIMER                       = " "0 (AICL_RESTART_TIMER_45S),1 (AICL_RESTART_TIMER_1P5MS),2 (AICL_RESTART_TIMER_3MS),3 (AICL_RESTART_TIMER_6MS)"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TEMP_COMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TEMP_COMP_CFG (at 0x14f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f60 0x214f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CFG_EN_TLOOP                             = " "0 (CFG_EN_TLOOP_DIS),1 (CFG_EN_TLOOP_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_DIS_TLOOP                            = " "0 (CFG_DIS_TLOOP_EN),1 (CFG_DIS_TLOOP_DIS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CFG_DIS_DIG_TLOOP                        = " "0 (CFG_DIS_DIG_TLOOP),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INT_TEMP_COMP_EN                         = " "0 (INT_TEMP_COMP_EN_DIS),1 (INT_TEMP_COMP_EN_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   INT_TEMP_COMP_SETTING                    = " "0 (INT_TEMP_COMP_SETTING_0),1 (INT_TEMP_COMP_SETTING_15PCT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_TEMP_COMP_CYCLE_TIME                 = " "0 (AINT_TEMP_COMP_CYCLE_TIME_350MS),1 (INT_TEMP_COMP_CYCLE_TIME_700MS),2 (INT_TEMP_COMP_CYCLE_TIME_31P4S),3 (INT_TEMP_COMP_CYCLE_TIME_2P8S)"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM7"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TRIM7 (at 0x14f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f70 0x214f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_80R32B                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_LORAMP                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_LONG_REFRESH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_GAIN1X                                = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TRIM8 (at 0x14f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f80 0x214f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TR_SCTR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   TR_OSC3M                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_OSC2M                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM9"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TRIM9 (at 0x14f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8214f90 0x214f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_DUTY                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TR_ZDTR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_BLTR                                  = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_TEMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TR_TEMP (at 0x14fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8214fa0 0x214fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_TEMP                                  = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM11"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TRIM11 (at 0x14fb)"
      tindex ezaxi:0xfc4cf980 %l 0x8214fb0 0x214fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TR_HICAP_VMODE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_SOFT                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_BT                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_DIS_SSUD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_NEW_TRIM                              = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TRIM12 (at 0x14fc)"
      tindex ezaxi:0xfc4cf980 %l 0x8214fc0 0x214fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_VD                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_VDTHRES                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_DCIN_SNS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TR_DCIN_SNS (at 0x14fd)"
      tindex ezaxi:0xfc4cf980 %l 0x8214fd0 0x214fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_DCIN_SNS                              = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_DCIN_DIVIDER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TR_DCIN_DIVIDER (at 0x14fe)"
      tindex ezaxi:0xfc4cf980 %l 0x8214fe0 0x214fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_DCIN_DIVIDER                          = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_IINOS_DC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_DC_CHGPTH_TR_IINOS_DC (at 0x14ff)"
      tindex ezaxi:0xfc4cf980 %l 0x8214ff0 0x214ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IINOS_DC                              = "
    tree.end
  tree.end
tree.end
tree "SMBCHG_MISC"
  tree "SMBCHG_MISC"
    tree "SMBCHG_MISC_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_REVISION1 (at 0x1600)"
      tindex ezaxi:0xfc4cf980 %l 0x8216000 0x216000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SMBCHG_MISC_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_REVISION2 (at 0x1601)"
      tindex ezaxi:0xfc4cf980 %l 0x8216010 0x216010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SMBCHG_MISC_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_REVISION3 (at 0x1602)"
      tindex ezaxi:0xfc4cf980 %l 0x8216020 0x216020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SMBCHG_MISC_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_REVISION4 (at 0x1603)"
      tindex ezaxi:0xfc4cf980 %l 0x8216030 0x216030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SMBCHG_MISC_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_PERPH_TYPE (at 0x1604)"
      tindex ezaxi:0xfc4cf980 %l 0x8216040 0x216040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_MISC_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_PERPH_SUBTYPE (at 0x1605)"
      tindex ezaxi:0xfc4cf980 %l 0x8216050 0x216050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_MISC_IDEV_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_IDEV_STS (at 0x1608)"
      tindex ezaxi:0xfc4cf980 %l 0x8216080 0x216080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SRC_DETECT_STS                           = "
    tree.end
    tree "SMBCHG_MISC_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_RT_STS (at 0x1610)"
      tindex ezaxi:0xfc4cf980 %l 0x8216100 0x216100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_RT_STS                          = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_SET_TYPE (at 0x1611)"
      tindex ezaxi:0xfc4cf980 %l 0x8216110 0x216110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_TYPE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_TYPE                            = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_POLARITY_HIGH (at 0x1612)"
      tindex ezaxi:0xfc4cf980 %l 0x8216120 0x216120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_HIGH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_HIGH                            = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_POLARITY_LOW (at 0x1613)"
      tindex ezaxi:0xfc4cf980 %l 0x8216130 0x216130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LOW                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LOW                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_LATCHED_CLR (at 0x1614)"
      tindex ezaxi:0xfc4cf980 %l 0x8216140 0x216140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_EN_SET (at 0x1615)"
      tindex ezaxi:0xfc4cf980 %l 0x8216150 0x216150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_EN_SET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_EN_SET                          = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_EN_CLR (at 0x1616)"
      tindex ezaxi:0xfc4cf980 %l 0x8216160 0x216160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_LATCHED_STS (at 0x1618)"
      tindex ezaxi:0xfc4cf980 %l 0x8216180 0x216180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LATCHED_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_PENDING_STS (at 0x1619)"
      tindex ezaxi:0xfc4cf980 %l 0x8216190 0x216190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_PENDING_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_MID_SEL (at 0x161a)"
      tindex ezaxi:0xfc4cf980 %l 0x82161a0 0x2161a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_MISC_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_PRIORITY (at 0x161b)"
      tindex ezaxi:0xfc4cf980 %l 0x82161b0 0x2161b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_WDOG_RST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_WDOG_RST (at 0x1640)"
      tindex ezaxi:0xfc4cf980 %l 0x8216400 0x216400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WDOG_RST                                 = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_AFP_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_AFP_MODE (at 0x1641)"
      tindex ezaxi:0xfc4cf980 %l 0x8216410 0x216410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFP_MODE_ENB                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_GSM_PA_ON_ADJ_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_GSM_PA_ON_ADJ_EN (at 0x1642)"
      tindex ezaxi:0xfc4cf980 %l 0x8216420 0x216420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GSM_PA_ON_ADJ_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_SEC_ACCESS (at 0x16d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8216d00 0x216d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_MISC_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_PERPH_RESET_CTL2 (at 0x16d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8216d90 0x216d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_PERPH_RESET_CTL3 (at 0x16da)"
      tindex ezaxi:0xfc4cf980 %l 0x8216da0 0x216da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_PERPH_RESET_CTL4 (at 0x16db)"
      tindex ezaxi:0xfc4cf980 %l 0x8216db0 0x216db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_SPARE (at 0x16df)"
      tindex ezaxi:0xfc4cf980 %l 0x8216df0 0x216df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_MISC_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_TEST1 (at 0x16e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e00 0x216e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_INT_TEST_VAL (at 0x16e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e10 0x216e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_INT_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_INT_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_INT_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_INT_VAL                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_TEST_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_MODE (at 0x16e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e20 0x216e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TM_IPWR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_CPATH_OS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_OTG_EN_HS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   TM_BB_LOOPS                              = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_DIS_SYSOV                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_TEST_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_EN (at 0x16e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e30 0x216e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TE_IIN_FB                                = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_79_72"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_79_72 (at 0x16e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e40 0x216e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_79_72                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_71_64"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_71_64 (at 0x16e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e50 0x216e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_71_64                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_63_56"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_63_56 (at 0x16e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e60 0x216e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_63_56                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_55_48"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_55_48 (at 0x16e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e70 0x216e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_55_48                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_47_40"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_47_40 (at 0x16e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e80 0x216e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_47_40                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_39_32"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_39_32 (at 0x16e9)"
      tindex ezaxi:0xfc4cf980 %l 0x8216e90 0x216e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_39_32                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_31_24"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_31_24 (at 0x16ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8216ea0 0x216ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_31_24                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_23_16"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_23_16 (at 0x16eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8216eb0 0x216eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_23_16                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_15_8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_15_8 (at 0x16ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8216ec0 0x216ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_15_8                  = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_7_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_7_0 (at 0x16ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8216ed0 0x216ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_7_0                   = "
    tree.end
    tree "SMBCHG_MISC_HVDCP_TST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_HVDCP_TST (at 0x16ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8216ee0 0x216ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HVDCP_TST                                = "
    tree.end
    tree "SMBCHG_MISC_TEST_MODE_STDBYOSC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TEST_MODE_STDBYOSC (at 0x16ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8216ef0 0x216ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TEST_MODE_STDBYOSC                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_MISC_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TRIM_NUM (at 0x16f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f00 0x216f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_MISC_WD_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_WD_CFG (at 0x16f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f10 0x216f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFP_WDOG_ENABLE                          = " "0 (AFP_WDOG_DIS),1 (AFP_WDOG_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   WDOG_TIMEOUT                             = " "0 (WDOG_TMOUT_18S),1 (WDOG_TMOUT_36S),2 (WDOG_TMOUT_72S),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SFT_AFTER_WDOG_IRQ                       = " "0 (TIMER_AFTER_WDOG_12MIN),1 (TIMER_AFTER_WDOG_24MIN),2 (TIMER_AFTER_WDOG_48MIN),3 (TIMER_AFTER_WDOG_96MIN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_IRQ_SFT                             = " "0 (WDOG_IRQ_TIMER_DIS),1 (WDOG_IRQ_TIMER_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_OPTION                              = " "0 (WDOG_AFTER_ACK),1 (WDOG_ALWAYS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_TIMER_EN                            = " "0 (WDOG_DIS),1 (WDOG_EN)"
    tree.end
    tree "SMBCHG_MISC_MISC_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_MISC_CFG (at 0x16f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f20 0x216f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SYSOK_LDO                                = " "0 (SYSOK_LDO_DIS),1 (SYSOK_LDO_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FETDRV                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_NTCVOUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PHY_ON                                   = " "0 (PHY_ON_DIS),1 (PHY_ON_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHG_OK                                   = " "0 (CHG_OK_DIS),1 (CHG_OK_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STANDBY_VCHG                             = " "0 (VCHG_STDBY_DIS),1 (VCHG_STDBY_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GSM_PA_ON_ADJ_SEL                        = " "0 (PA_ON_DIS),1 (PA_ON_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VCHG_PA_ON_SEL                           = " "0 (VCHG_DIS),1 (VCHG_EN)"
    tree.end
    tree "SMBCHG_MISC_CFG_NTC_VOUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_CFG_NTC_VOUT (at 0x16f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f30 0x216f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CFG_NTC_VOUT                             = "
    tree.end
    tree "SMBCHG_MISC_CHGR_TRIM_OPTIONS_16"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_CHGR_TRIM_OPTIONS_16 (at 0x16f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f40 0x216f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   PMI8994_CHARGER_OPTIONS                  = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_STOP_TBIT                           = " "0 (SOFT_STOP_DIS),1 (SOFT_STOP_EN)"
    tree.end
    tree "SMBCHG_MISC_CHGR_TRIM_OPTIONS_15_8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_CHGR_TRIM_OPTIONS_15_8 (at 0x16f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f50 0x216f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AICL_INIT                                = " "0 (AICL_INITIAL_0),1 (AICL_INITIAL_ICL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_ADC                                 = " "0 (AICL_ADC_DIS),1 (AICL_ADC_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_RERUN_AICL                         = " "0 (AICL_USB_RERUN_DIS),1 (AICL_USB_RERUN_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_RERUN_AICL                          = " "0 (AICL_DC_RERUN_DIS),1 (AICL_DC_RERUN_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYSOK_DCIN_SEL                           = " "0 (SYSOK_OPT_B),1 (SYSOK_OPT_C)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PRE_BYPASS_GF_TBIT                       = " "0 (BYPASS_GF_DIS),1 (BYPASS_GF_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STANDBY_OSC_EN                           = " "0 (STDBY_OSC_OVERRIDE_DIS),1 (STDBY_OSC_OVERRIDE_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAIN_OSC_EN                              = " "0 (MAIN_OSC_OVERRIDE_DIS),1 (MAIN_OSC_OVERRIDE_EN)"
    tree.end
    tree "SMBCHG_MISC_CHGR_TRIM_OPTIONS_7_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_CHGR_TRIM_OPTIONS_7_0 (at 0x16f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f60 0x216f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STANDBY_OSC_TRIM                         = " "0 (TAPER_JEITA_EN),1 (TAPER_JEITA_DIS)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TLIM_DIS_TBIT                            = " "0 (TLIM_EN),1 (TLIM_DIS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OV_OPTION_TBIT                           = " "0 (OV_OPT_MID_LOAD),1 (OV_OPT_NO_MID_LOAD),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TBIT_IMP_EN                              = " "0 (INPUT_MISSING_POLLER_DIS),1 (INPUT_MISSING_POLLER_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RLD_DIS_TBIT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_ARB_FIX_TBIT                         = " "0 (RAISE_ARB_THRESHOLD),1 (ARB_THRESHOLD_SEL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DB_TMR_DIS_TBIT                          = " "0 (DEAD_BATT_TIMER_EN),1 (DEAD_BATT_TIMER_DIS)"
    tree.end
    tree "SMBCHG_MISC_TR_IPWR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TR_IPWR1 (at 0x16f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f70 0x216f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IPWR1                                 = "
    tree.end
    tree "SMBCHG_MISC_TR_IPWR2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TR_IPWR2 (at 0x16f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f80 0x216f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IPWR2                                 = "
    tree.end
    tree "SMBCHG_MISC_TRIM9"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TRIM9 (at 0x16f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8216f90 0x216f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_VCHG_IOUT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_VCHG_IIN                              = "
    tree.end
    tree "SMBCHG_MISC_TRIM10"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TRIM10 (at 0x16fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8216fa0 0x216fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_TERM                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_BATLOW                                = "
    tree.end
    tree "SMBCHG_MISC_TRIM11"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TRIM11 (at 0x16fb)"
      tindex ezaxi:0xfc4cf980 %l 0x8216fb0 0x216fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TR_RT                                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TR_1356                                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_IOUT_SCALE                            = "
    tree.end
    tree "SMBCHG_MISC_TRIM12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TRIM12 (at 0x16fc)"
      tindex ezaxi:0xfc4cf980 %l 0x8216fc0 0x216fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IOUTOS                                = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IOUTCS_CHGOS                          = "
    tree.end
    tree "SMBCHG_MISC_TRIM13"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TRIM13 (at 0x16fd)"
      tindex ezaxi:0xfc4cf980 %l 0x8216fd0 0x216fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IOUTCS_OTGOS                          = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IOUTOS_PRECHG                         = "
    tree.end
    tree "SMBCHG_MISC_TRIM14"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_TRIM14 (at 0x16fe)"
      tindex ezaxi:0xfc4cf980 %l 0x8216fe0 0x216fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_FLT_SCALE                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_FLT_OFFSET                            = "
    tree.end
    tree "SMBCHG_MISC_CFG_TEMP_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_MISC_CFG_TEMP_SEL (at 0x16ff)"
      tindex ezaxi:0xfc4cf980 %l 0x8216ff0 0x216ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_TEMP_SEL                             = " "0 (TEMP_LOOP_100DEG),1 (TEMP_LOOP_110DEG),2 (TEMP_LOOP_120DEG),3 (TEMP_LOOP_130DEG)"
    tree.end
  tree.end
tree.end
tree "SMBCHG_OTG"
  tree "SMBCHG_OTG"
    tree "SMBCHG_OTG_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_PERPH_TYPE (at 0x1104)"
      tindex ezaxi:0xfc4cf980 %l 0x8211040 0x211040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_OTG_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_PERPH_SUBTYPE (at 0x1105)"
      tindex ezaxi:0xfc4cf980 %l 0x8211050 0x211050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_OTG_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_SEC_ACCESS (at 0x11d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8211d00 0x211d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_OTG_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_PERPH_RESET_CTL2 (at 0x11d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8211d90 0x211d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_PERPH_RESET_CTL3 (at 0x11da)"
      tindex ezaxi:0xfc4cf980 %l 0x8211da0 0x211da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_PERPH_RESET_CTL4 (at 0x11db)"
      tindex ezaxi:0xfc4cf980 %l 0x8211db0 0x211db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_SPARE (at 0x11df)"
      tindex ezaxi:0xfc4cf980 %l 0x8211df0 0x211df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_OTG_TEST_EN_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_EN_CFG (at 0x11e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e00 0x211e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TESTMODE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEST_INPUT_MUX_ENABLE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_OUTPUT_MUX_ENABLE                   = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_TEST_55_48"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_55_48 (at 0x11e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e10 0x211e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_55_48                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_47_40"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_47_40 (at 0x11e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e20 0x211e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_47_40                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_41_32"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_41_32 (at 0x11e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e30 0x211e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_41_32                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_95_88"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_95_88 (at 0x11e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e40 0x211e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_95_88                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_87_80"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_87_80 (at 0x11e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e50 0x211e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_87_80                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_79_72"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_79_72 (at 0x11e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e60 0x211e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_79_72                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_71_64"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_71_64 (at 0x11e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e70 0x211e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_71_64                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_63_56"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_63_56 (at 0x11e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e80 0x211e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_63_56                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_55_48"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_55_48 (at 0x11e9)"
      tindex ezaxi:0xfc4cf980 %l 0x8211e90 0x211e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_55_48                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_47_40"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_47_40 (at 0x11ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8211ea0 0x211ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_47_40                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_39_32"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_39_32 (at 0x11eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8211eb0 0x211eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_39_32                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_31_24"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_31_24 (at 0x11ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8211ec0 0x211ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_31_24                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_23_16"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_23_16 (at 0x11ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8211ed0 0x211ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_23_16                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_15_8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_15_8 (at 0x11ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8211ee0 0x211ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_15_8                   = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_7_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TEST_INPUT_MUX_IN_7_0 (at 0x11ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8211ef0 0x211ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_7_0                    = "
    tree.end
    tree "SMBCHG_OTG_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TRIM_NUM (at 0x11f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f00 0x211f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_OTG_OTG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_OTG_CFG (at 0x11f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f10 0x211f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HV_OTG_PROTECTION                        = " "0 (HV_OTG_DISABLED),1 (HV_OTG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_PIN_POL                              = " "0 (OTG_PIN_POL_HIGH),1 (OTG_PIN_POL_LOW)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OTG_CTRL                                 = " "0 (reserved),1 (reserved),2 (OTG_CTRL_CMD),3 (OTG_CTRL_AUTO)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OTG_UVLO_SENSOR_SRC                      = " "0 (OTG_UVLO_SENSOR_ANA),1 (reserved),2 (OTG_UVLO_SENSOR_FG),3 (OTG_UVLO_SENSOR_OR)"
    tree.end
    tree "SMBCHG_OTG_CFG_BATTUV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_CFG_BATTUV (at 0x11f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f20 0x211f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_BATTUV                               = " "0 (OTG_BATTUV_2P7),1 (OTG_BATTUV_2P9),2 (OTG_BATTUV_3P1),3 (OTG_BATTUV_3P3)"
    tree.end
    tree "SMBCHG_OTG_OTG_ICFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_OTG_ICFG (at 0x11f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f30 0x211f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OTG_ILIMIT                               = " "0 (OTG_ILIMIT_250MA),1 (OTG_ILIMIT_600MA),2 (OTG_ILIMIT_750MA),3 (OTG_ILIMIT_1000MA)"
    tree.end
    tree "SMBCHG_OTG_TR_ISOTG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_ISOTG (at 0x11f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f40 0x211f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_ISOTG                                 = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_OTG_TR_OTG_SNS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_OTG_SNS (at 0x11f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f50 0x211f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_OTG_SNS                               = "
    tree.end
    tree "SMBCHG_OTG_TRIM6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TRIM6 (at 0x11f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f60 0x211f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_ENB_ZD                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_ENB_SKIP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_EN_FPWM_USB1                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_ENLS_SS                               = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_TR_ISTR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_ISTR (at 0x11f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f70 0x211f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_ISTR                                  = "
    tree.end
    tree "SMBCHG_OTG_CFG_TLOOP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_CFG_TLOOP (at 0x11f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f80 0x211f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_TLOOP                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_OTG_CHG_PBS_TRIG_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_CHG_PBS_TRIG_CONTROL (at 0x11f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8211f90 0x211f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_PBS_TRIG_CONTROL                     = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_PWR_TR (at 0x11fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8211fa0 0x211fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TR                                = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TRB_A"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_PWR_TRB_A (at 0x11fb)"
      tindex ezaxi:0xfc4cf980 %l 0x8211fb0 0x211fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRB_A                             = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TRB_B"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_PWR_TRB_B (at 0x11fc)"
      tindex ezaxi:0xfc4cf980 %l 0x8211fc0 0x211fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRB_B                             = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TRS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_PWR_TRS (at 0x11fd)"
      tindex ezaxi:0xfc4cf980 %l 0x8211fd0 0x211fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRS                               = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TR_BGTR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_TR_PWR_TR_BGTR (at 0x11fe)"
      tindex ezaxi:0xfc4cf980 %l 0x8211fe0 0x211fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TR_BGTR                           = "
    tree.end
    tree "SMBCHG_OTG_LOW_PWR_OPTIONS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_OTG_LOW_PWR_OPTIONS (at 0x11ff)"
      tindex ezaxi:0xfc4cf980 %l 0x8211ff0 0x211ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_PWR_OPTIONS                          = "
    tree.end
  tree.end
tree.end
tree "SMBCHG_USB_CHGPTH"
  tree "SMBCHG_USB_CHGPTH"
    tree "SMBCHG_USB_CHGPTH_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_PERPH_TYPE (at 0x1304)"
      tindex ezaxi:0xfc4cf980 %l 0x8213040 0x213040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_PERPH_SUBTYPE (at 0x1305)"
      tindex ezaxi:0xfc4cf980 %l 0x8213050 0x213050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_ICL_STS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_ICL_STS_1 (at 0x1307)"
      tindex ezaxi:0xfc4cf980 %l 0x8213070 0x213070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_STS                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ICL_STS                                  = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_PWR_PTH_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_PWR_PTH_STS (at 0x1308)"
      tindex ezaxi:0xfc4cf980 %l 0x8213080 0x213080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   POWER_PATH                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_USB_CHGPTH_ICL_STS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_ICL_STS_2 (at 0x1309)"
      tindex ezaxi:0xfc4cf980 %l 0x8213090 0x213090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_STS                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ICL_MODE                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_SUSPEND_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_SUSPEND_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_ACTIVE_PWR_SRC                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_ACTIVE_PWR_SRC                      = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_APSD_DG_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_APSD_DG_STS (at 0x130a)"
      tindex ezaxi:0xfc4cf980 %l 0x82130a0 0x2130a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCD_TIMEOUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCD_GOOD_DG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCD_GOOD_DG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RID_ABC_DG                               = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_RID_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_RID_STS (at 0x130b)"
      tindex ezaxi:0xfc4cf980 %l 0x82130b0 0x2130b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RID_STS                                  = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_HVDCP_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_HVDCP_STS (at 0x130c)"
      tindex ezaxi:0xfc4cf980 %l 0x82130c0 0x2130c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IDEV_HVDCP_SEL_A                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HVDCP_SEL_20V                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HVDCP_SEL_12V                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HVDCP_SEL_9V                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HVDCP_SEL_5V                             = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INPUT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INPUT_STS (at 0x130d)"
      tindex ezaxi:0xfc4cf980 %l 0x82130d0 0x2130d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   USBIN_INPUT_STS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DCIN_INPUT_STS                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBID_VALID_ID_11_8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_USBID_VALID_ID_11_8 (at 0x130e)"
      tindex ezaxi:0xfc4cf980 %l 0x82130e0 0x2130e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   USBID_VALID_ID_11_8                      = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBID_VALID_ID_7_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_USBID_VALID_ID_7_0 (at 0x130f)"
      tindex ezaxi:0xfc4cf980 %l 0x82130f0 0x2130f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USBID_VALID_ID_7_0                       = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_RT_STS (at 0x1310)"
      tindex ezaxi:0xfc4cf980 %l 0x8213100 0x213100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_RT_STS                          = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_SET_TYPE (at 0x1311)"
      tindex ezaxi:0xfc4cf980 %l 0x8213110 0x213110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_TYPE                            = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_POLARITY_HIGH (at 0x1312)"
      tindex ezaxi:0xfc4cf980 %l 0x8213120 0x213120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_HIGH                            = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_POLARITY_LOW (at 0x1313)"
      tindex ezaxi:0xfc4cf980 %l 0x8213130 0x213130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LOW                             = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_LATCHED_CLR (at 0x1314)"
      tindex ezaxi:0xfc4cf980 %l 0x8213140 0x213140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_EN_SET (at 0x1315)"
      tindex ezaxi:0xfc4cf980 %l 0x8213150 0x213150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_EN_SET                          = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_EN_CLR (at 0x1316)"
      tindex ezaxi:0xfc4cf980 %l 0x8213160 0x213160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_LATCHED_STS (at 0x1318)"
      tindex ezaxi:0xfc4cf980 %l 0x8213180 0x213180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_PENDING_STS (at 0x1319)"
      tindex ezaxi:0xfc4cf980 %l 0x8213190 0x213190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_MID_SEL (at 0x131a)"
      tindex ezaxi:0xfc4cf980 %l 0x82131a0 0x2131a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_PRIORITY (at 0x131b)"
      tindex ezaxi:0xfc4cf980 %l 0x82131b0 0x2131b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_CMD_IL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_CMD_IL (at 0x1340)"
      tindex ezaxi:0xfc4cf980 %l 0x8213400 0x213400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_2_SYS_FET_DIS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_SUSPEND                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_SUSPEND                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ICL_OVERRIDE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51_MODE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_MODE_CHG                           = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_IUSB_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_IUSB_MAX (at 0x1344)"
      tindex ezaxi:0xfc4cf980 %l 0x8213440 0x213440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IUSB_MAX                                 = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_ENUM_TIMER_STOP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_ENUM_TIMER_STOP (at 0x134e)"
      tindex ezaxi:0xfc4cf980 %l 0x82134e0 0x2134e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STOP                                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_SEC_ACCESS (at 0x13d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8213d00 0x213d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL2 (at 0x13d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8213d90 0x213d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL3 (at 0x13da)"
      tindex ezaxi:0xfc4cf980 %l 0x8213da0 0x213da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL4 (at 0x13db)"
      tindex ezaxi:0xfc4cf980 %l 0x8213db0 0x213db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_SPARE (at 0x13df)"
      tindex ezaxi:0xfc4cf980 %l 0x8213df0 0x213df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_TEST1 (at 0x13e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8213e00 0x213e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_INT_TEST_VAL (at 0x13e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8213e10 0x213e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_INT_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_INT_VAL                         = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TM_EN_ATEST_USBIN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TM_EN_ATEST_USBIN (at 0x13e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8213e20 0x213e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_EN_ATEST_USBIN                        = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TEST_63_56"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TEST_63_56 (at 0x13e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8213e30 0x213e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_63_56                               = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TEST_23_16"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TEST_23_16 (at 0x13e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8213e40 0x213e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_23_16                               = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TEST_31_24"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TEST_31_24 (at 0x13e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8213e50 0x213e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_31_24                               = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TRIM_NUM (at 0x13f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f00 0x213f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBIN_CHGR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_USBIN_CHGR_CFG (at 0x13f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f10 0x213f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADAPTER_ALLOWANCE                        = " "0 (USBIN_ADAPTER_ALLOWANCE_5V),1 (USBIN_ADAPTER_ALLOWANCE_5V_9V),2 (USBIN_ADAPTER_ALLOWANCE_5V_TO_9V),3 (USBIN_ADAPTER_ALLOWANCE_9V),4 (USBIN_ADAPTER_ALLOWANCE_5V_UNREG),5 (USBIN_ADAPTER_ALLOWANCE_5V_9V_UNREG),6 (reserved),7 (reserved)"
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBIN_IL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_USBIN_IL_CFG (at 0x13f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f20 0x213f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CURRENT_LIMIT                            = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_USB_AICL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_USB_AICL_CFG (at 0x13f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f30 0x213f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OV_OPTION                                = " "0 (USB_OV_BLOCK),1 (USB_OV_NO_BLOCK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_9V_ADAPTER_EN                        = " "0 (USB_COLLAPSE_GF_NORMAL),1 (USB_COLLAPSE_GF_6P3)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEB_9V_ADAPTER_SEL                       = " "0 (USB_COLLAPSE_9VGF_20MS20MS),1 (USB_COLLAPSE_9VGF_15US20MS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEB_5V_ADAPTER_SEL                       = " "0 (USB_COLLAPSE_5VGF_20MS20MS),1 (USB_COLLAPSE_5VGF_15US20MS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL                                     = " "0 (USB_AICL_DISABLED),1 (USB_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEB_HV_ADAPTER                           = " "0 (USB_COLLAPSE_HV_FET_ON),1 (USB_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEB_LV_ADAPTER                           = " "0 (USB_COLLAPSE_LV_FET_ON),1 (USB_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SMBCHG_USB_CHGPTH_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_CFG (at 0x13f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f40 0x213f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CFG_USB3P0_SEL                           = " "0 (USB_2P0_SEL),1 (USB_3P0_SEL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_SUSPEND_SRC                        = " "0 (BATID_UNKNOWN_CHARGE),1 (BATID_UNKNOWN_NO_CHARGE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HVDCP_ADAPTER_SEL                        = " "0 (HVDCP_5V),1 (HVDCP_9V),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HVDCP_EN                                 = " "0 (HVDCP_DISABLE),1 (HVDCP_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB51_COMMAND_POL                        = " "0 (USB51AC_COMMAND1_500),1 (USB51AC_COMMAND1_100)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51AC_CTRL                             = " "0 (USB51_COMMAND_CONTROL),1 (USB51_PIN_CONTROL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB51AC_PIN_CTRL                         = " "0 (USB51AC_TRISTATE),1 (USB51AC_DUALSTATE)"
    tree.end
    tree "SMBCHG_USB_CHGPTH_APSD_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_APSD_CFG (at 0x13f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f50 0x213f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_PRIORITY                           = " "0 (DCIN_PRIORITY),1 (USBIN_PRIORITY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_FAIL_OPTION                          = " "0 (USB_FAIL_NORMAL),1 (USB_FAIL_POK_HV)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCD_ISEL                                 = " "0 (OCD_ISEL_500),1 (OCD_ISEL_HC)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SDP_SUSPEND                              = " "0 (SDP_NORMAL),1 (SDP_SUSPEND)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RID_CLK_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB_RID                                  = " "0 (DCD_DG_TMOUT),1 (DCD_TMOUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTO_SRC_DETECT                          = " "0 (AUTO_SRC_DETECT_DIS),1 (AUTO_SRC_DETECT_EN)"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TRIM6 (at 0x13f6)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f60 0x213f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   TR_SYSON_ILIM                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SYSON_LDO                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_USB100_SNS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TR_USB100_SNS (at 0x13f7)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f70 0x213f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_USB100_SNS                            = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_USB500_SNS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TR_USB500_SNS (at 0x13f8)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f80 0x213f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_USB500_SNS                            = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM9"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TRIM9 (at 0x13f9)"
      tindex ezaxi:0xfc4cf980 %l 0x8213f90 0x213f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IINOS_USBL                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IINOS_USB                             = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_RID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TR_RID (at 0x13fa)"
      tindex ezaxi:0xfc4cf980 %l 0x8213fa0 0x213fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   RID_SEL_CFG                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_RID                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM11"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TRIM11 (at 0x13fb)"
      tindex ezaxi:0xfc4cf980 %l 0x8213fb0 0x213fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SYSON_CFG                                = " "0 (SYSON_OTG_BATT),1 (SYSON_OTG_BATT_USBMID),2 (SYSON_OTG_USBMID),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TR_DPDM_PUP                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_DPLUS                                 = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_NEAL6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_NEAL6 (at 0x13fc)"
      tindex ezaxi:0xfc4cf980 %l 0x8213fc0 0x213fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_IIN_OPT                               = " "0 (EN_IIN_BUF_SS_DONE),1 (EN_IIN_BUF_SYSON_LDO)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OC_OPT                                   = " "0 (VSYS_SHORT_DIS),1 (VSYS_SHORT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYSON_OPT                                = " "0 (SYSON_LDO_DEFAULT),1 (SYSON_LDO_INPUT_FET_ON)"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_USBIN_DIVIDER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TR_USBIN_DIVIDER (at 0x13fd)"
      tindex ezaxi:0xfc4cf980 %l 0x8213fd0 0x213fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_USBIN_DIVIDER                         = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_8OR32B"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_TR_8OR32B (at 0x13fe)"
      tindex ezaxi:0xfc4cf980 %l 0x8213fe0 0x213fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   TR_ISENSE_LOW_CURR                       = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_8OR32B                                = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_WI_PWR_OPTIONS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SMBCHG_USB_CHGPTH_WI_PWR_OPTIONS (at 0x13ff)"
      tindex ezaxi:0xfc4cf980 %l 0x8213ff0 0x213ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BUCK_HOLDOFF_ENABLE                      = " "0 (WIPWR_BUCK_HOLDOFF_DIS),1 (WIPWR_BUCK_HOLDOFF_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHG_OK_HW_SW_SELECT                      = " "0 (CHG_OK_SW),1 (CHG_OK_HW)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_RST_ENABLE                         = " "0 (WIPWR_RST_DIS),1 (WIPWR_RST_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_WIPWR_IRQ_SELECT                    = " "0 (DCIN_IRQ_SEL),1 (WIPWR_IRQ_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_SWITCH_ENABLE                       = " "0 (WIPWR_AICL_SWITCH_DIS),1 (WIPWR_AICL_SWITCH_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZIN_ICL_ENABLE                           = " "0 (ICL_CHARGER_REGS),1 (ICL_WIPWR_REGS)"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION1 (at 0x600)"
      tindex ezaxi:0xfc4cf980 %l 0x8206000 0x206000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION2 (at 0x601)"
      tindex ezaxi:0xfc4cf980 %l 0x8206010 0x206010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION3 (at 0x602)"
      tindex ezaxi:0xfc4cf980 %l 0x8206020 0x206020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION4 (at 0x603)"
      tindex ezaxi:0xfc4cf980 %l 0x8206030 0x206030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_TYPE (at 0x604)"
      tindex ezaxi:0xfc4cf980 %l 0x8206040 0x206040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_SUBTYPE (at 0x605)"
      tindex ezaxi:0xfc4cf980 %l 0x8206050 0x206050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_SYNDROME (at 0x608)"
      tindex ezaxi:0xfc4cf980 %l 0x8206080 0x206080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_DATA (at 0x60b)"
      tindex ezaxi:0xfc4cf980 %l 0x82060b0 0x2060b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_ADDR_LO (at 0x60c)"
      tindex ezaxi:0xfc4cf980 %l 0x82060c0 0x2060c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_ADDR_MD (at 0x60d)"
      tindex ezaxi:0xfc4cf980 %l 0x82060d0 0x2060d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_ADDR_HI (at 0x60e)"
      tindex ezaxi:0xfc4cf980 %l 0x82060e0 0x2060e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_RT_STS (at 0x610)"
      tindex ezaxi:0xfc4cf980 %l 0x8206100 0x206100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_SET_TYPE (at 0x611)"
      tindex ezaxi:0xfc4cf980 %l 0x8206110 0x206110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_POLARITY_HIGH (at 0x612)"
      tindex ezaxi:0xfc4cf980 %l 0x8206120 0x206120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_POLARITY_LOW (at 0x613)"
      tindex ezaxi:0xfc4cf980 %l 0x8206130 0x206130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_LATCHED_CLR (at 0x614)"
      tindex ezaxi:0xfc4cf980 %l 0x8206140 0x206140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_EN_SET (at 0x615)"
      tindex ezaxi:0xfc4cf980 %l 0x8206150 0x206150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_EN_CLR (at 0x616)"
      tindex ezaxi:0xfc4cf980 %l 0x8206160 0x206160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_LATCHED_STS (at 0x618)"
      tindex ezaxi:0xfc4cf980 %l 0x8206180 0x206180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_PENDING_STS (at 0x619)"
      tindex ezaxi:0xfc4cf980 %l 0x8206190 0x206190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_MID_SEL (at 0x61a)"
      tindex ezaxi:0xfc4cf980 %l 0x82061a0 0x2061a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_PRIORITY (at 0x61b)"
      tindex ezaxi:0xfc4cf980 %l 0x82061b0 0x2061b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_SPMI_BUF_CFG (at 0x640)"
      tindex ezaxi:0xfc4cf980 %l 0x8206400 0x206400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_SSC_DETECT_CFG (at 0x641)"
      tindex ezaxi:0xfc4cf980 %l 0x8206410 0x206410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_SEC_ACCESS (at 0x6d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8206d00 0x206d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8206d90 0x206d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
      tindex ezaxi:0xfc4cf980 %l 0x8206da0 0x206da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
      tindex ezaxi:0xfc4cf980 %l 0x8206db0 0x206db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_TEST1 (at 0x6e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8206e00 0x206e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_TEST_VAL (at 0x6e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8206e10 0x206e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_TEST1 (at 0x6e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8206e20 0x206e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
      tindex ezaxi:0xfc4cf980 %l 0x8406430 0x406430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
      tindex ezaxi:0xfc4cf980 %l 0x8406440 0x406440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
      tindex ezaxi:0xfc4cf980 %l 0x8406450 0x406450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
      tindex ezaxi:0xfc4cf980 %l 0x8406460 0x406460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
      tindex ezaxi:0xfc4cf980 %l 0x8406470 0x406470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION1 (at 0xfe00)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe000 0x2fe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION2 (at 0xfe01)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe010 0x2fe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION3 (at 0xfe02)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe020 0x2fe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION4 (at 0xfe03)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe030 0x2fe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_TYPE (at 0xfe04)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe040 0x2fe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_SUBTYPE (at 0xfe05)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe050 0x2fe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe080 0x2fe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_OTP_PROG_STATUS (at 0xfe09)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe090 0x2fe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe0a0 0x2fe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
      tindex ezaxi:0xfc4cf980 %l 0x82fe0b0 0x2fe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_SEC_ACCESS (at 0xfed0)"
      tindex ezaxi:0xfc4cf980 %l 0x82fed00 0x2fed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
      tindex ezaxi:0xfc4cf980 %l 0x82fed90 0x2fed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
      tindex ezaxi:0xfc4cf980 %l 0x82feda0 0x2feda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
      tindex ezaxi:0xfc4cf980 %l 0x82fedb0 0x2fedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
      tindex ezaxi:0xfc4cf980 %l 0x82fee00 0x2fee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
      tindex ezaxi:0xfc4cf980 %l 0x82fee10 0x2fee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
      tindex ezaxi:0xfc4cf980 %l 0x82fee20 0x2fee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
      tindex ezaxi:0xfc4cf980 %l 0x82fee30 0x2fee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
      tindex ezaxi:0xfc4cf980 %l 0x82fee40 0x2fee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TEST1 (at 0xfee5)"
      tindex ezaxi:0xfc4cf980 %l 0x82fee50 0x2fee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
      tindex ezaxi:0xfc4cf980 %l 0x82fee60 0x2fee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end
tree "TRI_LED"
  tree "TRI_LED"
    tree "TRI_LED_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_REVISION1 (at 0x1d000)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0000 0x3d0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRI_LED_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_REVISION2 (at 0x1d001)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0010 0x3d0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRI_LED_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_REVISION3 (at 0x1d002)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0020 0x3d0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRI_LED_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_REVISION4 (at 0x1d003)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0030 0x3d0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRI_LED_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_PERPH_TYPE (at 0x1d004)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0040 0x3d0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRI_LED_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_PERPH_SUBTYPE (at 0x1d005)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0050 0x3d0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRI_LED_DROPOUT_DET_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_DROPOUT_DET_STATUS (at 0x1d008)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0080 0x3d0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DROPOUT_DET_R                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DROPOUT_DET_G                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_B                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
    tree.end
    tree "TRI_LED_DROPOUT_DET_STATUS_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_DROPOUT_DET_STATUS_CLR (at 0x1d009)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0090 0x3d0090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STATUS_CLR                               = " "0 (NO_CLR),1 (CLR_STS)"
    tree.end
    tree "TRI_LED_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_RT_STS (at 0x1d010)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0100 0x3d0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_RT_STS                       = " "0, 1"
    tree.end
    tree "TRI_LED_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_SET_TYPE (at 0x1d011)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0110 0x3d0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TRI_LED_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_POLARITY_HIGH (at 0x1d012)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0120 0x3d0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TRI_LED_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_POLARITY_LOW (at 0x1d013)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0130 0x3d0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TRI_LED_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_LATCHED_CLR (at 0x1d014)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0140 0x3d0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "TRI_LED_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_EN_SET (at 0x1d015)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0150 0x3d0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TRI_LED_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_EN_CLR (at 0x1d016)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0160 0x3d0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TRI_LED_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_LATCHED_STS (at 0x1d018)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0180 0x3d0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TRI_LED_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_PENDING_STS (at 0x1d019)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0190 0x3d0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TRI_LED_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_MID_SEL (at 0x1d01a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d01a0 0x3d01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TRI_LED_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_PRIORITY (at 0x1d01b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d01b0 0x3d01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "TRI_LED_LED_SRC_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_LED_SRC_SEL (at 0x1d045)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0450 0x3d0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED_SRC_SEL                              = " "0 (SRC_GND),1 (SRC_VINRGB_VBOOST),2 (reserved),3 (SRC_4P2V)"
    tree.end
    tree "TRI_LED_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_EN_CTL (at 0x1d046)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0460 0x3d0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RED_EN                                   = " "0 (RED_DIS),1 (RED_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GREEN_EN                                 = " "0 (GREEN_DIS),1 (GREEN_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BLUE_EN                                  = " "0 (BLUE_DIS),1 (BLUE_EN)"
    tree.end
    tree "TRI_LED_EN_CTL_ATC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_EN_CTL_ATC (at 0x1d047)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0470 0x3d0470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RED_ATC_EN                               = " "0 (RED_ATC_DISABLE),1 (RED_ATC_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GREEN_ATC_EN                             = " "0 (GREEN_ATC_DISABLE),1 (GREEN_ATC_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BLUE_ATC_EN                              = " "0 (BLUE_ATC_DISABLE),1 (BLUE_ATC_ENABLE)"
    tree.end
    tree "TRI_LED_DROPOUT_DET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_DROPOUT_DET (at 0x1d050)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0500 0x3d0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DROPOUT_DET                           = " "0 (DET_DIS),1 (DET_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DET_DEBOUNCE                             = " "0 (NO_DEBOUNCE),1 (DEBOUNCE_10US),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   DET_SEL                                  = " "0 (VIN_RGB),1 (RED),2 (GREEN),3 (BLUE)"
    tree.end
    tree "TRI_LED_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_SEC_ACCESS (at 0x1d0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0d00 0x3d0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_PERPH_RESET_CTL1 (at 0x1d0d8)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0d80 0x3d0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_PERPH_RESET_CTL2 (at 0x1d0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0d90 0x3d0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_PERPH_RESET_CTL3 (at 0x1d0da)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0da0 0x3d0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_PERPH_RESET_CTL4 (at 0x1d0db)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0db0 0x3d0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRI_LED_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_TEST1 (at 0x1d0e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0e00 0x3d0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (NO_REPLACE),1 (INV_TEST_VAL)"
    tree.end
    tree "TRI_LED_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_INT_TEST_VAL (at 0x1d0e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0e10 0x3d0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TRI_LED_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_TEST1 (at 0x1d0e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0e20 0x3d0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CLOSE_LOOP_TEST_EN                       = " "0 (CL_TEST_DIS),1 (BLUE),2 (GREEN),3 (RED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OPEN_LOOP_CAL_EN                         = " "0 (OL_CAL_DTEST2_DIS),1 (OL_CAL_DTEST2_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_MODE_EN                            = " "0 (ATEST_DTEST2_DIS),1 (ATEST_DTEST2_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_SEL                                  = " "0 (LPG_PWM),1 (DTEST1)"
    tree.end
    tree "TRI_LED_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_TRIM_NUM (at 0x1d0f0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0f00 0x3d0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TRI_LED_R_8MA_CURRENT_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_R_8MA_CURRENT_TRIM (at 0x1d0f1)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0f10 0x3d0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   R_8MA_CURRENT_TRIM                       = "
    tree.end
    tree "TRI_LED_G_8MA_CURRENT_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_G_8MA_CURRENT_TRIM (at 0x1d0f2)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0f20 0x3d0f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   G_8MA_CURRENT_TRIM                       = "
    tree.end
    tree "TRI_LED_B_8MA_CURRENT_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRI_LED_B_8MA_CURRENT_TRIM (at 0x1d0f3)"
      tindex ezaxi:0xfc4cf980 %l 0x83d0f30 0x3d0f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   B_8MA_CURRENT_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "VADC1_USR"
  tree "VADC1_USR"
    tree "VADC1_USR_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION1 (at 0x3100)"
      tindex ezaxi:0xfc4cf980 %l 0x8231000 0x231000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION2 (at 0x3101)"
      tindex ezaxi:0xfc4cf980 %l 0x8231010 0x231010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC1_USR_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION3 (at 0x3102)"
      tindex ezaxi:0xfc4cf980 %l 0x8231020 0x231020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION4 (at 0x3103)"
      tindex ezaxi:0xfc4cf980 %l 0x8231030 0x231030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC1_USR_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_TYPE (at 0x3104)"
      tindex ezaxi:0xfc4cf980 %l 0x8231040 0x231040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC1_USR_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_SUBTYPE (at 0x3105)"
      tindex ezaxi:0xfc4cf980 %l 0x8231050 0x231050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC1_USR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_STATUS1 (at 0x3108)"
      tindex ezaxi:0xfc4cf980 %l 0x8231080 0x231080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC1_USR_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_STATUS2 (at 0x3109)"
      tindex ezaxi:0xfc4cf980 %l 0x8231090 0x231090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_RT_STS (at 0x3110)"
      tindex ezaxi:0xfc4cf980 %l 0x8231100 0x231100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_SET_TYPE (at 0x3111)"
      tindex ezaxi:0xfc4cf980 %l 0x8231110 0x231110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_POLARITY_HIGH (at 0x3112)"
      tindex ezaxi:0xfc4cf980 %l 0x8231120 0x231120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_POLARITY_LOW (at 0x3113)"
      tindex ezaxi:0xfc4cf980 %l 0x8231130 0x231130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_LATCHED_CLR (at 0x3114)"
      tindex ezaxi:0xfc4cf980 %l 0x8231140 0x231140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC1_USR_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_EN_SET (at 0x3115)"
      tindex ezaxi:0xfc4cf980 %l 0x8231150 0x231150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_EN_CLR (at 0x3116)"
      tindex ezaxi:0xfc4cf980 %l 0x8231160 0x231160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_LATCHED_STS (at 0x3118)"
      tindex ezaxi:0xfc4cf980 %l 0x8231180 0x231180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC1_USR_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_PENDING_STS (at 0x3119)"
      tindex ezaxi:0xfc4cf980 %l 0x8231190 0x231190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC1_USR_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_MID_SEL (at 0x311a)"
      tindex ezaxi:0xfc4cf980 %l 0x82311a0 0x2311a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC1_USR_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_PRIORITY (at 0x311b)"
      tindex ezaxi:0xfc4cf980 %l 0x82311b0 0x2311b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC1_USR_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MODE_CTL (at 0x3140)"
      tindex ezaxi:0xfc4cf980 %l 0x8231400 0x231400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC1_USR_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_EN_CTL1 (at 0x3146)"
      tindex ezaxi:0xfc4cf980 %l 0x8231460 0x231460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC1_USR_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_ADC_CH_SEL_CTL (at 0x3148)"
      tindex ezaxi:0xfc4cf980 %l 0x8231480 0x231480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC1_USR_ADC_DIG_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_ADC_DIG_PARAM (at 0x3150)"
      tindex ezaxi:0xfc4cf980 %l 0x8231500 0x231500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC1_USR_HW_SETTLE_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_HW_SETTLE_DELAY (at 0x3151)"
      tindex ezaxi:0xfc4cf980 %l 0x8231510 0x231510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC1_USR_CONV_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_CONV_REQ (at 0x3152)"
      tindex ezaxi:0xfc4cf980 %l 0x8231520 0x231520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC1_USR_CONV_SEQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_CONV_SEQ_CTL (at 0x3154)"
      tindex ezaxi:0xfc4cf980 %l 0x8231540 0x231540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC1_USR_CONV_SEQ_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_CONV_SEQ_TRIG_CTL (at 0x3155)"
      tindex ezaxi:0xfc4cf980 %l 0x8231550 0x231550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MEAS_INTERVAL_CTL (at 0x3157)"
      tindex ezaxi:0xfc4cf980 %l 0x8231570 0x231570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_OP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MEAS_INTERVAL_OP_CTL (at 0x3159)"
      tindex ezaxi:0xfc4cf980 %l 0x8231590 0x231590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC1_USR_FAST_AVG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_FAST_AVG_CTL (at 0x315a)"
      tindex ezaxi:0xfc4cf980 %l 0x82315a0 0x2315a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC1_USR_FAST_AVG_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_FAST_AVG_EN (at 0x315b)"
      tindex ezaxi:0xfc4cf980 %l 0x82315b0 0x2315b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC1_USR_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_LOW_THR0 (at 0x315c)"
      tindex ezaxi:0xfc4cf980 %l 0x82315c0 0x2315c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC1_USR_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_LOW_THR1 (at 0x315d)"
      tindex ezaxi:0xfc4cf980 %l 0x82315d0 0x2315d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_HIGH_THR0 (at 0x315e)"
      tindex ezaxi:0xfc4cf980 %l 0x82315e0 0x2315e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_HIGH_THR1 (at 0x315f)"
      tindex ezaxi:0xfc4cf980 %l 0x82315f0 0x2315f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC1_USR_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_DATA0 (at 0x3160)"
      tindex ezaxi:0xfc4cf980 %l 0x8231600 0x231600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC1_USR_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_DATA1 (at 0x3161)"
      tindex ezaxi:0xfc4cf980 %l 0x8231610 0x231610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_LOW_THR0 (at 0x3162)"
      tindex ezaxi:0xfc4cf980 %l 0x8231620 0x231620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_LOW_THR1 (at 0x3163)"
      tindex ezaxi:0xfc4cf980 %l 0x8231630 0x231630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC1_USR_MIN_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_DATA0 (at 0x3166)"
      tindex ezaxi:0xfc4cf980 %l 0x8231660 0x231660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC1_USR_MIN_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_DATA1 (at 0x3167)"
      tindex ezaxi:0xfc4cf980 %l 0x8231670 0x231670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC1_USR_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_SEC_ACCESS (at 0x31d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8231d00 0x231d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL1 (at 0x31d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8231d80 0x231d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL2 (at 0x31d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8231d90 0x231d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL3 (at 0x31da)"
      tindex ezaxi:0xfc4cf980 %l 0x8231da0 0x231da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL4 (at 0x31db)"
      tindex ezaxi:0xfc4cf980 %l 0x8231db0 0x231db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_TEST1 (at 0x31e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e00 0x231e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_TEST_VAL (at 0x31e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e10 0x231e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC1_USR_TEST1_ADC_ANA_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST1_ADC_ANA_PARAM (at 0x31e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e20 0x231e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC1_USR_TEST2_ADC_DIG_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST2_ADC_DIG_PARAM (at 0x31e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e30 0x231e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0 (DEM_DISABLED),1 (DEM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0 (DECI_SEL),1 (FILTOUT_15_0),2 (FILTOUT_25_16),3 (DECI_SEL1)"
    tree.end
    tree "VADC1_USR_TEST3_ADC_RSV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST3_ADC_RSV (at 0x31e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e40 0x231e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0 (SINC2_OUTPUT),1 (SINC1_OUTPUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0 (RESET_DIG_FILT_FALSE),1 (RESET_DIG_FILT_TRUE)"
    tree.end
    tree "VADC1_USR_TEST4_ADC_ATEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST4_ADC_ATEST (at 0x31e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e50 0x231e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VOCM_0P60),1 (VOCM_0P65),2 (VOCM_0P70),3 (VOCM_0P75)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0 (ATEST3_DISABLED),1 (VTH_N),2 (VTH_P),3 (VICM),4 (VOCM),5 (VREFN),6 (VREFMID),7 (VREFP)"
    tree.end
    tree "VADC1_USR_TEST5_AMUX_ATEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST5_AMUX_ATEST (at 0x31e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e60 0x231e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_EN                                   = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
    tree.end
    tree "VADC1_USR_TEST6_DTEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST6_DTEST (at 0x31e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8231e70 0x231e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VADC1_USR_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM_NUM (at 0x31f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8231f00 0x231f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC1_USR_TRIM1_ADC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM1_ADC (at 0x31f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8231f10 0x231f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DAC_REF                                  = "
    tree.end
    tree "VADC1_USR_TRIM1_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM1_AMUX (at 0x31f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8231f20 0x231f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRESCALE_167_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM2_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM2_AMUX (at 0x31f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8231f30 0x231f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM4_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM4_AMUX (at 0x31f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8231f40 0x231f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_LOW_OFFSET                           = "
    tree.end
    tree "VADC1_USR_TRIM5_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM5_AMUX (at 0x31f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8231f50 0x231f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_HIGH_OFFSET                          = "
    tree.end
  tree.end
tree.end
tree "WLED1_CTRL"
  tree "WLED1_CTRL"
    tree "WLED1_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_REVISION1 (at 0x1d800)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8000 0x3d8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_REVISION2 (at 0x1d801)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8010 0x3d8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_REVISION3 (at 0x1d802)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8020 0x3d8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_REVISION4 (at 0x1d803)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8030 0x3d8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_PERPH_TYPE (at 0x1d804)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8040 0x3d8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_PERPH_SUBTYPE (at 0x1d805)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8050 0x3d8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_CTRL_FAULT_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_FAULT_STATUS (at 0x1d808)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8080 0x3d8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT                               = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_RT_STS (at 0x1d810)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8100 0x3d8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_RT_STS                        = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_SET_TYPE (at 0x1d811)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8110 0x3d8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TYPE                          = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_POLARITY_HIGH (at 0x1d812)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8120 0x3d8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_HIGH                          = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_POLARITY_LOW (at 0x1d813)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8130 0x3d8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LOW                           = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_LATCHED_CLR (at 0x1d814)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8140 0x3d8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_EN_SET (at 0x1d815)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8150 0x3d8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_SET                        = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_EN_CLR (at 0x1d816)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8160 0x3d8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_LATCHED_STS (at 0x1d818)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8180 0x3d8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_PENDING_STS (at 0x1d819)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8190 0x3d8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_PENDING_STS                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_MID_SEL (at 0x1d81a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d81a0 0x3d81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_PRIORITY (at 0x1d81b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d81b0 0x3d81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "WLED1_CTRL_EN_AMOLED"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_EN_AMOLED (at 0x1d844)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8440 0x3d8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_AMOLED                                = " "0, 1"
    tree.end
    tree "WLED1_CTRL_MODULE_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_MODULE_ENABLE (at 0x1d846)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8460 0x3d8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0, 1"
    tree.end
    tree "WLED1_CTRL_FEEDBACK_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_FEEDBACK_CONTROL (at 0x1d848)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8480 0x3d8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FEEDBACK_CONTROL                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_VREF_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_VREF_CONTROL (at 0x1d849)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8490 0x3d8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_CONTROL                             = "
    tree.end
    tree "WLED1_CTRL_BOOST_MAX_DUTY_CYCLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_BOOST_MAX_DUTY_CYCLE (at 0x1d84b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d84b0 0x3d84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_MAX_DUTY_CYCLE                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_SWITCHING_FREQUENCY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_SWITCHING_FREQUENCY (at 0x1d84c)"
      tindex ezaxi:0xfc4cf980 %l 0x83d84c0 0x3d84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SWITCHING_FREQ                           = "
    tree.end
    tree "WLED1_CTRL_WLED_OVP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_WLED_OVP (at 0x1d84d)"
      tindex ezaxi:0xfc4cf980 %l 0x83d84d0 0x3d84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WLED_OVP                                 = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_WLED_ILIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_WLED_ILIM (at 0x1d84e)"
      tindex ezaxi:0xfc4cf980 %l 0x83d84e0 0x3d84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WLED_ILIM                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SLOPE_COMP_CAP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_SLOPE_COMP_CAP (at 0x1d850)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8500 0x3d8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SLOPE_COMP_ADJ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_SLOPE_COMP_ADJ (at 0x1d851)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8510 0x3d8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SLOPE_COMP_ADJ                           = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_BIAS_GEN_WARMUP_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_BIAS_GEN_WARMUP_DELAY (at 0x1d852)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8520 0x3d8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BIAS_GEN_WARMUP_DELAY                    = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_SOFTSTART_RAMP_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_SOFTSTART_RAMP_DELAY (at 0x1d853)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8530 0x3d8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SOFTSTART_RAMP_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SW_SLEW_RATE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_SW_SLEW_RATE_CONTROL (at 0x1d854)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8540 0x3d8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SW_SLEW_RATE_CONTROL                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_RES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_VLOOP_COMP_RES (at 0x1d855)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8550 0x3d8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_COMP_RES                            = "
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_GM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_VLOOP_COMP_GM (at 0x1d856)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8560 0x3d8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_EA_GM                               = "
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_CAP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_VLOOP_COMP_CAP (at 0x1d857)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8570 0x3d8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_CAP                           = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_HCAP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_VLOOP_COMP_HCAP (at 0x1d858)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8580 0x3d8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_HCAP                          = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_EN_HW_BL_REDN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_EN_HW_BL_REDN (at 0x1d859)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8590 0x3d8590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_HW_BL_REDN                            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_EN_PSM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_EN_PSM (at 0x1d85a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d85a0 0x3d85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PSM                                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PSM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_PSM_CTRL (at 0x1d85b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d85b0 0x3d85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PSM_HYS_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VREF_PSM                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_WLED_PFM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_WLED_PFM (at 0x1d85d)"
      tindex ezaxi:0xfc4cf980 %l 0x83d85d0 0x3d85d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_HYS_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_ILIM                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_TOFF                                 = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_WLED_SHORT_PROTECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_WLED_SHORT_PROTECT (at 0x1d85e)"
      tindex ezaxi:0xfc4cf980 %l 0x83d85e0 0x3d85e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SC                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_DSCHGR                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DBNC_SHORT                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_CTL                                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_SEC_ACCESS (at 0x1d8d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8d00 0x3d8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_PERPH_RESET_CTL1 (at 0x1d8d8)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8d80 0x3d8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_PERPH_RESET_CTL2 (at 0x1d8d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8d90 0x3d8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_PERPH_RESET_CTL3 (at 0x1d8da)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8da0 0x3d8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_PERPH_RESET_CTL4 (at 0x1d8db)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8db0 0x3d8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "WLED1_CTRL_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_SPARE (at 0x1d8df)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8df0 0x3d8df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "WLED1_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_TEST1 (at 0x1d8e0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8e00 0x3d8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_INT_TEST_VAL (at 0x1d8e1)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8e10 0x3d8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_TEST_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TEST_VAL                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_TEST1 (at 0x1d8e2)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8e20 0x3d8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DTEST                                    = "
    tree.end
    tree "WLED1_CTRL_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_TEST2 (at 0x1d8e3)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8e30 0x3d8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST                                    = "
    tree.end
    tree "WLED1_CTRL_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_TEST3 (at 0x1d8e4)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8e40 0x3d8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDSON_TM                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   T_ERRAMP_OUT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVP_EN_MASK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SLOPE_COMP_EN_MASK                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_REF_EN_MASK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIM_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ERRAMP_EN_MASK                           = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_TEST4 (at 0x1d8e5)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8e50 0x3d8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_VREF_UP                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_CLAMP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEBOUNCE_BYPASS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_SLEEP_CLK_REQUEST                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SOFT_START                            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_TRIM_NUM (at 0x1d8f0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8f00 0x3d8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_CTRL_TRIM_ILIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_TRIM_ILIM (at 0x1d8f1)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8f10 0x3d8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_ILIM                                = "
    tree.end
    tree "WLED1_CTRL_REF_7P7_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_REF_7P7_TRIM (at 0x1d8f2)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8f20 0x3d8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REF_7P7_TRIM                             = "
    tree.end
    tree "WLED1_CTRL_WLED_OVP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_WLED_OVP_TRIM (at 0x1d8f3)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8f30 0x3d8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OVP_REF_TRIM                             = "
    tree.end
    tree "WLED1_CTRL_WLED_REF_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_CTRL_WLED_REF_TRIM (at 0x1d8f4)"
      tindex ezaxi:0xfc4cf980 %l 0x83d8f40 0x3d8f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_WLED_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "WLED1_SINK"
  tree "WLED1_SINK"
    tree "WLED1_SINK_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_REVISION1 (at 0x1d900)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9000 0x3d9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_REVISION2 (at 0x1d901)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9010 0x3d9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_REVISION3 (at 0x1d902)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9020 0x3d9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_REVISION4 (at 0x1d903)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9030 0x3d9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_SINK_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_PERPH_TYPE (at 0x1d904)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9040 0x3d9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_SINK_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_PERPH_SUBTYPE (at 0x1d905)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9050 0x3d9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_SINK_CURRENT_SINK_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_CURRENT_SINK_EN (at 0x1d946)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9460 0x3d9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_SINK4                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_CURRENT_SINK3                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_CURRENT_SINK2                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_CURRENT_SINK1                         = " "0, 1"
    tree.end
    tree "WLED1_SINK_ILED_SYNC_BIT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_ILED_SYNC_BIT (at 0x1d947)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9470 0x3d9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYNC_LED4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC_LED3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_LED2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_LED1                                = " "0, 1"
    tree.end
    tree "WLED1_SINK_DIG_DIM_CLK_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_DIG_DIM_CLK_SEL (at 0x1d948)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9480 0x3d9480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIG_DIM_CLK_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_SINK_MODULATION_SCHEME"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_MODULATION_SCHEME (at 0x1d94a)"
      tindex ezaxi:0xfc4cf980 %l 0x83d94a0 0x3d94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   MODULATOR_CLOCK_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PHASE_STAGGERING                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   ACCUMULATOR_CLOCK_SEL                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HYBRID_DIMMING                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INTERNAL_MOD_RESOLUTION                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIMMING_METHOD                           = " "0, 1"
    tree.end
    tree "WLED1_SINK_HYBRID_DIMMING_TRESH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_HYBRID_DIMMING_TRESH (at 0x1d94b)"
      tindex ezaxi:0xfc4cf980 %l 0x83d94b0 0x3d94b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HYBRID_DIM_THRESH                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED1_MODULATOR_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED1_MODULATOR_EN (at 0x1d950)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9500 0x3d9500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_IDAC_SYNC_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED1_IDAC_SYNC_DELAY (at 0x1d951)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9510 0x3d9510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED1_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED1_FULL_SCALE_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED1_FULL_SCALE_CURRENT (at 0x1d952)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9520 0x3d9520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED1_MODULATOR_SRC_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED1_MODULATOR_SRC_SEL (at 0x1d953)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9530 0x3d9530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_CABC_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED1_CABC_EN (at 0x1d956)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9560 0x3d9560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_BRIGHTNESS_SETTING_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED1_BRIGHTNESS_SETTING_LSB (at 0x1d957)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9570 0x3d9570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED1_BRIGHTNESS_SETTING_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED1_BRIGHTNESS_SETTING_MSB (at 0x1d958)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9580 0x3d9580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED2_MODULATOR_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED2_MODULATOR_EN (at 0x1d960)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9600 0x3d9600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_IDAC_SYNC_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED2_IDAC_SYNC_DELAY (at 0x1d961)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9610 0x3d9610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED2_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED2_FULL_SCALE_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED2_FULL_SCALE_CURRENT (at 0x1d962)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9620 0x3d9620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED2_MODULATOR_SRC_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED2_MODULATOR_SRC_SEL (at 0x1d963)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9630 0x3d9630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_CABC_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED2_CABC_EN (at 0x1d966)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9660 0x3d9660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_BRIGHTNESS_SETTING_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED2_BRIGHTNESS_SETTING_LSB (at 0x1d967)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9670 0x3d9670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED2_BRIGHTNESS_SETTING_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED2_BRIGHTNESS_SETTING_MSB (at 0x1d968)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9680 0x3d9680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED3_MODULATOR_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED3_MODULATOR_EN (at 0x1d970)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9700 0x3d9700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_IDAC_SYNC_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED3_IDAC_SYNC_DELAY (at 0x1d971)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9710 0x3d9710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED3_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED3_FULL_SCALE_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED3_FULL_SCALE_CURRENT (at 0x1d972)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9720 0x3d9720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED3_MODULATOR_SRC_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED3_MODULATOR_SRC_SEL (at 0x1d973)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9730 0x3d9730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED3_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_CABC_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED3_CABC_EN (at 0x1d976)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9760 0x3d9760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_BRIGHTNESS_SETTING_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED3_BRIGHTNESS_SETTING_LSB (at 0x1d977)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9770 0x3d9770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED3_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED3_BRIGHTNESS_SETTING_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED3_BRIGHTNESS_SETTING_MSB (at 0x1d978)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9780 0x3d9780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED4_MODULATOR_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED4_MODULATOR_EN (at 0x1d980)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9800 0x3d9800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED4_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_IDAC_SYNC_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED4_IDAC_SYNC_DELAY (at 0x1d981)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9810 0x3d9810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED4_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED4_FULL_SCALE_CURRENT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED4_FULL_SCALE_CURRENT (at 0x1d982)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9820 0x3d9820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED4_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED4_MODULATOR_SRC_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED4_MODULATOR_SRC_SEL (at 0x1d983)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9830 0x3d9830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED4_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_CABC_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED4_CABC_EN (at 0x1d986)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9860 0x3d9860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED4_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_BRIGHTNESS_SETTING_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED4_BRIGHTNESS_SETTING_LSB (at 0x1d987)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9870 0x3d9870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED4_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED4_BRIGHTNESS_SETTING_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_LED4_BRIGHTNESS_SETTING_MSB (at 0x1d988)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9880 0x3d9880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED4_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_SEC_ACCESS (at 0x1d9d0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9d00 0x3d9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_PERPH_RESET_CTL1 (at 0x1d9d8)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9d80 0x3d9d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_PERPH_RESET_CTL2 (at 0x1d9d9)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9d90 0x3d9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_PERPH_RESET_CTL3 (at 0x1d9da)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9da0 0x3d9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_PERPH_RESET_CTL4 (at 0x1d9db)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9db0 0x3d9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "WLED1_SINK_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_SPARE (at 0x1d9df)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9df0 0x3d9df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "WLED1_SINK_TEST5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TEST5 (at 0x1d9e6)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9e60 0x3d9e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CS_TGATE_ATEST                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CS_GATE_DRV_THRESH                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_HVG_PULL_STR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CS_OTA_COMP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CS_FSTON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_FASTOTA                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_MAN_CAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_MAN_CAL_CTL (at 0x1d9e7)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9e70 0x3d9e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAN_CS_OTA_CAL_EN                        = " "0, 1"
    tree.end
    tree "WLED1_SINK_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_NUM (at 0x1d9f0)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f00 0x3d9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_VREF_ILED1 (at 0x1d9f1)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f10 0x3d9f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED1                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_VREF_ILED2 (at 0x1d9f2)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f20 0x3d9f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED2                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_VREF_ILED3 (at 0x1d9f3)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f30 0x3d9f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED3                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_VREF_ILED4 (at 0x1d9f4)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f40 0x3d9f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED4                          = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_OFFSET_ILED1 (at 0x1d9f5)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f50 0x3d9f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED1                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_OFFSET_ILED2 (at 0x1d9f6)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f60 0x3d9f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED2                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_OFFSET_ILED3 (at 0x1d9f7)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f70 0x3d9f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED3                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "WLED1_SINK_TRIM_OFFSET_ILED4 (at 0x1d9f8)"
      tindex ezaxi:0xfc4cf980 %l 0x83d9f80 0x3d9f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED4                        = "
    tree.end
  tree.end
tree.end

