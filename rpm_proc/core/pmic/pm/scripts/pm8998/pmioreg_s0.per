      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S12_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ZX_ADAPT_VAL (at 0x136ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8136ab0 0x136ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S12_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ADC_CLK_CTL (at 0x136ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8136ac0 0x136ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S12_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ATEST12 (at 0x136b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8136b00 0x136b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S12_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ATEST34 (at 0x136b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8136b10 0x136b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S12_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_DTEST12 (at 0x136b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8136b20 0x136b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S12_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_DTEST43 (at 0x136b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8136b30 0x136b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S12_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_GANG_CTL1 (at 0x136c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8136c00 0x136c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S12_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_GANG_CTL2 (at 0x136c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8136c10 0x136c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S12_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_SEC_ACCESS (at 0x136d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8136d00 0x136d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S12_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PERPH_RESET_CTL2 (at 0x136d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8136d90 0x136d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S12_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PERPH_RESET_CTL3 (at 0x136da)"
      tindex ezaxi:0xfc4cf980 %l 0x8136da0 0x136da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S12_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PERPH_RESET_CTL4 (at 0x136db)"
      tindex ezaxi:0xfc4cf980 %l 0x8136db0 0x136db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S12_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_CAL_REQUEST (at 0x136e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8136e20 0x136e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S12_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MAN_CAL_VAL (at 0x136e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8136e50 0x136e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S12_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_REPLICA_CFG (at 0x136e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8136e60 0x136e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S12_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_CAL_CTL_1 (at 0x136e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8136e70 0x136e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S12_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_CAL_CTL_2 (at 0x136e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8136e80 0x136e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S12_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_REPLICA_CAL_VAL (at 0x136ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8136ea0 0x136ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S12_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_DACMID_BUF_CAL_VAL (at 0x136ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8136ec0 0x136ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S12_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_FRONT_BUF_CAL_VAL (at 0x136ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8136ed0 0x136ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S12_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_CL_CAL_VAL (at 0x136ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8136ee0 0x136ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S12_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ZX_CAL_VAL (at 0x136ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8136ef0 0x136ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S12_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_TRIM_NUM (at 0x136f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8136f00 0x136f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S12_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ZX_TRIM (at 0x136f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8136f10 0x136f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S12_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_CL_TRIM (at 0x136f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8136f20 0x136f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S12_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_REPLICA_TRIM (at 0x136f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8136f30 0x136f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION1 (at 0x11400)"
      tindex ezaxi:0xfc4cf980 %l 0x8114000 0x114000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION2 (at 0x11401)"
      tindex ezaxi:0xfc4cf980 %l 0x8114010 0x114010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION3 (at 0x11402)"
      tindex ezaxi:0xfc4cf980 %l 0x8114020 0x114020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REVISION4 (at 0x11403)"
      tindex ezaxi:0xfc4cf980 %l 0x8114030 0x114030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_TYPE (at 0x11404)"
      tindex ezaxi:0xfc4cf980 %l 0x8114040 0x114040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
      tindex ezaxi:0xfc4cf980 %l 0x8114050 0x114050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STATUS_1 (at 0x11408)"
      tindex ezaxi:0xfc4cf980 %l 0x8114080 0x114080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STATUS_2 (at 0x11409)"
      tindex ezaxi:0xfc4cf980 %l 0x8114090 0x114090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STATUS_3 (at 0x1140a)"
      tindex ezaxi:0xfc4cf980 %l 0x81140a0 0x1140a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STATUS_4 (at 0x1140b)"
      tindex ezaxi:0xfc4cf980 %l 0x81140b0 0x1140b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S1_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_STATUS_5 (at 0x1140c)"
      tindex ezaxi:0xfc4cf980 %l 0x81140c0 0x1140c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_RT_STS (at 0x11410)"
      tindex ezaxi:0xfc4cf980 %l 0x8114100 0x114100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_SET_TYPE (at 0x11411)"
      tindex ezaxi:0xfc4cf980 %l 0x8114110 0x114110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
      tindex ezaxi:0xfc4cf980 %l 0x8114120 0x114120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
      tindex ezaxi:0xfc4cf980 %l 0x8114130 0x114130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
      tindex ezaxi:0xfc4cf980 %l 0x8114140 0x114140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_EN_SET (at 0x11415)"
      tindex ezaxi:0xfc4cf980 %l 0x8114150 0x114150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_EN_CLR (at 0x11416)"
      tindex ezaxi:0xfc4cf980 %l 0x8114160 0x114160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
      tindex ezaxi:0xfc4cf980 %l 0x8114180 0x114180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_PENDING_STS (at 0x11419)"
      tindex ezaxi:0xfc4cf980 %l 0x8114190 0x114190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_MID_SEL (at 0x1141a)"
      tindex ezaxi:0xfc4cf980 %l 0x81141a0 0x1141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_PRIORITY (at 0x1141b)"
      tindex ezaxi:0xfc4cf980 %l 0x81141b0 0x1141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VOLTAGE_CTL1 (at 0x11440)"
      tindex ezaxi:0xfc4cf980 %l 0x8114400 0x114400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
      tindex ezaxi:0xfc4cf980 %l 0x8114410 0x114410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S1_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VSET_VALID (at 0x11442)"
      tindex ezaxi:0xfc4cf980 %l 0x8114420 0x114420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S1_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MPPFM_VOFFSET (at 0x11444)"
      tindex ezaxi:0xfc4cf980 %l 0x8114440 0x114440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MODE_CTL (at 0x11445)"
      tindex ezaxi:0xfc4cf980 %l 0x8114450 0x114450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S1_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_EN_CTL (at 0x11446)"
      tindex ezaxi:0xfc4cf980 %l 0x8114460 0x114460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PD_CTL (at 0x11448)"
      tindex ezaxi:0xfc4cf980 %l 0x8114480 0x114480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S1_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_FREQ_CTL (at 0x11450)"
      tindex ezaxi:0xfc4cf980 %l 0x8114500 0x114500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S1_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MULTIPHASE_CTL (at 0x11451)"
      tindex ezaxi:0xfc4cf980 %l 0x8114510 0x114510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S1_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PHASE_CTL (at 0x11452)"
      tindex ezaxi:0xfc4cf980 %l 0x8114520 0x114520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S1_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PHASE_ID (at 0x11453)"
      tindex ezaxi:0xfc4cf980 %l 0x8114530 0x114530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S1_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PHASE_CNT_MAX (at 0x11454)"
      tindex ezaxi:0xfc4cf980 %l 0x8114540 0x114540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S1_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PH_READY (at 0x11455)"
      tindex ezaxi:0xfc4cf980 %l 0x8114550 0x114550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S1_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_SS_CTL (at 0x11460)"
      tindex ezaxi:0xfc4cf980 %l 0x8114600 0x114600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S1_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VS_CTL (at 0x11461)"
      tindex ezaxi:0xfc4cf980 %l 0x8114610 0x114610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S1_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CORR_CFG (at 0x11462)"
      tindex ezaxi:0xfc4cf980 %l 0x8114620 0x114620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S1_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_RAMP_CFG (at 0x11463)"
      tindex ezaxi:0xfc4cf980 %l 0x8114630 0x114630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S1_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_COMPENS_CFG (at 0x11464)"
      tindex ezaxi:0xfc4cf980 %l 0x8114640 0x114640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S1_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_VREG_MON (at 0x11465)"
      tindex ezaxi:0xfc4cf980 %l 0x8114650 0x114650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S1_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_VREG_OCP (at 0x11466)"
      tindex ezaxi:0xfc4cf980 %l 0x8114660 0x114660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S1_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_PFM_COMP (at 0x11467)"
      tindex ezaxi:0xfc4cf980 %l 0x8114670 0x114670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S1_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_UL_LL_CTL (at 0x11468)"
      tindex ezaxi:0xfc4cf980 %l 0x8114680 0x114680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S1_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VSET_ULS (at 0x11469)"
      tindex ezaxi:0xfc4cf980 %l 0x8114690 0x114690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S1_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_ULS_VALID (at 0x1146a)"
      tindex ezaxi:0xfc4cf980 %l 0x81146a0 0x1146a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S1_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VSET_LLS (at 0x1146b)"
      tindex ezaxi:0xfc4cf980 %l 0x81146b0 0x1146b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S1_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_LLS_VALID (at 0x1146c)"
      tindex ezaxi:0xfc4cf980 %l 0x81146c0 0x1146c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S1_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_GPL_HI (at 0x1146d)"
      tindex ezaxi:0xfc4cf980 %l 0x81146d0 0x1146d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S1_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_GPL_LO (at 0x1146e)"
      tindex ezaxi:0xfc4cf980 %l 0x81146e0 0x1146e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S1_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_FB_FILT_CFG (at 0x1146f)"
      tindex ezaxi:0xfc4cf980 %l 0x81146f0 0x1146f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S1_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VDIP_CFG (at 0x11471)"
      tindex ezaxi:0xfc4cf980 %l 0x8114710 0x114710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S1_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MPH_STROBE (at 0x11479)"
      tindex ezaxi:0xfc4cf980 %l 0x8114790 0x114790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S1_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MODE_FSM_MASK (at 0x114a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a00 0x114a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S1_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MODE_FSM_WAITS_1 (at 0x114a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a10 0x114a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S1_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MODE_FSM_WAIT_2 (at 0x114a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a20 0x114a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S1_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_GATE_DRV_MUX (at 0x114a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a30 0x114a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S1_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CORR_DUTY_MUX (at 0x114a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a40 0x114a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S1_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_EN_OPTIONS_DFT_1 (at 0x114a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a50 0x114a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S1_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_EN_OPTIONS_DFT_2 (at 0x114a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a60 0x114a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S1_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MPHASE_IDAC (at 0x114a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8114a70 0x114a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S1_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_ANTI_ESL_CFG_1 (at 0x114ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8114ac0 0x114ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_ANTI_ESL_CFG_2 (at 0x114ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8114ad0 0x114ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S1_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_ATEST1 (at 0x114b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b00 0x114b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S1_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_ATEST2 (at 0x114b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b10 0x114b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S1_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_ATEST3 (at 0x114b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b20 0x114b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S1_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_ATEST4 (at 0x114b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b30 0x114b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S1_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_DTEST1 (at 0x114b4)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b40 0x114b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S1_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_DTEST2 (at 0x114b5)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b50 0x114b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S1_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_DTEST3 (at 0x114b6)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b60 0x114b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S1_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CFG_DTEST4 (at 0x114b7)"
      tindex ezaxi:0xfc4cf980 %l 0x8114b70 0x114b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S1_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_GANG_CTL1 (at 0x114c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8114c00 0x114c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_GANG_CTL2 (at 0x114c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8114c10 0x114c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_SEC_ACCESS (at 0x114d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8114d00 0x114d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8114d80 0x114d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8114d90 0x114d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
      tindex ezaxi:0xfc4cf980 %l 0x8114da0 0x114da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
      tindex ezaxi:0xfc4cf980 %l 0x8114db0 0x114db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_TEST1 (at 0x114e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8114e00 0x114e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8114e10 0x114e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S1_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CAL_REQUEST (at 0x114e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8114e20 0x114e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S1_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CAL_CTL_1 (at 0x114e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8114e30 0x114e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S1_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CAL_CTL_2 (at 0x114e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8114e40 0x114e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S1_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_MAN_CAL_VAL (at 0x114e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8114e50 0x114e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S1_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REFDAC_CAL_VAL (at 0x114ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8114ea0 0x114ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S1_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_VDIP_CAL_VAL (at 0x114eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8114eb0 0x114eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S1_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_IDAC_CAL_VAL (at 0x114ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8114ec0 0x114ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S1_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_CORR_CAL_VAL (at 0x114ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8114ed0 0x114ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S1_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PWM_CAL_VAL (at 0x114ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8114ee0 0x114ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S1_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_PFM_CAL_VAL (at 0x114ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8114ef0 0x114ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_TRIM_NUM (at 0x114f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8114f00 0x114f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S1_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_REFDAC_TRIM (at 0x114f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8114f10 0x114f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S1_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_CTRL_RAMP_TRIM (at 0x114f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8114f20 0x114f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_REVISION1 (at 0x11600)"
      tindex ezaxi:0xfc4cf980 %l 0x8116000 0x116000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_REVISION2 (at 0x11601)"
      tindex ezaxi:0xfc4cf980 %l 0x8116010 0x116010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_TYPE (at 0x11604)"
      tindex ezaxi:0xfc4cf980 %l 0x8116040 0x116040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
      tindex ezaxi:0xfc4cf980 %l 0x8116050 0x116050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_CLK_ENABLE (at 0x11646)"
      tindex ezaxi:0xfc4cf980 %l 0x8116460 0x116460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_CLK_DIV (at 0x11650)"
      tindex ezaxi:0xfc4cf980 %l 0x8116500 0x116500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_CLK_PHASE (at 0x11651)"
      tindex ezaxi:0xfc4cf980 %l 0x8116510 0x116510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_GANG_CTL1 (at 0x116c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8116c00 0x116c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_GANG_CTL2 (at 0x116c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8116c10 0x116c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_SEC_ACCESS (at 0x116d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8116d00 0x116d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8116d90 0x116d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
      tindex ezaxi:0xfc4cf980 %l 0x8116da0 0x116da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
      tindex ezaxi:0xfc4cf980 %l 0x8116db0 0x116db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S1_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_FREQ_TEST1 (at 0x116e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8116e20 0x116e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION1 (at 0x11500)"
      tindex ezaxi:0xfc4cf980 %l 0x8115000 0x115000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION2 (at 0x11501)"
      tindex ezaxi:0xfc4cf980 %l 0x8115010 0x115010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION3 (at 0x11502)"
      tindex ezaxi:0xfc4cf980 %l 0x8115020 0x115020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REVISION4 (at 0x11503)"
      tindex ezaxi:0xfc4cf980 %l 0x8115030 0x115030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_TYPE (at 0x11504)"
      tindex ezaxi:0xfc4cf980 %l 0x8115040 0x115040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_SUBTYPE (at 0x11505)"
      tindex ezaxi:0xfc4cf980 %l 0x8115050 0x115050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_STATUS_1 (at 0x11508)"
      tindex ezaxi:0xfc4cf980 %l 0x8115080 0x115080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S1_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_STATUS_2 (at 0x11509)"
      tindex ezaxi:0xfc4cf980 %l 0x8115090 0x115090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S1_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_VOLTAGE_CTL1 (at 0x11540)"
      tindex ezaxi:0xfc4cf980 %l 0x8115400 0x115400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S1_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_VOLTAGE_CTL2 (at 0x11541)"
      tindex ezaxi:0xfc4cf980 %l 0x8115410 0x115410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S1_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MODE_CTL (at 0x11545)"
      tindex ezaxi:0xfc4cf980 %l 0x8115450 0x115450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S1_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_FREQ_CTL (at 0x11550)"
      tindex ezaxi:0xfc4cf980 %l 0x8115500 0x115500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S1_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MULTIPHASE_CTL (at 0x11551)"
      tindex ezaxi:0xfc4cf980 %l 0x8115510 0x115510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S1_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PHASE_CTL (at 0x11552)"
      tindex ezaxi:0xfc4cf980 %l 0x8115520 0x115520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S1_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PHASE_ID (at 0x11553)"
      tindex ezaxi:0xfc4cf980 %l 0x8115530 0x115530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S1_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PHASE_CNT_MAX (at 0x11554)"
      tindex ezaxi:0xfc4cf980 %l 0x8115540 0x115540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S1_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PWM_CL_CTL (at 0x11560)"
      tindex ezaxi:0xfc4cf980 %l 0x8115600 0x115600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S1_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LPM_CL_CTL (at 0x11561)"
      tindex ezaxi:0xfc4cf980 %l 0x8115610 0x115610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S1_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_AUTO_CTL_1 (at 0x11562)"
      tindex ezaxi:0xfc4cf980 %l 0x8115620 0x115620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S1_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LPM_ADC_VAL (at 0x11563)"
      tindex ezaxi:0xfc4cf980 %l 0x8115630 0x115630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S1_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LPM_ADC_CTL (at 0x11564)"
      tindex ezaxi:0xfc4cf980 %l 0x8115640 0x115640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S1_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ACTIVITY_DETECT (at 0x11565)"
      tindex ezaxi:0xfc4cf980 %l 0x8115650 0x115650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S1_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LPM_CFG (at 0x11568)"
      tindex ezaxi:0xfc4cf980 %l 0x8115680 0x115680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S1_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_FSM_MINON_CFG (at 0x11570)"
      tindex ezaxi:0xfc4cf980 %l 0x8115700 0x115700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S1_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ZX_CAL_CFG (at 0x11573)"
      tindex ezaxi:0xfc4cf980 %l 0x8115730 0x115730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S1_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_NONOVLAP_CFG (at 0x11574)"
      tindex ezaxi:0xfc4cf980 %l 0x8115740 0x115740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S1_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ADC_FRONT_CFG (at 0x11575)"
      tindex ezaxi:0xfc4cf980 %l 0x8115750 0x115750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_P0_LUT_IN (at 0x11578)"
      tindex ezaxi:0xfc4cf980 %l 0x8115780 0x115780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S1_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MPH_STROBE (at 0x11579)"
      tindex ezaxi:0xfc4cf980 %l 0x8115790 0x115790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S1_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_OUT (at 0x1157a)"
      tindex ezaxi:0xfc4cf980 %l 0x81157a0 0x1157a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S1_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ADC_OUT (at 0x1157b)"
      tindex ezaxi:0xfc4cf980 %l 0x81157b0 0x1157b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S1_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ADC_FRC (at 0x1157c)"
      tindex ezaxi:0xfc4cf980 %l 0x81157c0 0x1157c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S1_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MP_CORR_DFT (at 0x1157d)"
      tindex ezaxi:0xfc4cf980 %l 0x81157d0 0x1157d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S1_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DAC_DATA (at 0x1157e)"
      tindex ezaxi:0xfc4cf980 %l 0x81157e0 0x1157e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S1_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DAC_FRC (at 0x1157f)"
      tindex ezaxi:0xfc4cf980 %l 0x81157f0 0x1157f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S1_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_DAC_PT_0 (at 0x11580)"
      tindex ezaxi:0xfc4cf980 %l 0x8115800 0x115800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S1_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_DAC_PT_1 (at 0x11581)"
      tindex ezaxi:0xfc4cf980 %l 0x8115810 0x115810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S1_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_DAC_PT_2 (at 0x11582)"
      tindex ezaxi:0xfc4cf980 %l 0x8115820 0x115820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S1_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_DAC_PT_3 (at 0x11583)"
      tindex ezaxi:0xfc4cf980 %l 0x8115830 0x115830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S1_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_ADC_PT_1 (at 0x11587)"
      tindex ezaxi:0xfc4cf980 %l 0x8115870 0x115870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S1_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_ADC_PT_2 (at 0x11588)"
      tindex ezaxi:0xfc4cf980 %l 0x8115880 0x115880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S1_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_ADC_PT_3 (at 0x11589)"
      tindex ezaxi:0xfc4cf980 %l 0x8115890 0x115890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S1_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_SLOPE_HI_0 (at 0x1158c)"
      tindex ezaxi:0xfc4cf980 %l 0x81158c0 0x1158c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S1_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_SLOPE_LO_0 (at 0x1158d)"
      tindex ezaxi:0xfc4cf980 %l 0x81158d0 0x1158d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S1_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_SLOPE_HI_1 (at 0x1158e)"
      tindex ezaxi:0xfc4cf980 %l 0x81158e0 0x1158e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S1_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_SLOPE_LO_1 (at 0x1158f)"
      tindex ezaxi:0xfc4cf980 %l 0x81158f0 0x1158f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S1_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_SLOPE_HI_2 (at 0x11590)"
      tindex ezaxi:0xfc4cf980 %l 0x8115900 0x115900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S1_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_LUT_SLOPE_LO_2 (at 0x11591)"
      tindex ezaxi:0xfc4cf980 %l 0x8115910 0x115910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S1_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MPHASE_PI_CFG1 (at 0x11596)"
      tindex ezaxi:0xfc4cf980 %l 0x8115960 0x115960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S1_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MPHASE_PI_CFG4 (at 0x11597)"
      tindex ezaxi:0xfc4cf980 %l 0x8115970 0x115970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S1_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MPHASE_PHASE_CNT (at 0x11598)"
      tindex ezaxi:0xfc4cf980 %l 0x8115980 0x115980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S1_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_EN_OPTIONS_DFT_1 (at 0x115a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8115a80 0x115a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S1_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_EN_OPTIONS_DFT_2 (at 0x115a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8115a90 0x115a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S1_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ZX_ADAPT_CTL (at 0x115aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8115aa0 0x115aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S1_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ZX_ADAPT_VAL (at 0x115ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8115ab0 0x115ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S1_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ADC_CLK_CTL (at 0x115ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8115ac0 0x115ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S1_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ATEST12 (at 0x115b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8115b00 0x115b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S1_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ATEST34 (at 0x115b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8115b10 0x115b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S1_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DTEST12 (at 0x115b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8115b20 0x115b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S1_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DTEST43 (at 0x115b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8115b30 0x115b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S1_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_GANG_CTL1 (at 0x115c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8115c00 0x115c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_GANG_CTL2 (at 0x115c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8115c10 0x115c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_SEC_ACCESS (at 0x115d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8115d00 0x115d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8115d90 0x115d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
      tindex ezaxi:0xfc4cf980 %l 0x8115da0 0x115da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
      tindex ezaxi:0xfc4cf980 %l 0x8115db0 0x115db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_CAL_REQUEST (at 0x115e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8115e20 0x115e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S1_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_MAN_CAL_VAL (at 0x115e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8115e50 0x115e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S1_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REPLICA_CFG (at 0x115e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8115e60 0x115e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S1_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_CAL_CTL_1 (at 0x115e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8115e70 0x115e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S1_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_CAL_CTL_2 (at 0x115e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8115e80 0x115e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S1_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REPLICA_CAL_VAL (at 0x115ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8115ea0 0x115ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S1_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_DACMID_BUF_CAL_VAL (at 0x115ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8115ec0 0x115ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S1_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_FRONT_BUF_CAL_VAL (at 0x115ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8115ed0 0x115ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S1_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_CL_CAL_VAL (at 0x115ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8115ee0 0x115ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S1_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ZX_CAL_VAL (at 0x115ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8115ef0 0x115ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S1_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_TRIM_NUM (at 0x115f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8115f00 0x115f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S1_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_ZX_TRIM (at 0x115f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8115f10 0x115f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S1_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_CL_TRIM (at 0x115f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8115f20 0x115f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S1_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S1_PS_REPLICA_TRIM (at 0x115f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8115f30 0x115f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION1 (at 0x11700)"
      tindex ezaxi:0xfc4cf980 %l 0x8117000 0x117000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION2 (at 0x11701)"
      tindex ezaxi:0xfc4cf980 %l 0x8117010 0x117010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION3 (at 0x11702)"
      tindex ezaxi:0xfc4cf980 %l 0x8117020 0x117020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REVISION4 (at 0x11703)"
      tindex ezaxi:0xfc4cf980 %l 0x8117030 0x117030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_TYPE (at 0x11704)"
      tindex ezaxi:0xfc4cf980 %l 0x8117040 0x117040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
      tindex ezaxi:0xfc4cf980 %l 0x8117050 0x117050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_1 (at 0x11708)"
      tindex ezaxi:0xfc4cf980 %l 0x8117080 0x117080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_2 (at 0x11709)"
      tindex ezaxi:0xfc4cf980 %l 0x8117090 0x117090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_3 (at 0x1170a)"
      tindex ezaxi:0xfc4cf980 %l 0x81170a0 0x1170a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_4 (at 0x1170b)"
      tindex ezaxi:0xfc4cf980 %l 0x81170b0 0x1170b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S2_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_STATUS_5 (at 0x1170c)"
      tindex ezaxi:0xfc4cf980 %l 0x81170c0 0x1170c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_RT_STS (at 0x11710)"
      tindex ezaxi:0xfc4cf980 %l 0x8117100 0x117100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_SET_TYPE (at 0x11711)"
      tindex ezaxi:0xfc4cf980 %l 0x8117110 0x117110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
      tindex ezaxi:0xfc4cf980 %l 0x8117120 0x117120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
      tindex ezaxi:0xfc4cf980 %l 0x8117130 0x117130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
      tindex ezaxi:0xfc4cf980 %l 0x8117140 0x117140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_EN_SET (at 0x11715)"
      tindex ezaxi:0xfc4cf980 %l 0x8117150 0x117150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_EN_CLR (at 0x11716)"
      tindex ezaxi:0xfc4cf980 %l 0x8117160 0x117160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
      tindex ezaxi:0xfc4cf980 %l 0x8117180 0x117180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_PENDING_STS (at 0x11719)"
      tindex ezaxi:0xfc4cf980 %l 0x8117190 0x117190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_MID_SEL (at 0x1171a)"
      tindex ezaxi:0xfc4cf980 %l 0x81171a0 0x1171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_PRIORITY (at 0x1171b)"
      tindex ezaxi:0xfc4cf980 %l 0x81171b0 0x1171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VOLTAGE_CTL1 (at 0x11740)"
      tindex ezaxi:0xfc4cf980 %l 0x8117400 0x117400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
      tindex ezaxi:0xfc4cf980 %l 0x8117410 0x117410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VSET_VALID (at 0x11742)"
      tindex ezaxi:0xfc4cf980 %l 0x8117420 0x117420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S2_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MPPFM_VOFFSET (at 0x11744)"
      tindex ezaxi:0xfc4cf980 %l 0x8117440 0x117440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_CTL (at 0x11745)"
      tindex ezaxi:0xfc4cf980 %l 0x8117450 0x117450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S2_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_EN_CTL (at 0x11746)"
      tindex ezaxi:0xfc4cf980 %l 0x8117460 0x117460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S2_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PD_CTL (at 0x11748)"
      tindex ezaxi:0xfc4cf980 %l 0x8117480 0x117480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S2_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_FREQ_CTL (at 0x11750)"
      tindex ezaxi:0xfc4cf980 %l 0x8117500 0x117500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MULTIPHASE_CTL (at 0x11751)"
      tindex ezaxi:0xfc4cf980 %l 0x8117510 0x117510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S2_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PHASE_CTL (at 0x11752)"
      tindex ezaxi:0xfc4cf980 %l 0x8117520 0x117520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PHASE_ID (at 0x11753)"
      tindex ezaxi:0xfc4cf980 %l 0x8117530 0x117530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S2_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PHASE_CNT_MAX (at 0x11754)"
      tindex ezaxi:0xfc4cf980 %l 0x8117540 0x117540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S2_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PH_READY (at 0x11755)"
      tindex ezaxi:0xfc4cf980 %l 0x8117550 0x117550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S2_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_SS_CTL (at 0x11760)"
      tindex ezaxi:0xfc4cf980 %l 0x8117600 0x117600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VS_CTL (at 0x11761)"
      tindex ezaxi:0xfc4cf980 %l 0x8117610 0x117610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CORR_CFG (at 0x11762)"
      tindex ezaxi:0xfc4cf980 %l 0x8117620 0x117620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S2_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_RAMP_CFG (at 0x11763)"
      tindex ezaxi:0xfc4cf980 %l 0x8117630 0x117630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S2_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_COMPENS_CFG (at 0x11764)"
      tindex ezaxi:0xfc4cf980 %l 0x8117640 0x117640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S2_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_VREG_MON (at 0x11765)"
      tindex ezaxi:0xfc4cf980 %l 0x8117650 0x117650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S2_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_VREG_OCP (at 0x11766)"
      tindex ezaxi:0xfc4cf980 %l 0x8117660 0x117660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_PFM_COMP (at 0x11767)"
      tindex ezaxi:0xfc4cf980 %l 0x8117670 0x117670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S2_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_UL_LL_CTL (at 0x11768)"
      tindex ezaxi:0xfc4cf980 %l 0x8117680 0x117680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S2_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VSET_ULS (at 0x11769)"
      tindex ezaxi:0xfc4cf980 %l 0x8117690 0x117690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S2_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_ULS_VALID (at 0x1176a)"
      tindex ezaxi:0xfc4cf980 %l 0x81176a0 0x1176a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S2_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VSET_LLS (at 0x1176b)"
      tindex ezaxi:0xfc4cf980 %l 0x81176b0 0x1176b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S2_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_LLS_VALID (at 0x1176c)"
      tindex ezaxi:0xfc4cf980 %l 0x81176c0 0x1176c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S2_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GPL_HI (at 0x1176d)"
      tindex ezaxi:0xfc4cf980 %l 0x81176d0 0x1176d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S2_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GPL_LO (at 0x1176e)"
      tindex ezaxi:0xfc4cf980 %l 0x81176e0 0x1176e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S2_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_FB_FILT_CFG (at 0x1176f)"
      tindex ezaxi:0xfc4cf980 %l 0x81176f0 0x1176f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S2_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VDIP_CFG (at 0x11771)"
      tindex ezaxi:0xfc4cf980 %l 0x8117710 0x117710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S2_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MPH_STROBE (at 0x11779)"
      tindex ezaxi:0xfc4cf980 %l 0x8117790 0x117790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S2_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_FSM_MASK (at 0x117a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a00 0x117a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S2_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_FSM_WAITS_1 (at 0x117a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a10 0x117a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S2_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MODE_FSM_WAIT_2 (at 0x117a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a20 0x117a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S2_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GATE_DRV_MUX (at 0x117a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a30 0x117a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S2_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CORR_DUTY_MUX (at 0x117a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a40 0x117a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_EN_OPTIONS_DFT_1 (at 0x117a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a50 0x117a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_EN_OPTIONS_DFT_2 (at 0x117a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a60 0x117a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S2_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MPHASE_IDAC (at 0x117a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8117a70 0x117a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S2_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_ANTI_ESL_CFG_1 (at 0x117ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8117ac0 0x117ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_ANTI_ESL_CFG_2 (at 0x117ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8117ad0 0x117ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S2_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST1 (at 0x117b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b00 0x117b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S2_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST2 (at 0x117b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b10 0x117b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S2_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST3 (at 0x117b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b20 0x117b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S2_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_ATEST4 (at 0x117b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b30 0x117b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S2_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST1 (at 0x117b4)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b40 0x117b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST2 (at 0x117b5)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b50 0x117b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST3 (at 0x117b6)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b60 0x117b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S2_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CFG_DTEST4 (at 0x117b7)"
      tindex ezaxi:0xfc4cf980 %l 0x8117b70 0x117b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S2_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GANG_CTL1 (at 0x117c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8117c00 0x117c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_GANG_CTL2 (at 0x117c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8117c10 0x117c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_SEC_ACCESS (at 0x117d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8117d00 0x117d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8117d80 0x117d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8117d90 0x117d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
      tindex ezaxi:0xfc4cf980 %l 0x8117da0 0x117da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
      tindex ezaxi:0xfc4cf980 %l 0x8117db0 0x117db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_TEST1 (at 0x117e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8117e00 0x117e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8117e10 0x117e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S2_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CAL_REQUEST (at 0x117e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8117e20 0x117e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S2_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CAL_CTL_1 (at 0x117e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8117e30 0x117e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CAL_CTL_2 (at 0x117e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8117e40 0x117e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_MAN_CAL_VAL (at 0x117e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8117e50 0x117e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REFDAC_CAL_VAL (at 0x117ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8117ea0 0x117ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S2_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_VDIP_CAL_VAL (at 0x117eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8117eb0 0x117eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_IDAC_CAL_VAL (at 0x117ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8117ec0 0x117ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_CORR_CAL_VAL (at 0x117ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8117ed0 0x117ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PWM_CAL_VAL (at 0x117ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8117ee0 0x117ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_PFM_CAL_VAL (at 0x117ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8117ef0 0x117ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_TRIM_NUM (at 0x117f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8117f00 0x117f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_REFDAC_TRIM (at 0x117f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8117f10 0x117f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S2_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_CTRL_RAMP_TRIM (at 0x117f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8117f20 0x117f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_REVISION1 (at 0x11900)"
      tindex ezaxi:0xfc4cf980 %l 0x8119000 0x119000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_REVISION2 (at 0x11901)"
      tindex ezaxi:0xfc4cf980 %l 0x8119010 0x119010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_TYPE (at 0x11904)"
      tindex ezaxi:0xfc4cf980 %l 0x8119040 0x119040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
      tindex ezaxi:0xfc4cf980 %l 0x8119050 0x119050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_CLK_ENABLE (at 0x11946)"
      tindex ezaxi:0xfc4cf980 %l 0x8119460 0x119460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_CLK_DIV (at 0x11950)"
      tindex ezaxi:0xfc4cf980 %l 0x8119500 0x119500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_CLK_PHASE (at 0x11951)"
      tindex ezaxi:0xfc4cf980 %l 0x8119510 0x119510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_GANG_CTL1 (at 0x119c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8119c00 0x119c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_GANG_CTL2 (at 0x119c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8119c10 0x119c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_SEC_ACCESS (at 0x119d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8119d00 0x119d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8119d90 0x119d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
      tindex ezaxi:0xfc4cf980 %l 0x8119da0 0x119da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
      tindex ezaxi:0xfc4cf980 %l 0x8119db0 0x119db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S2_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_FREQ_TEST1 (at 0x119e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8119e20 0x119e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION1 (at 0x11800)"
      tindex ezaxi:0xfc4cf980 %l 0x8118000 0x118000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION2 (at 0x11801)"
      tindex ezaxi:0xfc4cf980 %l 0x8118010 0x118010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION3 (at 0x11802)"
      tindex ezaxi:0xfc4cf980 %l 0x8118020 0x118020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REVISION4 (at 0x11803)"
      tindex ezaxi:0xfc4cf980 %l 0x8118030 0x118030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_TYPE (at 0x11804)"
      tindex ezaxi:0xfc4cf980 %l 0x8118040 0x118040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_SUBTYPE (at 0x11805)"
      tindex ezaxi:0xfc4cf980 %l 0x8118050 0x118050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_STATUS_1 (at 0x11808)"
      tindex ezaxi:0xfc4cf980 %l 0x8118080 0x118080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S2_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_STATUS_2 (at 0x11809)"
      tindex ezaxi:0xfc4cf980 %l 0x8118090 0x118090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S2_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_VOLTAGE_CTL1 (at 0x11840)"
      tindex ezaxi:0xfc4cf980 %l 0x8118400 0x118400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S2_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_VOLTAGE_CTL2 (at 0x11841)"
      tindex ezaxi:0xfc4cf980 %l 0x8118410 0x118410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MODE_CTL (at 0x11845)"
      tindex ezaxi:0xfc4cf980 %l 0x8118450 0x118450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S2_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_FREQ_CTL (at 0x11850)"
      tindex ezaxi:0xfc4cf980 %l 0x8118500 0x118500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MULTIPHASE_CTL (at 0x11851)"
      tindex ezaxi:0xfc4cf980 %l 0x8118510 0x118510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S2_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PHASE_CTL (at 0x11852)"
      tindex ezaxi:0xfc4cf980 %l 0x8118520 0x118520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PHASE_ID (at 0x11853)"
      tindex ezaxi:0xfc4cf980 %l 0x8118530 0x118530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S2_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PHASE_CNT_MAX (at 0x11854)"
      tindex ezaxi:0xfc4cf980 %l 0x8118540 0x118540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S2_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PWM_CL_CTL (at 0x11860)"
      tindex ezaxi:0xfc4cf980 %l 0x8118600 0x118600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S2_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_CL_CTL (at 0x11861)"
      tindex ezaxi:0xfc4cf980 %l 0x8118610 0x118610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S2_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_AUTO_CTL_1 (at 0x11862)"
      tindex ezaxi:0xfc4cf980 %l 0x8118620 0x118620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S2_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_ADC_VAL (at 0x11863)"
      tindex ezaxi:0xfc4cf980 %l 0x8118630 0x118630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S2_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_ADC_CTL (at 0x11864)"
      tindex ezaxi:0xfc4cf980 %l 0x8118640 0x118640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ACTIVITY_DETECT (at 0x11865)"
      tindex ezaxi:0xfc4cf980 %l 0x8118650 0x118650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LPM_CFG (at 0x11868)"
      tindex ezaxi:0xfc4cf980 %l 0x8118680 0x118680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S2_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_FSM_MINON_CFG (at 0x11870)"
      tindex ezaxi:0xfc4cf980 %l 0x8118700 0x118700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S2_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_CAL_CFG (at 0x11873)"
      tindex ezaxi:0xfc4cf980 %l 0x8118730 0x118730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S2_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_NONOVLAP_CFG (at 0x11874)"
      tindex ezaxi:0xfc4cf980 %l 0x8118740 0x118740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S2_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_FRONT_CFG (at 0x11875)"
      tindex ezaxi:0xfc4cf980 %l 0x8118750 0x118750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_P0_LUT_IN (at 0x11878)"
      tindex ezaxi:0xfc4cf980 %l 0x8118780 0x118780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S2_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPH_STROBE (at 0x11879)"
      tindex ezaxi:0xfc4cf980 %l 0x8118790 0x118790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S2_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_OUT (at 0x1187a)"
      tindex ezaxi:0xfc4cf980 %l 0x81187a0 0x1187a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S2_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_OUT (at 0x1187b)"
      tindex ezaxi:0xfc4cf980 %l 0x81187b0 0x1187b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S2_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_FRC (at 0x1187c)"
      tindex ezaxi:0xfc4cf980 %l 0x81187c0 0x1187c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S2_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MP_CORR_DFT (at 0x1187d)"
      tindex ezaxi:0xfc4cf980 %l 0x81187d0 0x1187d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S2_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DAC_DATA (at 0x1187e)"
      tindex ezaxi:0xfc4cf980 %l 0x81187e0 0x1187e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S2_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DAC_FRC (at 0x1187f)"
      tindex ezaxi:0xfc4cf980 %l 0x81187f0 0x1187f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_0 (at 0x11880)"
      tindex ezaxi:0xfc4cf980 %l 0x8118800 0x118800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_1 (at 0x11881)"
      tindex ezaxi:0xfc4cf980 %l 0x8118810 0x118810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_2 (at 0x11882)"
      tindex ezaxi:0xfc4cf980 %l 0x8118820 0x118820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S2_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_DAC_PT_3 (at 0x11883)"
      tindex ezaxi:0xfc4cf980 %l 0x8118830 0x118830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_ADC_PT_1 (at 0x11887)"
      tindex ezaxi:0xfc4cf980 %l 0x8118870 0x118870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_ADC_PT_2 (at 0x11888)"
      tindex ezaxi:0xfc4cf980 %l 0x8118880 0x118880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S2_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_ADC_PT_3 (at 0x11889)"
      tindex ezaxi:0xfc4cf980 %l 0x8118890 0x118890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_HI_0 (at 0x1188c)"
      tindex ezaxi:0xfc4cf980 %l 0x81188c0 0x1188c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_LO_0 (at 0x1188d)"
      tindex ezaxi:0xfc4cf980 %l 0x81188d0 0x1188d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_HI_1 (at 0x1188e)"
      tindex ezaxi:0xfc4cf980 %l 0x81188e0 0x1188e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_LO_1 (at 0x1188f)"
      tindex ezaxi:0xfc4cf980 %l 0x81188f0 0x1188f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_HI_2 (at 0x11890)"
      tindex ezaxi:0xfc4cf980 %l 0x8118900 0x118900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S2_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_LUT_SLOPE_LO_2 (at 0x11891)"
      tindex ezaxi:0xfc4cf980 %l 0x8118910 0x118910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPHASE_PI_CFG1 (at 0x11896)"
      tindex ezaxi:0xfc4cf980 %l 0x8118960 0x118960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPHASE_PI_CFG4 (at 0x11897)"
      tindex ezaxi:0xfc4cf980 %l 0x8118970 0x118970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S2_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MPHASE_PHASE_CNT (at 0x11898)"
      tindex ezaxi:0xfc4cf980 %l 0x8118980 0x118980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_EN_OPTIONS_DFT_1 (at 0x118a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8118a80 0x118a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S2_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_EN_OPTIONS_DFT_2 (at 0x118a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8118a90 0x118a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S2_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_ADAPT_CTL (at 0x118aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8118aa0 0x118aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S2_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_ADAPT_VAL (at 0x118ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8118ab0 0x118ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S2_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ADC_CLK_CTL (at 0x118ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8118ac0 0x118ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S2_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ATEST12 (at 0x118b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8118b00 0x118b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S2_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ATEST34 (at 0x118b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8118b10 0x118b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S2_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DTEST12 (at 0x118b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8118b20 0x118b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S2_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DTEST43 (at 0x118b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8118b30 0x118b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S2_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_GANG_CTL1 (at 0x118c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8118c00 0x118c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_GANG_CTL2 (at 0x118c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8118c10 0x118c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_SEC_ACCESS (at 0x118d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8118d00 0x118d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8118d90 0x118d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
      tindex ezaxi:0xfc4cf980 %l 0x8118da0 0x118da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
      tindex ezaxi:0xfc4cf980 %l 0x8118db0 0x118db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CAL_REQUEST (at 0x118e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8118e20 0x118e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S2_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_MAN_CAL_VAL (at 0x118e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8118e50 0x118e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S2_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REPLICA_CFG (at 0x118e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8118e60 0x118e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S2_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CAL_CTL_1 (at 0x118e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8118e70 0x118e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CAL_CTL_2 (at 0x118e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8118e80 0x118e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S2_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REPLICA_CAL_VAL (at 0x118ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8118ea0 0x118ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S2_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_DACMID_BUF_CAL_VAL (at 0x118ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8118ec0 0x118ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S2_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_FRONT_BUF_CAL_VAL (at 0x118ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8118ed0 0x118ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S2_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CL_CAL_VAL (at 0x118ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8118ee0 0x118ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S2_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_CAL_VAL (at 0x118ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8118ef0 0x118ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S2_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_TRIM_NUM (at 0x118f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8118f00 0x118f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_ZX_TRIM (at 0x118f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8118f10 0x118f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S2_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_CL_TRIM (at 0x118f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8118f20 0x118f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S2_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S2_PS_REPLICA_TRIM (at 0x118f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8118f30 0x118f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION1 (at 0x11a00)"
      tindex ezaxi:0xfc4cf980 %l 0x811a000 0x11a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION2 (at 0x11a01)"
      tindex ezaxi:0xfc4cf980 %l 0x811a010 0x11a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION3 (at 0x11a02)"
      tindex ezaxi:0xfc4cf980 %l 0x811a020 0x11a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_REVISION4 (at 0x11a03)"
      tindex ezaxi:0xfc4cf980 %l 0x811a030 0x11a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_TYPE (at 0x11a04)"
      tindex ezaxi:0xfc4cf980 %l 0x811a040 0x11a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
      tindex ezaxi:0xfc4cf980 %l 0x811a050 0x11a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STATUS (at 0x11a08)"
      tindex ezaxi:0xfc4cf980 %l 0x811a080 0x11a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_RT_STS (at 0x11a10)"
      tindex ezaxi:0xfc4cf980 %l 0x811a100 0x11a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
      tindex ezaxi:0xfc4cf980 %l 0x811a110 0x11a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
      tindex ezaxi:0xfc4cf980 %l 0x811a120 0x11a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
      tindex ezaxi:0xfc4cf980 %l 0x811a130 0x11a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
      tindex ezaxi:0xfc4cf980 %l 0x811a140 0x11a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_EN_SET (at 0x11a15)"
      tindex ezaxi:0xfc4cf980 %l 0x811a150 0x11a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_EN_CLR (at 0x11a16)"
      tindex ezaxi:0xfc4cf980 %l 0x811a160 0x11a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
      tindex ezaxi:0xfc4cf980 %l 0x811a180 0x11a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
      tindex ezaxi:0xfc4cf980 %l 0x811a190 0x11a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
      tindex ezaxi:0xfc4cf980 %l 0x811a1a0 0x11a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
      tindex ezaxi:0xfc4cf980 %l 0x811a1b0 0x11a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VOLTAGE_CTL1 (at 0x11a40)"
      tindex ezaxi:0xfc4cf980 %l 0x811a400 0x11a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_VOLTAGE_CTL2 (at 0x11a41)"
      tindex ezaxi:0xfc4cf980 %l 0x811a410 0x11a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_PFM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PFM_CTL (at 0x11a44)"
      tindex ezaxi:0xfc4cf980 %l 0x811a440 0x11a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S3_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_MODE_CTL (at 0x11a45)"
      tindex ezaxi:0xfc4cf980 %l 0x811a450 0x11a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S3_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_EN_CTL (at 0x11a46)"
      tindex ezaxi:0xfc4cf980 %l 0x811a460 0x11a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S3_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PD_CTL (at 0x11a48)"
      tindex ezaxi:0xfc4cf980 %l 0x811a480 0x11a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S3_CTRL_COMP_CAP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_COMP_CAP_CTL (at 0x11a51)"
      tindex ezaxi:0xfc4cf980 %l 0x811a510 0x11a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S3_CTRL_GM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_GM_CTL (at 0x11a52)"
      tindex ezaxi:0xfc4cf980 %l 0x811a520 0x11a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S3_CTRL_RZ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_RZ_CTL (at 0x11a53)"
      tindex ezaxi:0xfc4cf980 %l 0x811a530 0x11a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S3_CTRL_ISNS_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_ISNS_CTRL (at 0x11a55)"
      tindex ezaxi:0xfc4cf980 %l 0x811a550 0x11a550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S3_CTRL_SAW_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_SAW_CTL (at 0x11a56)"
      tindex ezaxi:0xfc4cf980 %l 0x811a560 0x11a560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S3_CTRL_DMAX_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_DMAX_CTL (at 0x11a58)"
      tindex ezaxi:0xfc4cf980 %l 0x811a580 0x11a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PULSE_SKIP_CTL (at 0x11a59)"
      tindex ezaxi:0xfc4cf980 %l 0x811a590 0x11a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_THRES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PULSE_SKIP_THRES (at 0x11a5a)"
      tindex ezaxi:0xfc4cf980 %l 0x811a5a0 0x11a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S3_CTRL_AUTO_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_AUTO_MODE_CTL (at 0x11a5b)"
      tindex ezaxi:0xfc4cf980 %l 0x811a5b0 0x11a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S3_CTRL_INZERO_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INZERO_COUNT_CTL (at 0x11a5c)"
      tindex ezaxi:0xfc4cf980 %l 0x811a5c0 0x11a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PFM_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PFM_COUNT_CTL (at 0x11a5d)"
      tindex ezaxi:0xfc4cf980 %l 0x811a5d0 0x11a5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PS_VGA_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PS_VGA_CTL (at 0x11a5e)"
      tindex ezaxi:0xfc4cf980 %l 0x811a5e0 0x11a5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S3_CTRL_STEPPER_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STEPPER_SS_CTL (at 0x11a60)"
      tindex ezaxi:0xfc4cf980 %l 0x811a600 0x11a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_STEPPER_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_STEPPER_VS_CTL (at 0x11a61)"
      tindex ezaxi:0xfc4cf980 %l 0x811a610 0x11a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_FT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_FT_CTL (at 0x11a62)"
      tindex ezaxi:0xfc4cf980 %l 0x811a620 0x11a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S3_CTRL_QMODE_SHADOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_QMODE_SHADOW (at 0x11a63)"
      tindex ezaxi:0xfc4cf980 %l 0x811a630 0x11a630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S3_CTRL_UL_LL_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_UL_LL_CTRL (at 0x11a68)"
      tindex ezaxi:0xfc4cf980 %l 0x811a680 0x11a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S3_CTRL_UL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_UL_VOLTAGE (at 0x11a69)"
      tindex ezaxi:0xfc4cf980 %l 0x811a690 0x11a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_LL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_LL_VOLTAGE (at 0x11a6b)"
      tindex ezaxi:0xfc4cf980 %l 0x811a6b0 0x11a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_OCP (at 0x11a6c)"
      tindex ezaxi:0xfc4cf980 %l 0x811a6c0 0x11a6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S3_CTRL_CTLR_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CTLR_MISC (at 0x11a7a)"
      tindex ezaxi:0xfc4cf980 %l 0x811a7a0 0x11a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S3_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_SEC_ACCESS (at 0x11ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x811ad00 0x11ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
      tindex ezaxi:0xfc4cf980 %l 0x811ad80 0x11ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x811ad90 0x11ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
      tindex ezaxi:0xfc4cf980 %l 0x811ada0 0x11ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
      tindex ezaxi:0xfc4cf980 %l 0x811adb0 0x11adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_TEST1 (at 0x11ae0)"
      tindex ezaxi:0xfc4cf980 %l 0x811ae00 0x11ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
      tindex ezaxi:0xfc4cf980 %l 0x811ae10 0x11ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S3_CTRL_CTLR_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CTLR_TEST (at 0x11ae2)"
      tindex ezaxi:0xfc4cf980 %l 0x811ae20 0x11ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_TRIM_NUM (at 0x11af0)"
      tindex ezaxi:0xfc4cf980 %l 0x811af00 0x11af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_CTRL_CTL_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CTL_TRIM1 (at 0x11af1)"
      tindex ezaxi:0xfc4cf980 %l 0x811af10 0x11af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S3_CTRL_CTL_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CTL_TRIM2 (at 0x11af2)"
      tindex ezaxi:0xfc4cf980 %l 0x811af20 0x11af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S3_CTRL_CTL_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CTL_TRIM3 (at 0x11af3)"
      tindex ezaxi:0xfc4cf980 %l 0x811af30 0x11af30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S3_CTRL_CTL_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_CTRL_CTL_TRIM4 (at 0x11af4)"
      tindex ezaxi:0xfc4cf980 %l 0x811af40 0x11af40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_REVISION1 (at 0x11c00)"
      tindex ezaxi:0xfc4cf980 %l 0x811c000 0x11c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_REVISION2 (at 0x11c01)"
      tindex ezaxi:0xfc4cf980 %l 0x811c010 0x11c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_TYPE (at 0x11c04)"
      tindex ezaxi:0xfc4cf980 %l 0x811c040 0x11c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
      tindex ezaxi:0xfc4cf980 %l 0x811c050 0x11c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_CLK_ENABLE (at 0x11c46)"
      tindex ezaxi:0xfc4cf980 %l 0x811c460 0x11c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_CLK_DIV (at 0x11c50)"
      tindex ezaxi:0xfc4cf980 %l 0x811c500 0x11c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_CLK_PHASE (at 0x11c51)"
      tindex ezaxi:0xfc4cf980 %l 0x811c510 0x11c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
      tindex ezaxi:0xfc4cf980 %l 0x811cc00 0x11cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
      tindex ezaxi:0xfc4cf980 %l 0x811cc10 0x11cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x811cd00 0x11cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x811cd90 0x11cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
      tindex ezaxi:0xfc4cf980 %l 0x811cda0 0x11cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x811cdb0 0x11cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S3_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_FREQ_TEST1 (at 0x11ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x811ce20 0x11ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION1 (at 0x11b00)"
      tindex ezaxi:0xfc4cf980 %l 0x811b000 0x11b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION2 (at 0x11b01)"
      tindex ezaxi:0xfc4cf980 %l 0x811b010 0x11b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION3 (at 0x11b02)"
      tindex ezaxi:0xfc4cf980 %l 0x811b020 0x11b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_REVISION4 (at 0x11b03)"
      tindex ezaxi:0xfc4cf980 %l 0x811b030 0x11b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_TYPE (at 0x11b04)"
      tindex ezaxi:0xfc4cf980 %l 0x811b040 0x11b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
      tindex ezaxi:0xfc4cf980 %l 0x811b050 0x11b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PWM_CURRENT_LIM_CTL (at 0x11b4a)"
      tindex ezaxi:0xfc4cf980 %l 0x811b4a0 0x11b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S3_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PFM_CURRENT_LIM_CTL (at 0x11b4b)"
      tindex ezaxi:0xfc4cf980 %l 0x811b4b0 0x11b4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S3_PS_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_SOFT_START_CTL (at 0x11b4c)"
      tindex ezaxi:0xfc4cf980 %l 0x811b4c0 0x11b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S3_PS_SWITCH_SIZE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_SWITCH_SIZE_CTL (at 0x11b70)"
      tindex ezaxi:0xfc4cf980 %l 0x811b700 0x11b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DEAD_TIME_CTRL1 (at 0x11b71)"
      tindex ezaxi:0xfc4cf980 %l 0x811b710 0x11b710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DEAD_TIME_CTRL2 (at 0x11b72)"
      tindex ezaxi:0xfc4cf980 %l 0x811b720 0x11b720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S3_PS_BLNK_TIME_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_BLNK_TIME_CTL (at 0x11b73)"
      tindex ezaxi:0xfc4cf980 %l 0x811b730 0x11b730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S3_PS_INZERO_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_INZERO_CTL (at 0x11b74)"
      tindex ezaxi:0xfc4cf980 %l 0x811b740 0x11b740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S3_PS_DIG_FSM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_DIG_FSM_CTL (at 0x11b75)"
      tindex ezaxi:0xfc4cf980 %l 0x811b750 0x11b750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S3_PS_PWR_STG_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PWR_STG_MISC (at 0x11b79)"
      tindex ezaxi:0xfc4cf980 %l 0x811b790 0x11b790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S3_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_SEC_ACCESS (at 0x11bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x811bd00 0x11bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x811bd90 0x11bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
      tindex ezaxi:0xfc4cf980 %l 0x811bda0 0x11bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x811bdb0 0x11bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S3_PS_FORCE_FET_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_FORCE_FET_TEST (at 0x11be3)"
      tindex ezaxi:0xfc4cf980 %l 0x811be30 0x11be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S3_PS_PWR_STG_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PWR_STG_TEST (at 0x11be4)"
      tindex ezaxi:0xfc4cf980 %l 0x811be40 0x11be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_TRIM_NUM (at 0x11bf0)"
      tindex ezaxi:0xfc4cf980 %l 0x811bf00 0x11bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_PS_PS_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PS_TRIM1 (at 0x11bf1)"
      tindex ezaxi:0xfc4cf980 %l 0x811bf10 0x11bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S3_PS_PS_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S3_PS_PS_TRIM2 (at 0x11bf2)"
      tindex ezaxi:0xfc4cf980 %l 0x811bf20 0x11bf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_REVISION1 (at 0x11d00)"
      tindex ezaxi:0xfc4cf980 %l 0x811d000 0x11d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_REVISION2 (at 0x11d01)"
      tindex ezaxi:0xfc4cf980 %l 0x811d010 0x11d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_REVISION3 (at 0x11d02)"
      tindex ezaxi:0xfc4cf980 %l 0x811d020 0x11d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_REVISION4 (at 0x11d03)"
      tindex ezaxi:0xfc4cf980 %l 0x811d030 0x11d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PERPH_TYPE (at 0x11d04)"
      tindex ezaxi:0xfc4cf980 %l 0x811d040 0x11d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PERPH_SUBTYPE (at 0x11d05)"
      tindex ezaxi:0xfc4cf980 %l 0x811d050 0x11d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_STATUS (at 0x11d08)"
      tindex ezaxi:0xfc4cf980 %l 0x811d080 0x11d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_RT_STS (at 0x11d10)"
      tindex ezaxi:0xfc4cf980 %l 0x811d100 0x11d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_SET_TYPE (at 0x11d11)"
      tindex ezaxi:0xfc4cf980 %l 0x811d110 0x11d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_POLARITY_HIGH (at 0x11d12)"
      tindex ezaxi:0xfc4cf980 %l 0x811d120 0x11d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_POLARITY_LOW (at 0x11d13)"
      tindex ezaxi:0xfc4cf980 %l 0x811d130 0x11d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_LATCHED_CLR (at 0x11d14)"
      tindex ezaxi:0xfc4cf980 %l 0x811d140 0x11d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_EN_SET (at 0x11d15)"
      tindex ezaxi:0xfc4cf980 %l 0x811d150 0x11d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_EN_CLR (at 0x11d16)"
      tindex ezaxi:0xfc4cf980 %l 0x811d160 0x11d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_LATCHED_STS (at 0x11d18)"
      tindex ezaxi:0xfc4cf980 %l 0x811d180 0x11d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_PENDING_STS (at 0x11d19)"
      tindex ezaxi:0xfc4cf980 %l 0x811d190 0x11d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_MID_SEL (at 0x11d1a)"
      tindex ezaxi:0xfc4cf980 %l 0x811d1a0 0x11d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_PRIORITY (at 0x11d1b)"
      tindex ezaxi:0xfc4cf980 %l 0x811d1b0 0x11d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_VOLTAGE_CTL1 (at 0x11d40)"
      tindex ezaxi:0xfc4cf980 %l 0x811d400 0x11d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_VOLTAGE_CTL2 (at 0x11d41)"
      tindex ezaxi:0xfc4cf980 %l 0x811d410 0x11d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_PFM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PFM_CTL (at 0x11d44)"
      tindex ezaxi:0xfc4cf980 %l 0x811d440 0x11d440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S4_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_MODE_CTL (at 0x11d45)"
      tindex ezaxi:0xfc4cf980 %l 0x811d450 0x11d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S4_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_EN_CTL (at 0x11d46)"
      tindex ezaxi:0xfc4cf980 %l 0x811d460 0x11d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S4_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PD_CTL (at 0x11d48)"
      tindex ezaxi:0xfc4cf980 %l 0x811d480 0x11d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S4_CTRL_COMP_CAP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_COMP_CAP_CTL (at 0x11d51)"
      tindex ezaxi:0xfc4cf980 %l 0x811d510 0x11d510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S4_CTRL_GM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_GM_CTL (at 0x11d52)"
      tindex ezaxi:0xfc4cf980 %l 0x811d520 0x11d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S4_CTRL_RZ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_RZ_CTL (at 0x11d53)"
      tindex ezaxi:0xfc4cf980 %l 0x811d530 0x11d530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S4_CTRL_ISNS_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_ISNS_CTRL (at 0x11d55)"
      tindex ezaxi:0xfc4cf980 %l 0x811d550 0x11d550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S4_CTRL_SAW_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_SAW_CTL (at 0x11d56)"
      tindex ezaxi:0xfc4cf980 %l 0x811d560 0x11d560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S4_CTRL_DMAX_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_DMAX_CTL (at 0x11d58)"
      tindex ezaxi:0xfc4cf980 %l 0x811d580 0x11d580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PULSE_SKIP_CTL (at 0x11d59)"
      tindex ezaxi:0xfc4cf980 %l 0x811d590 0x11d590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_THRES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PULSE_SKIP_THRES (at 0x11d5a)"
      tindex ezaxi:0xfc4cf980 %l 0x811d5a0 0x11d5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S4_CTRL_AUTO_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_AUTO_MODE_CTL (at 0x11d5b)"
      tindex ezaxi:0xfc4cf980 %l 0x811d5b0 0x11d5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S4_CTRL_INZERO_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INZERO_COUNT_CTL (at 0x11d5c)"
      tindex ezaxi:0xfc4cf980 %l 0x811d5c0 0x11d5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PFM_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PFM_COUNT_CTL (at 0x11d5d)"
      tindex ezaxi:0xfc4cf980 %l 0x811d5d0 0x11d5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PS_VGA_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PS_VGA_CTL (at 0x11d5e)"
      tindex ezaxi:0xfc4cf980 %l 0x811d5e0 0x11d5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S4_CTRL_STEPPER_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_STEPPER_SS_CTL (at 0x11d60)"
      tindex ezaxi:0xfc4cf980 %l 0x811d600 0x11d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_STEPPER_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_STEPPER_VS_CTL (at 0x11d61)"
      tindex ezaxi:0xfc4cf980 %l 0x811d610 0x11d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_FT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_FT_CTL (at 0x11d62)"
      tindex ezaxi:0xfc4cf980 %l 0x811d620 0x11d620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S4_CTRL_QMODE_SHADOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_QMODE_SHADOW (at 0x11d63)"
      tindex ezaxi:0xfc4cf980 %l 0x811d630 0x11d630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S4_CTRL_UL_LL_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_UL_LL_CTRL (at 0x11d68)"
      tindex ezaxi:0xfc4cf980 %l 0x811d680 0x11d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S4_CTRL_UL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_UL_VOLTAGE (at 0x11d69)"
      tindex ezaxi:0xfc4cf980 %l 0x811d690 0x11d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_LL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_LL_VOLTAGE (at 0x11d6b)"
      tindex ezaxi:0xfc4cf980 %l 0x811d6b0 0x11d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_OCP (at 0x11d6c)"
      tindex ezaxi:0xfc4cf980 %l 0x811d6c0 0x11d6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S4_CTRL_CTLR_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_CTLR_MISC (at 0x11d7a)"
      tindex ezaxi:0xfc4cf980 %l 0x811d7a0 0x11d7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_SEC_ACCESS (at 0x11dd0)"
      tindex ezaxi:0xfc4cf980 %l 0x811dd00 0x11dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PERPH_RESET_CTL1 (at 0x11dd8)"
      tindex ezaxi:0xfc4cf980 %l 0x811dd80 0x11dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PERPH_RESET_CTL2 (at 0x11dd9)"
      tindex ezaxi:0xfc4cf980 %l 0x811dd90 0x11dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PERPH_RESET_CTL3 (at 0x11dda)"
      tindex ezaxi:0xfc4cf980 %l 0x811dda0 0x11dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_PERPH_RESET_CTL4 (at 0x11ddb)"
      tindex ezaxi:0xfc4cf980 %l 0x811ddb0 0x11ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_TEST1 (at 0x11de0)"
      tindex ezaxi:0xfc4cf980 %l 0x811de00 0x11de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_INT_TEST_VAL (at 0x11de1)"
      tindex ezaxi:0xfc4cf980 %l 0x811de10 0x11de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S4_CTRL_CTLR_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_CTLR_TEST (at 0x11de2)"
      tindex ezaxi:0xfc4cf980 %l 0x811de20 0x11de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_TRIM_NUM (at 0x11df0)"
      tindex ezaxi:0xfc4cf980 %l 0x811df00 0x11df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_CTRL_CTL_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_CTL_TRIM1 (at 0x11df1)"
      tindex ezaxi:0xfc4cf980 %l 0x811df10 0x11df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S4_CTRL_CTL_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_CTL_TRIM2 (at 0x11df2)"
      tindex ezaxi:0xfc4cf980 %l 0x811df20 0x11df20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S4_CTRL_CTL_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_CTL_TRIM3 (at 0x11df3)"
      tindex ezaxi:0xfc4cf980 %l 0x811df30 0x11df30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S4_CTRL_CTL_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_CTRL_CTL_TRIM4 (at 0x11df4)"
      tindex ezaxi:0xfc4cf980 %l 0x811df40 0x11df40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_REVISION1 (at 0x11f00)"
      tindex ezaxi:0xfc4cf980 %l 0x811f000 0x11f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_REVISION2 (at 0x11f01)"
      tindex ezaxi:0xfc4cf980 %l 0x811f010 0x11f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_PERPH_TYPE (at 0x11f04)"
      tindex ezaxi:0xfc4cf980 %l 0x811f040 0x11f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_PERPH_SUBTYPE (at 0x11f05)"
      tindex ezaxi:0xfc4cf980 %l 0x811f050 0x11f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_CLK_ENABLE (at 0x11f46)"
      tindex ezaxi:0xfc4cf980 %l 0x811f460 0x11f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_CLK_DIV (at 0x11f50)"
      tindex ezaxi:0xfc4cf980 %l 0x811f500 0x11f500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_CLK_PHASE (at 0x11f51)"
      tindex ezaxi:0xfc4cf980 %l 0x811f510 0x11f510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_GANG_CTL1 (at 0x11fc0)"
      tindex ezaxi:0xfc4cf980 %l 0x811fc00 0x11fc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_GANG_CTL2 (at 0x11fc1)"
      tindex ezaxi:0xfc4cf980 %l 0x811fc10 0x11fc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_SEC_ACCESS (at 0x11fd0)"
      tindex ezaxi:0xfc4cf980 %l 0x811fd00 0x11fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_PERPH_RESET_CTL2 (at 0x11fd9)"
      tindex ezaxi:0xfc4cf980 %l 0x811fd90 0x11fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_PERPH_RESET_CTL3 (at 0x11fda)"
      tindex ezaxi:0xfc4cf980 %l 0x811fda0 0x11fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_PERPH_RESET_CTL4 (at 0x11fdb)"
      tindex ezaxi:0xfc4cf980 %l 0x811fdb0 0x11fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S4_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_FREQ_TEST1 (at 0x11fe2)"
      tindex ezaxi:0xfc4cf980 %l 0x811fe20 0x11fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_REVISION1 (at 0x11e00)"
      tindex ezaxi:0xfc4cf980 %l 0x811e000 0x11e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_REVISION2 (at 0x11e01)"
      tindex ezaxi:0xfc4cf980 %l 0x811e010 0x11e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_REVISION3 (at 0x11e02)"
      tindex ezaxi:0xfc4cf980 %l 0x811e020 0x11e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_REVISION4 (at 0x11e03)"
      tindex ezaxi:0xfc4cf980 %l 0x811e030 0x11e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PERPH_TYPE (at 0x11e04)"
      tindex ezaxi:0xfc4cf980 %l 0x811e040 0x11e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PERPH_SUBTYPE (at 0x11e05)"
      tindex ezaxi:0xfc4cf980 %l 0x811e050 0x11e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PWM_CURRENT_LIM_CTL (at 0x11e4a)"
      tindex ezaxi:0xfc4cf980 %l 0x811e4a0 0x11e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S4_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PFM_CURRENT_LIM_CTL (at 0x11e4b)"
      tindex ezaxi:0xfc4cf980 %l 0x811e4b0 0x11e4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S4_PS_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_SOFT_START_CTL (at 0x11e4c)"
      tindex ezaxi:0xfc4cf980 %l 0x811e4c0 0x11e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S4_PS_SWITCH_SIZE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_SWITCH_SIZE_CTL (at 0x11e70)"
      tindex ezaxi:0xfc4cf980 %l 0x811e700 0x11e700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_DEAD_TIME_CTRL1 (at 0x11e71)"
      tindex ezaxi:0xfc4cf980 %l 0x811e710 0x11e710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_DEAD_TIME_CTRL2 (at 0x11e72)"
      tindex ezaxi:0xfc4cf980 %l 0x811e720 0x11e720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S4_PS_BLNK_TIME_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_BLNK_TIME_CTL (at 0x11e73)"
      tindex ezaxi:0xfc4cf980 %l 0x811e730 0x11e730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S4_PS_INZERO_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_INZERO_CTL (at 0x11e74)"
      tindex ezaxi:0xfc4cf980 %l 0x811e740 0x11e740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S4_PS_DIG_FSM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_DIG_FSM_CTL (at 0x11e75)"
      tindex ezaxi:0xfc4cf980 %l 0x811e750 0x11e750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S4_PS_PWR_STG_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PWR_STG_MISC (at 0x11e79)"
      tindex ezaxi:0xfc4cf980 %l 0x811e790 0x11e790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S4_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_SEC_ACCESS (at 0x11ed0)"
      tindex ezaxi:0xfc4cf980 %l 0x811ed00 0x11ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PERPH_RESET_CTL2 (at 0x11ed9)"
      tindex ezaxi:0xfc4cf980 %l 0x811ed90 0x11ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PERPH_RESET_CTL3 (at 0x11eda)"
      tindex ezaxi:0xfc4cf980 %l 0x811eda0 0x11eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PERPH_RESET_CTL4 (at 0x11edb)"
      tindex ezaxi:0xfc4cf980 %l 0x811edb0 0x11edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S4_PS_FORCE_FET_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_FORCE_FET_TEST (at 0x11ee3)"
      tindex ezaxi:0xfc4cf980 %l 0x811ee30 0x11ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S4_PS_PWR_STG_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PWR_STG_TEST (at 0x11ee4)"
      tindex ezaxi:0xfc4cf980 %l 0x811ee40 0x11ee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_TRIM_NUM (at 0x11ef0)"
      tindex ezaxi:0xfc4cf980 %l 0x811ef00 0x11ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_PS_PS_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PS_TRIM1 (at 0x11ef1)"
      tindex ezaxi:0xfc4cf980 %l 0x811ef10 0x11ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S4_PS_PS_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S4_PS_PS_TRIM2 (at 0x11ef2)"
      tindex ezaxi:0xfc4cf980 %l 0x811ef20 0x11ef20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S5_CTRL"
  tree "S5_CTRL"
    tree "S5_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_REVISION1 (at 0x12000)"
      tindex ezaxi:0xfc4cf980 %l 0x8120000 0x120000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_REVISION2 (at 0x12001)"
      tindex ezaxi:0xfc4cf980 %l 0x8120010 0x120010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_REVISION3 (at 0x12002)"
      tindex ezaxi:0xfc4cf980 %l 0x8120020 0x120020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_REVISION4 (at 0x12003)"
      tindex ezaxi:0xfc4cf980 %l 0x8120030 0x120030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PERPH_TYPE (at 0x12004)"
      tindex ezaxi:0xfc4cf980 %l 0x8120040 0x120040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PERPH_SUBTYPE (at 0x12005)"
      tindex ezaxi:0xfc4cf980 %l 0x8120050 0x120050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_CTRL_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_STATUS (at 0x12008)"
      tindex ezaxi:0xfc4cf980 %l 0x8120080 0x120080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S5_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_RT_STS (at 0x12010)"
      tindex ezaxi:0xfc4cf980 %l 0x8120100 0x120100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_SET_TYPE (at 0x12011)"
      tindex ezaxi:0xfc4cf980 %l 0x8120110 0x120110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_POLARITY_HIGH (at 0x12012)"
      tindex ezaxi:0xfc4cf980 %l 0x8120120 0x120120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_POLARITY_LOW (at 0x12013)"
      tindex ezaxi:0xfc4cf980 %l 0x8120130 0x120130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_LATCHED_CLR (at 0x12014)"
      tindex ezaxi:0xfc4cf980 %l 0x8120140 0x120140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_EN_SET (at 0x12015)"
      tindex ezaxi:0xfc4cf980 %l 0x8120150 0x120150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_EN_CLR (at 0x12016)"
      tindex ezaxi:0xfc4cf980 %l 0x8120160 0x120160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_LATCHED_STS (at 0x12018)"
      tindex ezaxi:0xfc4cf980 %l 0x8120180 0x120180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_PENDING_STS (at 0x12019)"
      tindex ezaxi:0xfc4cf980 %l 0x8120190 0x120190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_MID_SEL (at 0x1201a)"
      tindex ezaxi:0xfc4cf980 %l 0x81201a0 0x1201a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S5_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_PRIORITY (at 0x1201b)"
      tindex ezaxi:0xfc4cf980 %l 0x81201b0 0x1201b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_VOLTAGE_CTL1 (at 0x12040)"
      tindex ezaxi:0xfc4cf980 %l 0x8120400 0x120400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_VOLTAGE_CTL2 (at 0x12041)"
      tindex ezaxi:0xfc4cf980 %l 0x8120410 0x120410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_PFM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PFM_CTL (at 0x12044)"
      tindex ezaxi:0xfc4cf980 %l 0x8120440 0x120440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S5_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_MODE_CTL (at 0x12045)"
      tindex ezaxi:0xfc4cf980 %l 0x8120450 0x120450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S5_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_EN_CTL (at 0x12046)"
      tindex ezaxi:0xfc4cf980 %l 0x8120460 0x120460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S5_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PD_CTL (at 0x12048)"
      tindex ezaxi:0xfc4cf980 %l 0x8120480 0x120480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S5_CTRL_COMP_CAP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_COMP_CAP_CTL (at 0x12051)"
      tindex ezaxi:0xfc4cf980 %l 0x8120510 0x120510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S5_CTRL_GM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_GM_CTL (at 0x12052)"
      tindex ezaxi:0xfc4cf980 %l 0x8120520 0x120520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S5_CTRL_RZ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_RZ_CTL (at 0x12053)"
      tindex ezaxi:0xfc4cf980 %l 0x8120530 0x120530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S5_CTRL_ISNS_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_ISNS_CTRL (at 0x12055)"
      tindex ezaxi:0xfc4cf980 %l 0x8120550 0x120550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S5_CTRL_SAW_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_SAW_CTL (at 0x12056)"
      tindex ezaxi:0xfc4cf980 %l 0x8120560 0x120560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S5_CTRL_DMAX_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_DMAX_CTL (at 0x12058)"
      tindex ezaxi:0xfc4cf980 %l 0x8120580 0x120580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S5_CTRL_PULSE_SKIP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PULSE_SKIP_CTL (at 0x12059)"
      tindex ezaxi:0xfc4cf980 %l 0x8120590 0x120590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S5_CTRL_PULSE_SKIP_THRES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PULSE_SKIP_THRES (at 0x1205a)"
      tindex ezaxi:0xfc4cf980 %l 0x81205a0 0x1205a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S5_CTRL_AUTO_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_AUTO_MODE_CTL (at 0x1205b)"
      tindex ezaxi:0xfc4cf980 %l 0x81205b0 0x1205b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S5_CTRL_INZERO_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INZERO_COUNT_CTL (at 0x1205c)"
      tindex ezaxi:0xfc4cf980 %l 0x81205c0 0x1205c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PFM_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PFM_COUNT_CTL (at 0x1205d)"
      tindex ezaxi:0xfc4cf980 %l 0x81205d0 0x1205d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PS_VGA_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PS_VGA_CTL (at 0x1205e)"
      tindex ezaxi:0xfc4cf980 %l 0x81205e0 0x1205e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S5_CTRL_STEPPER_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_STEPPER_SS_CTL (at 0x12060)"
      tindex ezaxi:0xfc4cf980 %l 0x8120600 0x120600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_STEPPER_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_STEPPER_VS_CTL (at 0x12061)"
      tindex ezaxi:0xfc4cf980 %l 0x8120610 0x120610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_FT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_FT_CTL (at 0x12062)"
      tindex ezaxi:0xfc4cf980 %l 0x8120620 0x120620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S5_CTRL_QMODE_SHADOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_QMODE_SHADOW (at 0x12063)"
      tindex ezaxi:0xfc4cf980 %l 0x8120630 0x120630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S5_CTRL_UL_LL_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_UL_LL_CTRL (at 0x12068)"
      tindex ezaxi:0xfc4cf980 %l 0x8120680 0x120680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S5_CTRL_UL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_UL_VOLTAGE (at 0x12069)"
      tindex ezaxi:0xfc4cf980 %l 0x8120690 0x120690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_LL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_LL_VOLTAGE (at 0x1206b)"
      tindex ezaxi:0xfc4cf980 %l 0x81206b0 0x1206b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_OCP (at 0x1206c)"
      tindex ezaxi:0xfc4cf980 %l 0x81206c0 0x1206c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S5_CTRL_CTLR_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_CTLR_MISC (at 0x1207a)"
      tindex ezaxi:0xfc4cf980 %l 0x81207a0 0x1207a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_SEC_ACCESS (at 0x120d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8120d00 0x120d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PERPH_RESET_CTL1 (at 0x120d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8120d80 0x120d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PERPH_RESET_CTL2 (at 0x120d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8120d90 0x120d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PERPH_RESET_CTL3 (at 0x120da)"
      tindex ezaxi:0xfc4cf980 %l 0x8120da0 0x120da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_PERPH_RESET_CTL4 (at 0x120db)"
      tindex ezaxi:0xfc4cf980 %l 0x8120db0 0x120db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_TEST1 (at 0x120e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8120e00 0x120e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_INT_TEST_VAL (at 0x120e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8120e10 0x120e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S5_CTRL_CTLR_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_CTLR_TEST (at 0x120e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8120e20 0x120e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_TRIM_NUM (at 0x120f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8120f00 0x120f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_CTRL_CTL_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_CTL_TRIM1 (at 0x120f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8120f10 0x120f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S5_CTRL_CTL_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_CTL_TRIM2 (at 0x120f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8120f20 0x120f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S5_CTRL_CTL_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_CTL_TRIM3 (at 0x120f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8120f30 0x120f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S5_CTRL_CTL_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_CTRL_CTL_TRIM4 (at 0x120f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8120f40 0x120f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S5_FREQ"
  tree "S5_FREQ"
    tree "S5_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_REVISION1 (at 0x12200)"
      tindex ezaxi:0xfc4cf980 %l 0x8122000 0x122000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_REVISION2 (at 0x12201)"
      tindex ezaxi:0xfc4cf980 %l 0x8122010 0x122010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_PERPH_TYPE (at 0x12204)"
      tindex ezaxi:0xfc4cf980 %l 0x8122040 0x122040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_PERPH_SUBTYPE (at 0x12205)"
      tindex ezaxi:0xfc4cf980 %l 0x8122050 0x122050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_CLK_ENABLE (at 0x12246)"
      tindex ezaxi:0xfc4cf980 %l 0x8122460 0x122460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S5_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_CLK_DIV (at 0x12250)"
      tindex ezaxi:0xfc4cf980 %l 0x8122500 0x122500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S5_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_CLK_PHASE (at 0x12251)"
      tindex ezaxi:0xfc4cf980 %l 0x8122510 0x122510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S5_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_GANG_CTL1 (at 0x122c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8122c00 0x122c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_GANG_CTL2 (at 0x122c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8122c10 0x122c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S5_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_SEC_ACCESS (at 0x122d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8122d00 0x122d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_PERPH_RESET_CTL2 (at 0x122d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8122d90 0x122d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_PERPH_RESET_CTL3 (at 0x122da)"
      tindex ezaxi:0xfc4cf980 %l 0x8122da0 0x122da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_PERPH_RESET_CTL4 (at 0x122db)"
      tindex ezaxi:0xfc4cf980 %l 0x8122db0 0x122db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S5_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_FREQ_TEST1 (at 0x122e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8122e20 0x122e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S5_PS"
  tree "S5_PS"
    tree "S5_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_REVISION1 (at 0x12100)"
      tindex ezaxi:0xfc4cf980 %l 0x8121000 0x121000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_REVISION2 (at 0x12101)"
      tindex ezaxi:0xfc4cf980 %l 0x8121010 0x121010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_REVISION3 (at 0x12102)"
      tindex ezaxi:0xfc4cf980 %l 0x8121020 0x121020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_REVISION4 (at 0x12103)"
      tindex ezaxi:0xfc4cf980 %l 0x8121030 0x121030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PERPH_TYPE (at 0x12104)"
      tindex ezaxi:0xfc4cf980 %l 0x8121040 0x121040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PERPH_SUBTYPE (at 0x12105)"
      tindex ezaxi:0xfc4cf980 %l 0x8121050 0x121050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PWM_CURRENT_LIM_CTL (at 0x1214a)"
      tindex ezaxi:0xfc4cf980 %l 0x81214a0 0x1214a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S5_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PFM_CURRENT_LIM_CTL (at 0x1214b)"
      tindex ezaxi:0xfc4cf980 %l 0x81214b0 0x1214b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S5_PS_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_SOFT_START_CTL (at 0x1214c)"
      tindex ezaxi:0xfc4cf980 %l 0x81214c0 0x1214c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S5_PS_SWITCH_SIZE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_SWITCH_SIZE_CTL (at 0x12170)"
      tindex ezaxi:0xfc4cf980 %l 0x8121700 0x121700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S5_PS_DEAD_TIME_CTRL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_DEAD_TIME_CTRL1 (at 0x12171)"
      tindex ezaxi:0xfc4cf980 %l 0x8121710 0x121710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S5_PS_DEAD_TIME_CTRL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_DEAD_TIME_CTRL2 (at 0x12172)"
      tindex ezaxi:0xfc4cf980 %l 0x8121720 0x121720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S5_PS_BLNK_TIME_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_BLNK_TIME_CTL (at 0x12173)"
      tindex ezaxi:0xfc4cf980 %l 0x8121730 0x121730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S5_PS_INZERO_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_INZERO_CTL (at 0x12174)"
      tindex ezaxi:0xfc4cf980 %l 0x8121740 0x121740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S5_PS_DIG_FSM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_DIG_FSM_CTL (at 0x12175)"
      tindex ezaxi:0xfc4cf980 %l 0x8121750 0x121750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S5_PS_PWR_STG_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PWR_STG_MISC (at 0x12179)"
      tindex ezaxi:0xfc4cf980 %l 0x8121790 0x121790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S5_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_SEC_ACCESS (at 0x121d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8121d00 0x121d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PERPH_RESET_CTL2 (at 0x121d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8121d90 0x121d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PERPH_RESET_CTL3 (at 0x121da)"
      tindex ezaxi:0xfc4cf980 %l 0x8121da0 0x121da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PERPH_RESET_CTL4 (at 0x121db)"
      tindex ezaxi:0xfc4cf980 %l 0x8121db0 0x121db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S5_PS_FORCE_FET_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_FORCE_FET_TEST (at 0x121e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8121e30 0x121e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S5_PS_PWR_STG_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PWR_STG_TEST (at 0x121e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8121e40 0x121e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_TRIM_NUM (at 0x121f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8121f00 0x121f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_PS_PS_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PS_TRIM1 (at 0x121f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8121f10 0x121f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S5_PS_PS_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S5_PS_PS_TRIM2 (at 0x121f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8121f20 0x121f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S6_CTRL"
  tree "S6_CTRL"
    tree "S6_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_REVISION1 (at 0x12300)"
      tindex ezaxi:0xfc4cf980 %l 0x8123000 0x123000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_REVISION2 (at 0x12301)"
      tindex ezaxi:0xfc4cf980 %l 0x8123010 0x123010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_REVISION3 (at 0x12302)"
      tindex ezaxi:0xfc4cf980 %l 0x8123020 0x123020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_REVISION4 (at 0x12303)"
      tindex ezaxi:0xfc4cf980 %l 0x8123030 0x123030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PERPH_TYPE (at 0x12304)"
      tindex ezaxi:0xfc4cf980 %l 0x8123040 0x123040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PERPH_SUBTYPE (at 0x12305)"
      tindex ezaxi:0xfc4cf980 %l 0x8123050 0x123050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_STATUS_1 (at 0x12308)"
      tindex ezaxi:0xfc4cf980 %l 0x8123080 0x123080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S6_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_STATUS_2 (at 0x12309)"
      tindex ezaxi:0xfc4cf980 %l 0x8123090 0x123090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S6_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_STATUS_3 (at 0x1230a)"
      tindex ezaxi:0xfc4cf980 %l 0x81230a0 0x1230a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S6_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_STATUS_4 (at 0x1230b)"
      tindex ezaxi:0xfc4cf980 %l 0x81230b0 0x1230b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S6_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_STATUS_5 (at 0x1230c)"
      tindex ezaxi:0xfc4cf980 %l 0x81230c0 0x1230c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S6_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_RT_STS (at 0x12310)"
      tindex ezaxi:0xfc4cf980 %l 0x8123100 0x123100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S6_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_SET_TYPE (at 0x12311)"
      tindex ezaxi:0xfc4cf980 %l 0x8123110 0x123110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S6_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_POLARITY_HIGH (at 0x12312)"
      tindex ezaxi:0xfc4cf980 %l 0x8123120 0x123120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S6_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_POLARITY_LOW (at 0x12313)"
      tindex ezaxi:0xfc4cf980 %l 0x8123130 0x123130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S6_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_LATCHED_CLR (at 0x12314)"
      tindex ezaxi:0xfc4cf980 %l 0x8123140 0x123140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_EN_SET (at 0x12315)"
      tindex ezaxi:0xfc4cf980 %l 0x8123150 0x123150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S6_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_EN_CLR (at 0x12316)"
      tindex ezaxi:0xfc4cf980 %l 0x8123160 0x123160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S6_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_LATCHED_STS (at 0x12318)"
      tindex ezaxi:0xfc4cf980 %l 0x8123180 0x123180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S6_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_PENDING_STS (at 0x12319)"
      tindex ezaxi:0xfc4cf980 %l 0x8123190 0x123190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S6_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_MID_SEL (at 0x1231a)"
      tindex ezaxi:0xfc4cf980 %l 0x81231a0 0x1231a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S6_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_PRIORITY (at 0x1231b)"
      tindex ezaxi:0xfc4cf980 %l 0x81231b0 0x1231b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VOLTAGE_CTL1 (at 0x12340)"
      tindex ezaxi:0xfc4cf980 %l 0x8123400 0x123400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VOLTAGE_CTL2 (at 0x12341)"
      tindex ezaxi:0xfc4cf980 %l 0x8123410 0x123410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S6_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VSET_VALID (at 0x12342)"
      tindex ezaxi:0xfc4cf980 %l 0x8123420 0x123420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S6_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MPPFM_VOFFSET (at 0x12344)"
      tindex ezaxi:0xfc4cf980 %l 0x8123440 0x123440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S6_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MODE_CTL (at 0x12345)"
      tindex ezaxi:0xfc4cf980 %l 0x8123450 0x123450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S6_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_EN_CTL (at 0x12346)"
      tindex ezaxi:0xfc4cf980 %l 0x8123460 0x123460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S6_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PD_CTL (at 0x12348)"
      tindex ezaxi:0xfc4cf980 %l 0x8123480 0x123480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S6_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_FREQ_CTL (at 0x12350)"
      tindex ezaxi:0xfc4cf980 %l 0x8123500 0x123500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S6_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MULTIPHASE_CTL (at 0x12351)"
      tindex ezaxi:0xfc4cf980 %l 0x8123510 0x123510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S6_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PHASE_CTL (at 0x12352)"
      tindex ezaxi:0xfc4cf980 %l 0x8123520 0x123520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S6_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PHASE_ID (at 0x12353)"
      tindex ezaxi:0xfc4cf980 %l 0x8123530 0x123530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S6_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PHASE_CNT_MAX (at 0x12354)"
      tindex ezaxi:0xfc4cf980 %l 0x8123540 0x123540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S6_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PH_READY (at 0x12355)"
      tindex ezaxi:0xfc4cf980 %l 0x8123550 0x123550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S6_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_SS_CTL (at 0x12360)"
      tindex ezaxi:0xfc4cf980 %l 0x8123600 0x123600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S6_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VS_CTL (at 0x12361)"
      tindex ezaxi:0xfc4cf980 %l 0x8123610 0x123610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S6_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CORR_CFG (at 0x12362)"
      tindex ezaxi:0xfc4cf980 %l 0x8123620 0x123620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S6_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_RAMP_CFG (at 0x12363)"
      tindex ezaxi:0xfc4cf980 %l 0x8123630 0x123630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S6_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_COMPENS_CFG (at 0x12364)"
      tindex ezaxi:0xfc4cf980 %l 0x8123640 0x123640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S6_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_VREG_MON (at 0x12365)"
      tindex ezaxi:0xfc4cf980 %l 0x8123650 0x123650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S6_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_VREG_OCP (at 0x12366)"
      tindex ezaxi:0xfc4cf980 %l 0x8123660 0x123660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S6_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_PFM_COMP (at 0x12367)"
      tindex ezaxi:0xfc4cf980 %l 0x8123670 0x123670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S6_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_UL_LL_CTL (at 0x12368)"
      tindex ezaxi:0xfc4cf980 %l 0x8123680 0x123680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S6_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VSET_ULS (at 0x12369)"
      tindex ezaxi:0xfc4cf980 %l 0x8123690 0x123690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S6_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_ULS_VALID (at 0x1236a)"
      tindex ezaxi:0xfc4cf980 %l 0x81236a0 0x1236a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S6_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VSET_LLS (at 0x1236b)"
      tindex ezaxi:0xfc4cf980 %l 0x81236b0 0x1236b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S6_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_LLS_VALID (at 0x1236c)"
      tindex ezaxi:0xfc4cf980 %l 0x81236c0 0x1236c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S6_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_GPL_HI (at 0x1236d)"
      tindex ezaxi:0xfc4cf980 %l 0x81236d0 0x1236d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S6_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_GPL_LO (at 0x1236e)"
      tindex ezaxi:0xfc4cf980 %l 0x81236e0 0x1236e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S6_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_FB_FILT_CFG (at 0x1236f)"
      tindex ezaxi:0xfc4cf980 %l 0x81236f0 0x1236f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S6_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VDIP_CFG (at 0x12371)"
      tindex ezaxi:0xfc4cf980 %l 0x8123710 0x123710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S6_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MPH_STROBE (at 0x12379)"
      tindex ezaxi:0xfc4cf980 %l 0x8123790 0x123790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S6_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MODE_FSM_MASK (at 0x123a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a00 0x123a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S6_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MODE_FSM_WAITS_1 (at 0x123a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a10 0x123a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S6_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MODE_FSM_WAIT_2 (at 0x123a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a20 0x123a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S6_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_GATE_DRV_MUX (at 0x123a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a30 0x123a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S6_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CORR_DUTY_MUX (at 0x123a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a40 0x123a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S6_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_EN_OPTIONS_DFT_1 (at 0x123a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a50 0x123a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S6_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_EN_OPTIONS_DFT_2 (at 0x123a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a60 0x123a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S6_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MPHASE_IDAC (at 0x123a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8123a70 0x123a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S6_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_ANTI_ESL_CFG_1 (at 0x123ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8123ac0 0x123ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_ANTI_ESL_CFG_2 (at 0x123ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8123ad0 0x123ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S6_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_ATEST1 (at 0x123b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b00 0x123b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S6_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_ATEST2 (at 0x123b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b10 0x123b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S6_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_ATEST3 (at 0x123b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b20 0x123b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S6_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_ATEST4 (at 0x123b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b30 0x123b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S6_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_DTEST1 (at 0x123b4)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b40 0x123b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S6_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_DTEST2 (at 0x123b5)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b50 0x123b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S6_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_DTEST3 (at 0x123b6)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b60 0x123b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S6_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CFG_DTEST4 (at 0x123b7)"
      tindex ezaxi:0xfc4cf980 %l 0x8123b70 0x123b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S6_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_GANG_CTL1 (at 0x123c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8123c00 0x123c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_GANG_CTL2 (at 0x123c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8123c10 0x123c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S6_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_SEC_ACCESS (at 0x123d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8123d00 0x123d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PERPH_RESET_CTL1 (at 0x123d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8123d80 0x123d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PERPH_RESET_CTL2 (at 0x123d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8123d90 0x123d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PERPH_RESET_CTL3 (at 0x123da)"
      tindex ezaxi:0xfc4cf980 %l 0x8123da0 0x123da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PERPH_RESET_CTL4 (at 0x123db)"
      tindex ezaxi:0xfc4cf980 %l 0x8123db0 0x123db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S6_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_TEST1 (at 0x123e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8123e00 0x123e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S6_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_INT_TEST_VAL (at 0x123e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8123e10 0x123e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S6_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CAL_REQUEST (at 0x123e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8123e20 0x123e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S6_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CAL_CTL_1 (at 0x123e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8123e30 0x123e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S6_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CAL_CTL_2 (at 0x123e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8123e40 0x123e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S6_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_MAN_CAL_VAL (at 0x123e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8123e50 0x123e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S6_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_REFDAC_CAL_VAL (at 0x123ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8123ea0 0x123ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S6_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_VDIP_CAL_VAL (at 0x123eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8123eb0 0x123eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S6_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_IDAC_CAL_VAL (at 0x123ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8123ec0 0x123ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S6_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_CORR_CAL_VAL (at 0x123ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8123ed0 0x123ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S6_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PWM_CAL_VAL (at 0x123ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8123ee0 0x123ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S6_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_PFM_CAL_VAL (at 0x123ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8123ef0 0x123ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S6_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_TRIM_NUM (at 0x123f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8123f00 0x123f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S6_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_REFDAC_TRIM (at 0x123f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8123f10 0x123f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S6_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_CTRL_RAMP_TRIM (at 0x123f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8123f20 0x123f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S6_FREQ"
  tree "S6_FREQ"
    tree "S6_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_REVISION1 (at 0x12500)"
      tindex ezaxi:0xfc4cf980 %l 0x8125000 0x125000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_REVISION2 (at 0x12501)"
      tindex ezaxi:0xfc4cf980 %l 0x8125010 0x125010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_PERPH_TYPE (at 0x12504)"
      tindex ezaxi:0xfc4cf980 %l 0x8125040 0x125040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_PERPH_SUBTYPE (at 0x12505)"
      tindex ezaxi:0xfc4cf980 %l 0x8125050 0x125050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_CLK_ENABLE (at 0x12546)"
      tindex ezaxi:0xfc4cf980 %l 0x8125460 0x125460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S6_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_CLK_DIV (at 0x12550)"
      tindex ezaxi:0xfc4cf980 %l 0x8125500 0x125500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S6_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_CLK_PHASE (at 0x12551)"
      tindex ezaxi:0xfc4cf980 %l 0x8125510 0x125510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S6_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_GANG_CTL1 (at 0x125c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8125c00 0x125c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_GANG_CTL2 (at 0x125c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8125c10 0x125c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S6_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_SEC_ACCESS (at 0x125d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8125d00 0x125d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_PERPH_RESET_CTL2 (at 0x125d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8125d90 0x125d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_PERPH_RESET_CTL3 (at 0x125da)"
      tindex ezaxi:0xfc4cf980 %l 0x8125da0 0x125da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_PERPH_RESET_CTL4 (at 0x125db)"
      tindex ezaxi:0xfc4cf980 %l 0x8125db0 0x125db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S6_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_FREQ_TEST1 (at 0x125e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8125e20 0x125e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S6_PS"
  tree "S6_PS"
    tree "S6_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_REVISION1 (at 0x12400)"
      tindex ezaxi:0xfc4cf980 %l 0x8124000 0x124000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_REVISION2 (at 0x12401)"
      tindex ezaxi:0xfc4cf980 %l 0x8124010 0x124010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_REVISION3 (at 0x12402)"
      tindex ezaxi:0xfc4cf980 %l 0x8124020 0x124020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_REVISION4 (at 0x12403)"
      tindex ezaxi:0xfc4cf980 %l 0x8124030 0x124030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PERPH_TYPE (at 0x12404)"
      tindex ezaxi:0xfc4cf980 %l 0x8124040 0x124040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PERPH_SUBTYPE (at 0x12405)"
      tindex ezaxi:0xfc4cf980 %l 0x8124050 0x124050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_STATUS_1 (at 0x12408)"
      tindex ezaxi:0xfc4cf980 %l 0x8124080 0x124080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S6_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_STATUS_2 (at 0x12409)"
      tindex ezaxi:0xfc4cf980 %l 0x8124090 0x124090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S6_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_VOLTAGE_CTL1 (at 0x12440)"
      tindex ezaxi:0xfc4cf980 %l 0x8124400 0x124400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S6_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_VOLTAGE_CTL2 (at 0x12441)"
      tindex ezaxi:0xfc4cf980 %l 0x8124410 0x124410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S6_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MODE_CTL (at 0x12445)"
      tindex ezaxi:0xfc4cf980 %l 0x8124450 0x124450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S6_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_FREQ_CTL (at 0x12450)"
      tindex ezaxi:0xfc4cf980 %l 0x8124500 0x124500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S6_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MULTIPHASE_CTL (at 0x12451)"
      tindex ezaxi:0xfc4cf980 %l 0x8124510 0x124510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S6_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PHASE_CTL (at 0x12452)"
      tindex ezaxi:0xfc4cf980 %l 0x8124520 0x124520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S6_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PHASE_ID (at 0x12453)"
      tindex ezaxi:0xfc4cf980 %l 0x8124530 0x124530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S6_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PHASE_CNT_MAX (at 0x12454)"
      tindex ezaxi:0xfc4cf980 %l 0x8124540 0x124540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S6_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PWM_CL_CTL (at 0x12460)"
      tindex ezaxi:0xfc4cf980 %l 0x8124600 0x124600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S6_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LPM_CL_CTL (at 0x12461)"
      tindex ezaxi:0xfc4cf980 %l 0x8124610 0x124610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S6_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_AUTO_CTL_1 (at 0x12462)"
      tindex ezaxi:0xfc4cf980 %l 0x8124620 0x124620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S6_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LPM_ADC_VAL (at 0x12463)"
      tindex ezaxi:0xfc4cf980 %l 0x8124630 0x124630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S6_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LPM_ADC_CTL (at 0x12464)"
      tindex ezaxi:0xfc4cf980 %l 0x8124640 0x124640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ACTIVITY_DETECT (at 0x12465)"
      tindex ezaxi:0xfc4cf980 %l 0x8124650 0x124650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LPM_CFG (at 0x12468)"
      tindex ezaxi:0xfc4cf980 %l 0x8124680 0x124680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S6_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_FSM_MINON_CFG (at 0x12470)"
      tindex ezaxi:0xfc4cf980 %l 0x8124700 0x124700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S6_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ZX_CAL_CFG (at 0x12473)"
      tindex ezaxi:0xfc4cf980 %l 0x8124730 0x124730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S6_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_NONOVLAP_CFG (at 0x12474)"
      tindex ezaxi:0xfc4cf980 %l 0x8124740 0x124740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S6_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ADC_FRONT_CFG (at 0x12475)"
      tindex ezaxi:0xfc4cf980 %l 0x8124750 0x124750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_P0_LUT_IN (at 0x12478)"
      tindex ezaxi:0xfc4cf980 %l 0x8124780 0x124780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S6_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MPH_STROBE (at 0x12479)"
      tindex ezaxi:0xfc4cf980 %l 0x8124790 0x124790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S6_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_OUT (at 0x1247a)"
      tindex ezaxi:0xfc4cf980 %l 0x81247a0 0x1247a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S6_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ADC_OUT (at 0x1247b)"
      tindex ezaxi:0xfc4cf980 %l 0x81247b0 0x1247b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S6_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ADC_FRC (at 0x1247c)"
      tindex ezaxi:0xfc4cf980 %l 0x81247c0 0x1247c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S6_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MP_CORR_DFT (at 0x1247d)"
      tindex ezaxi:0xfc4cf980 %l 0x81247d0 0x1247d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S6_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_DAC_DATA (at 0x1247e)"
      tindex ezaxi:0xfc4cf980 %l 0x81247e0 0x1247e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S6_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_DAC_FRC (at 0x1247f)"
      tindex ezaxi:0xfc4cf980 %l 0x81247f0 0x1247f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S6_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_DAC_PT_0 (at 0x12480)"
      tindex ezaxi:0xfc4cf980 %l 0x8124800 0x124800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S6_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_DAC_PT_1 (at 0x12481)"
      tindex ezaxi:0xfc4cf980 %l 0x8124810 0x124810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S6_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_DAC_PT_2 (at 0x12482)"
      tindex ezaxi:0xfc4cf980 %l 0x8124820 0x124820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S6_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_DAC_PT_3 (at 0x12483)"
      tindex ezaxi:0xfc4cf980 %l 0x8124830 0x124830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S6_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_ADC_PT_1 (at 0x12487)"
      tindex ezaxi:0xfc4cf980 %l 0x8124870 0x124870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S6_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_ADC_PT_2 (at 0x12488)"
      tindex ezaxi:0xfc4cf980 %l 0x8124880 0x124880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S6_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_ADC_PT_3 (at 0x12489)"
      tindex ezaxi:0xfc4cf980 %l 0x8124890 0x124890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S6_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_SLOPE_HI_0 (at 0x1248c)"
      tindex ezaxi:0xfc4cf980 %l 0x81248c0 0x1248c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S6_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_SLOPE_LO_0 (at 0x1248d)"
      tindex ezaxi:0xfc4cf980 %l 0x81248d0 0x1248d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S6_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_SLOPE_HI_1 (at 0x1248e)"
      tindex ezaxi:0xfc4cf980 %l 0x81248e0 0x1248e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S6_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_SLOPE_LO_1 (at 0x1248f)"
      tindex ezaxi:0xfc4cf980 %l 0x81248f0 0x1248f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S6_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_SLOPE_HI_2 (at 0x12490)"
      tindex ezaxi:0xfc4cf980 %l 0x8124900 0x124900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S6_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_LUT_SLOPE_LO_2 (at 0x12491)"
      tindex ezaxi:0xfc4cf980 %l 0x8124910 0x124910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MPHASE_PI_CFG1 (at 0x12496)"
      tindex ezaxi:0xfc4cf980 %l 0x8124960 0x124960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MPHASE_PI_CFG4 (at 0x12497)"
      tindex ezaxi:0xfc4cf980 %l 0x8124970 0x124970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S6_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MPHASE_PHASE_CNT (at 0x12498)"
      tindex ezaxi:0xfc4cf980 %l 0x8124980 0x124980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_EN_OPTIONS_DFT_1 (at 0x124a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8124a80 0x124a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S6_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_EN_OPTIONS_DFT_2 (at 0x124a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8124a90 0x124a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S6_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ZX_ADAPT_CTL (at 0x124aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8124aa0 0x124aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S6_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ZX_ADAPT_VAL (at 0x124ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8124ab0 0x124ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S6_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ADC_CLK_CTL (at 0x124ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8124ac0 0x124ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S6_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ATEST12 (at 0x124b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8124b00 0x124b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S6_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ATEST34 (at 0x124b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8124b10 0x124b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S6_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_DTEST12 (at 0x124b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8124b20 0x124b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S6_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_DTEST43 (at 0x124b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8124b30 0x124b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S6_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_GANG_CTL1 (at 0x124c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8124c00 0x124c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_GANG_CTL2 (at 0x124c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8124c10 0x124c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S6_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_SEC_ACCESS (at 0x124d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8124d00 0x124d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PERPH_RESET_CTL2 (at 0x124d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8124d90 0x124d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PERPH_RESET_CTL3 (at 0x124da)"
      tindex ezaxi:0xfc4cf980 %l 0x8124da0 0x124da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_PERPH_RESET_CTL4 (at 0x124db)"
      tindex ezaxi:0xfc4cf980 %l 0x8124db0 0x124db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S6_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_CAL_REQUEST (at 0x124e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8124e20 0x124e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S6_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_MAN_CAL_VAL (at 0x124e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8124e50 0x124e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S6_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_REPLICA_CFG (at 0x124e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8124e60 0x124e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S6_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_CAL_CTL_1 (at 0x124e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8124e70 0x124e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S6_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_CAL_CTL_2 (at 0x124e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8124e80 0x124e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S6_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_REPLICA_CAL_VAL (at 0x124ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8124ea0 0x124ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S6_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_DACMID_BUF_CAL_VAL (at 0x124ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8124ec0 0x124ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S6_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_FRONT_BUF_CAL_VAL (at 0x124ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8124ed0 0x124ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S6_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_CL_CAL_VAL (at 0x124ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8124ee0 0x124ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S6_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ZX_CAL_VAL (at 0x124ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8124ef0 0x124ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S6_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_TRIM_NUM (at 0x124f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8124f00 0x124f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S6_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_ZX_TRIM (at 0x124f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8124f10 0x124f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S6_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_CL_TRIM (at 0x124f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8124f20 0x124f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S6_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S6_PS_REPLICA_TRIM (at 0x124f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8124f30 0x124f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S7_CTRL"
  tree "S7_CTRL"
    tree "S7_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_REVISION1 (at 0x12600)"
      tindex ezaxi:0xfc4cf980 %l 0x8126000 0x126000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_REVISION2 (at 0x12601)"
      tindex ezaxi:0xfc4cf980 %l 0x8126010 0x126010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_REVISION3 (at 0x12602)"
      tindex ezaxi:0xfc4cf980 %l 0x8126020 0x126020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_REVISION4 (at 0x12603)"
      tindex ezaxi:0xfc4cf980 %l 0x8126030 0x126030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PERPH_TYPE (at 0x12604)"
      tindex ezaxi:0xfc4cf980 %l 0x8126040 0x126040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PERPH_SUBTYPE (at 0x12605)"
      tindex ezaxi:0xfc4cf980 %l 0x8126050 0x126050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_CTRL_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_STATUS (at 0x12608)"
      tindex ezaxi:0xfc4cf980 %l 0x8126080 0x126080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S7_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_RT_STS (at 0x12610)"
      tindex ezaxi:0xfc4cf980 %l 0x8126100 0x126100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_SET_TYPE (at 0x12611)"
      tindex ezaxi:0xfc4cf980 %l 0x8126110 0x126110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_POLARITY_HIGH (at 0x12612)"
      tindex ezaxi:0xfc4cf980 %l 0x8126120 0x126120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_POLARITY_LOW (at 0x12613)"
      tindex ezaxi:0xfc4cf980 %l 0x8126130 0x126130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_LATCHED_CLR (at 0x12614)"
      tindex ezaxi:0xfc4cf980 %l 0x8126140 0x126140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_EN_SET (at 0x12615)"
      tindex ezaxi:0xfc4cf980 %l 0x8126150 0x126150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_EN_CLR (at 0x12616)"
      tindex ezaxi:0xfc4cf980 %l 0x8126160 0x126160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_LATCHED_STS (at 0x12618)"
      tindex ezaxi:0xfc4cf980 %l 0x8126180 0x126180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_PENDING_STS (at 0x12619)"
      tindex ezaxi:0xfc4cf980 %l 0x8126190 0x126190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S7_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_MID_SEL (at 0x1261a)"
      tindex ezaxi:0xfc4cf980 %l 0x81261a0 0x1261a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S7_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_PRIORITY (at 0x1261b)"
      tindex ezaxi:0xfc4cf980 %l 0x81261b0 0x1261b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_VOLTAGE_CTL1 (at 0x12640)"
      tindex ezaxi:0xfc4cf980 %l 0x8126400 0x126400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_VOLTAGE_CTL2 (at 0x12641)"
      tindex ezaxi:0xfc4cf980 %l 0x8126410 0x126410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S7_CTRL_PFM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PFM_CTL (at 0x12644)"
      tindex ezaxi:0xfc4cf980 %l 0x8126440 0x126440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S7_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_MODE_CTL (at 0x12645)"
      tindex ezaxi:0xfc4cf980 %l 0x8126450 0x126450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S7_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_EN_CTL (at 0x12646)"
      tindex ezaxi:0xfc4cf980 %l 0x8126460 0x126460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S7_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PD_CTL (at 0x12648)"
      tindex ezaxi:0xfc4cf980 %l 0x8126480 0x126480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S7_CTRL_COMP_CAP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_COMP_CAP_CTL (at 0x12651)"
      tindex ezaxi:0xfc4cf980 %l 0x8126510 0x126510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S7_CTRL_GM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_GM_CTL (at 0x12652)"
      tindex ezaxi:0xfc4cf980 %l 0x8126520 0x126520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S7_CTRL_RZ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_RZ_CTL (at 0x12653)"
      tindex ezaxi:0xfc4cf980 %l 0x8126530 0x126530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S7_CTRL_ISNS_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_ISNS_CTRL (at 0x12655)"
      tindex ezaxi:0xfc4cf980 %l 0x8126550 0x126550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S7_CTRL_SAW_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_SAW_CTL (at 0x12656)"
      tindex ezaxi:0xfc4cf980 %l 0x8126560 0x126560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S7_CTRL_DMAX_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_DMAX_CTL (at 0x12658)"
      tindex ezaxi:0xfc4cf980 %l 0x8126580 0x126580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S7_CTRL_PULSE_SKIP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PULSE_SKIP_CTL (at 0x12659)"
      tindex ezaxi:0xfc4cf980 %l 0x8126590 0x126590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S7_CTRL_PULSE_SKIP_THRES"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PULSE_SKIP_THRES (at 0x1265a)"
      tindex ezaxi:0xfc4cf980 %l 0x81265a0 0x1265a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S7_CTRL_AUTO_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_AUTO_MODE_CTL (at 0x1265b)"
      tindex ezaxi:0xfc4cf980 %l 0x81265b0 0x1265b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S7_CTRL_INZERO_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INZERO_COUNT_CTL (at 0x1265c)"
      tindex ezaxi:0xfc4cf980 %l 0x81265c0 0x1265c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S7_CTRL_PFM_COUNT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PFM_COUNT_CTL (at 0x1265d)"
      tindex ezaxi:0xfc4cf980 %l 0x81265d0 0x1265d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S7_CTRL_PS_VGA_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PS_VGA_CTL (at 0x1265e)"
      tindex ezaxi:0xfc4cf980 %l 0x81265e0 0x1265e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S7_CTRL_STEPPER_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_STEPPER_SS_CTL (at 0x12660)"
      tindex ezaxi:0xfc4cf980 %l 0x8126600 0x126600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S7_CTRL_STEPPER_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_STEPPER_VS_CTL (at 0x12661)"
      tindex ezaxi:0xfc4cf980 %l 0x8126610 0x126610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S7_CTRL_FT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_FT_CTL (at 0x12662)"
      tindex ezaxi:0xfc4cf980 %l 0x8126620 0x126620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S7_CTRL_QMODE_SHADOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_QMODE_SHADOW (at 0x12663)"
      tindex ezaxi:0xfc4cf980 %l 0x8126630 0x126630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S7_CTRL_UL_LL_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_UL_LL_CTRL (at 0x12668)"
      tindex ezaxi:0xfc4cf980 %l 0x8126680 0x126680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S7_CTRL_UL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_UL_VOLTAGE (at 0x12669)"
      tindex ezaxi:0xfc4cf980 %l 0x8126690 0x126690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S7_CTRL_LL_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_LL_VOLTAGE (at 0x1266b)"
      tindex ezaxi:0xfc4cf980 %l 0x81266b0 0x1266b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S7_CTRL_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_OCP (at 0x1266c)"
      tindex ezaxi:0xfc4cf980 %l 0x81266c0 0x1266c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE                                   = " "0 (OCP_FALSE),1 (OCP_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_RIDE                                = " "0 (OCP_TEST_MODE_FALSE),1 (OCP_TEST_MODE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLK_DIV                                  = " "0 (OCP_STARTUP_CLK_DIV_BY_2_FALSE),1 (OCP_STARTUP_CLK_DIV_BY_2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPM                                      = " "0 (OCP_LPM_DURING_PFM_FALSE),1 (OCP_LPM_DURING_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IPLIMIT_COUNT                            = " "0 (OCP_IPLIMT_COUNT_4),1 (OCP_IPLIMIT_COUNT_8)"
    tree.end
    tree "S7_CTRL_CTLR_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_CTLR_MISC (at 0x1267a)"
      tindex ezaxi:0xfc4cf980 %l 0x81267a0 0x1267a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S7_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_SEC_ACCESS (at 0x126d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8126d00 0x126d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PERPH_RESET_CTL1 (at 0x126d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8126d80 0x126d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PERPH_RESET_CTL2 (at 0x126d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8126d90 0x126d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PERPH_RESET_CTL3 (at 0x126da)"
      tindex ezaxi:0xfc4cf980 %l 0x8126da0 0x126da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_PERPH_RESET_CTL4 (at 0x126db)"
      tindex ezaxi:0xfc4cf980 %l 0x8126db0 0x126db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S7_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_TEST1 (at 0x126e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8126e00 0x126e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S7_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_INT_TEST_VAL (at 0x126e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8126e10 0x126e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S7_CTRL_CTLR_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_CTLR_TEST (at 0x126e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8126e20 0x126e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_OCP_DETECT),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S7_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_TRIM_NUM (at 0x126f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8126f00 0x126f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S7_CTRL_CTL_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_CTL_TRIM1 (at 0x126f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8126f10 0x126f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S7_CTRL_CTL_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_CTL_TRIM2 (at 0x126f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8126f20 0x126f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S7_CTRL_CTL_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_CTL_TRIM3 (at 0x126f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8126f30 0x126f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S7_CTRL_CTL_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_CTRL_CTL_TRIM4 (at 0x126f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8126f40 0x126f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S7_FREQ"
  tree "S7_FREQ"
    tree "S7_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_REVISION1 (at 0x12800)"
      tindex ezaxi:0xfc4cf980 %l 0x8128000 0x128000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_REVISION2 (at 0x12801)"
      tindex ezaxi:0xfc4cf980 %l 0x8128010 0x128010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_PERPH_TYPE (at 0x12804)"
      tindex ezaxi:0xfc4cf980 %l 0x8128040 0x128040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_PERPH_SUBTYPE (at 0x12805)"
      tindex ezaxi:0xfc4cf980 %l 0x8128050 0x128050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_CLK_ENABLE (at 0x12846)"
      tindex ezaxi:0xfc4cf980 %l 0x8128460 0x128460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S7_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_CLK_DIV (at 0x12850)"
      tindex ezaxi:0xfc4cf980 %l 0x8128500 0x128500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S7_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_CLK_PHASE (at 0x12851)"
      tindex ezaxi:0xfc4cf980 %l 0x8128510 0x128510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S7_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_GANG_CTL1 (at 0x128c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8128c00 0x128c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S7_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_GANG_CTL2 (at 0x128c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8128c10 0x128c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S7_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_SEC_ACCESS (at 0x128d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8128d00 0x128d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_PERPH_RESET_CTL2 (at 0x128d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8128d90 0x128d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_PERPH_RESET_CTL3 (at 0x128da)"
      tindex ezaxi:0xfc4cf980 %l 0x8128da0 0x128da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_PERPH_RESET_CTL4 (at 0x128db)"
      tindex ezaxi:0xfc4cf980 %l 0x8128db0 0x128db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S7_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_FREQ_TEST1 (at 0x128e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8128e20 0x128e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S7_PS"
  tree "S7_PS"
    tree "S7_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_REVISION1 (at 0x12700)"
      tindex ezaxi:0xfc4cf980 %l 0x8127000 0x127000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_REVISION2 (at 0x12701)"
      tindex ezaxi:0xfc4cf980 %l 0x8127010 0x127010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_REVISION3 (at 0x12702)"
      tindex ezaxi:0xfc4cf980 %l 0x8127020 0x127020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_REVISION4 (at 0x12703)"
      tindex ezaxi:0xfc4cf980 %l 0x8127030 0x127030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PERPH_TYPE (at 0x12704)"
      tindex ezaxi:0xfc4cf980 %l 0x8127040 0x127040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PERPH_SUBTYPE (at 0x12705)"
      tindex ezaxi:0xfc4cf980 %l 0x8127050 0x127050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PWM_CURRENT_LIM_CTL (at 0x1274a)"
      tindex ezaxi:0xfc4cf980 %l 0x81274a0 0x1274a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S7_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PFM_CURRENT_LIM_CTL (at 0x1274b)"
      tindex ezaxi:0xfc4cf980 %l 0x81274b0 0x1274b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S7_PS_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_SOFT_START_CTL (at 0x1274c)"
      tindex ezaxi:0xfc4cf980 %l 0x81274c0 0x1274c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S7_PS_SWITCH_SIZE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_SWITCH_SIZE_CTL (at 0x12770)"
      tindex ezaxi:0xfc4cf980 %l 0x8127700 0x127700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S7_PS_DEAD_TIME_CTRL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_DEAD_TIME_CTRL1 (at 0x12771)"
      tindex ezaxi:0xfc4cf980 %l 0x8127710 0x127710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S7_PS_DEAD_TIME_CTRL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_DEAD_TIME_CTRL2 (at 0x12772)"
      tindex ezaxi:0xfc4cf980 %l 0x8127720 0x127720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S7_PS_BLNK_TIME_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_BLNK_TIME_CTL (at 0x12773)"
      tindex ezaxi:0xfc4cf980 %l 0x8127730 0x127730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S7_PS_INZERO_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_INZERO_CTL (at 0x12774)"
      tindex ezaxi:0xfc4cf980 %l 0x8127740 0x127740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S7_PS_DIG_FSM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_DIG_FSM_CTL (at 0x12775)"
      tindex ezaxi:0xfc4cf980 %l 0x8127750 0x127750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S7_PS_PWR_STG_MISC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PWR_STG_MISC (at 0x12779)"
      tindex ezaxi:0xfc4cf980 %l 0x8127790 0x127790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S7_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_SEC_ACCESS (at 0x127d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8127d00 0x127d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PERPH_RESET_CTL2 (at 0x127d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8127d90 0x127d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PERPH_RESET_CTL3 (at 0x127da)"
      tindex ezaxi:0xfc4cf980 %l 0x8127da0 0x127da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PERPH_RESET_CTL4 (at 0x127db)"
      tindex ezaxi:0xfc4cf980 %l 0x8127db0 0x127db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S7_PS_FORCE_FET_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_FORCE_FET_TEST (at 0x127e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8127e30 0x127e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S7_PS_PWR_STG_TEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PWR_STG_TEST (at 0x127e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8127e40 0x127e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S7_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_TRIM_NUM (at 0x127f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8127f00 0x127f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S7_PS_PS_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PS_TRIM1 (at 0x127f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8127f10 0x127f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S7_PS_PS_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S7_PS_PS_TRIM2 (at 0x127f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8127f20 0x127f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S8_CTRL"
  tree "S8_CTRL"
    tree "S8_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_REVISION1 (at 0x12900)"
      tindex ezaxi:0xfc4cf980 %l 0x8129000 0x129000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_REVISION2 (at 0x12901)"
      tindex ezaxi:0xfc4cf980 %l 0x8129010 0x129010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_REVISION3 (at 0x12902)"
      tindex ezaxi:0xfc4cf980 %l 0x8129020 0x129020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_REVISION4 (at 0x12903)"
      tindex ezaxi:0xfc4cf980 %l 0x8129030 0x129030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PERPH_TYPE (at 0x12904)"
      tindex ezaxi:0xfc4cf980 %l 0x8129040 0x129040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PERPH_SUBTYPE (at 0x12905)"
      tindex ezaxi:0xfc4cf980 %l 0x8129050 0x129050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_STATUS_1 (at 0x12908)"
      tindex ezaxi:0xfc4cf980 %l 0x8129080 0x129080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S8_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_STATUS_2 (at 0x12909)"
      tindex ezaxi:0xfc4cf980 %l 0x8129090 0x129090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S8_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_STATUS_3 (at 0x1290a)"
      tindex ezaxi:0xfc4cf980 %l 0x81290a0 0x1290a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S8_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_STATUS_4 (at 0x1290b)"
      tindex ezaxi:0xfc4cf980 %l 0x81290b0 0x1290b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S8_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_STATUS_5 (at 0x1290c)"
      tindex ezaxi:0xfc4cf980 %l 0x81290c0 0x1290c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S8_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_RT_STS (at 0x12910)"
      tindex ezaxi:0xfc4cf980 %l 0x8129100 0x129100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S8_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_SET_TYPE (at 0x12911)"
      tindex ezaxi:0xfc4cf980 %l 0x8129110 0x129110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S8_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_POLARITY_HIGH (at 0x12912)"
      tindex ezaxi:0xfc4cf980 %l 0x8129120 0x129120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S8_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_POLARITY_LOW (at 0x12913)"
      tindex ezaxi:0xfc4cf980 %l 0x8129130 0x129130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S8_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_LATCHED_CLR (at 0x12914)"
      tindex ezaxi:0xfc4cf980 %l 0x8129140 0x129140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_EN_SET (at 0x12915)"
      tindex ezaxi:0xfc4cf980 %l 0x8129150 0x129150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S8_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_EN_CLR (at 0x12916)"
      tindex ezaxi:0xfc4cf980 %l 0x8129160 0x129160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S8_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_LATCHED_STS (at 0x12918)"
      tindex ezaxi:0xfc4cf980 %l 0x8129180 0x129180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S8_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_PENDING_STS (at 0x12919)"
      tindex ezaxi:0xfc4cf980 %l 0x8129190 0x129190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S8_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_MID_SEL (at 0x1291a)"
      tindex ezaxi:0xfc4cf980 %l 0x81291a0 0x1291a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S8_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_PRIORITY (at 0x1291b)"
      tindex ezaxi:0xfc4cf980 %l 0x81291b0 0x1291b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VOLTAGE_CTL1 (at 0x12940)"
      tindex ezaxi:0xfc4cf980 %l 0x8129400 0x129400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VOLTAGE_CTL2 (at 0x12941)"
      tindex ezaxi:0xfc4cf980 %l 0x8129410 0x129410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S8_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VSET_VALID (at 0x12942)"
      tindex ezaxi:0xfc4cf980 %l 0x8129420 0x129420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S8_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MPPFM_VOFFSET (at 0x12944)"
      tindex ezaxi:0xfc4cf980 %l 0x8129440 0x129440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S8_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MODE_CTL (at 0x12945)"
      tindex ezaxi:0xfc4cf980 %l 0x8129450 0x129450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S8_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_EN_CTL (at 0x12946)"
      tindex ezaxi:0xfc4cf980 %l 0x8129460 0x129460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S8_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PD_CTL (at 0x12948)"
      tindex ezaxi:0xfc4cf980 %l 0x8129480 0x129480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S8_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_FREQ_CTL (at 0x12950)"
      tindex ezaxi:0xfc4cf980 %l 0x8129500 0x129500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S8_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MULTIPHASE_CTL (at 0x12951)"
      tindex ezaxi:0xfc4cf980 %l 0x8129510 0x129510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S8_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PHASE_CTL (at 0x12952)"
      tindex ezaxi:0xfc4cf980 %l 0x8129520 0x129520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S8_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PHASE_ID (at 0x12953)"
      tindex ezaxi:0xfc4cf980 %l 0x8129530 0x129530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S8_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PHASE_CNT_MAX (at 0x12954)"
      tindex ezaxi:0xfc4cf980 %l 0x8129540 0x129540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S8_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PH_READY (at 0x12955)"
      tindex ezaxi:0xfc4cf980 %l 0x8129550 0x129550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S8_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_SS_CTL (at 0x12960)"
      tindex ezaxi:0xfc4cf980 %l 0x8129600 0x129600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S8_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VS_CTL (at 0x12961)"
      tindex ezaxi:0xfc4cf980 %l 0x8129610 0x129610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S8_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CORR_CFG (at 0x12962)"
      tindex ezaxi:0xfc4cf980 %l 0x8129620 0x129620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S8_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_RAMP_CFG (at 0x12963)"
      tindex ezaxi:0xfc4cf980 %l 0x8129630 0x129630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S8_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_COMPENS_CFG (at 0x12964)"
      tindex ezaxi:0xfc4cf980 %l 0x8129640 0x129640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S8_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_VREG_MON (at 0x12965)"
      tindex ezaxi:0xfc4cf980 %l 0x8129650 0x129650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S8_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_VREG_OCP (at 0x12966)"
      tindex ezaxi:0xfc4cf980 %l 0x8129660 0x129660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S8_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_PFM_COMP (at 0x12967)"
      tindex ezaxi:0xfc4cf980 %l 0x8129670 0x129670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S8_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_UL_LL_CTL (at 0x12968)"
      tindex ezaxi:0xfc4cf980 %l 0x8129680 0x129680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S8_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VSET_ULS (at 0x12969)"
      tindex ezaxi:0xfc4cf980 %l 0x8129690 0x129690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S8_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_ULS_VALID (at 0x1296a)"
      tindex ezaxi:0xfc4cf980 %l 0x81296a0 0x1296a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S8_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VSET_LLS (at 0x1296b)"
      tindex ezaxi:0xfc4cf980 %l 0x81296b0 0x1296b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S8_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_LLS_VALID (at 0x1296c)"
      tindex ezaxi:0xfc4cf980 %l 0x81296c0 0x1296c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S8_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_GPL_HI (at 0x1296d)"
      tindex ezaxi:0xfc4cf980 %l 0x81296d0 0x1296d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S8_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_GPL_LO (at 0x1296e)"
      tindex ezaxi:0xfc4cf980 %l 0x81296e0 0x1296e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S8_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_FB_FILT_CFG (at 0x1296f)"
      tindex ezaxi:0xfc4cf980 %l 0x81296f0 0x1296f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S8_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VDIP_CFG (at 0x12971)"
      tindex ezaxi:0xfc4cf980 %l 0x8129710 0x129710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S8_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MPH_STROBE (at 0x12979)"
      tindex ezaxi:0xfc4cf980 %l 0x8129790 0x129790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S8_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MODE_FSM_MASK (at 0x129a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a00 0x129a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S8_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MODE_FSM_WAITS_1 (at 0x129a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a10 0x129a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S8_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MODE_FSM_WAIT_2 (at 0x129a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a20 0x129a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S8_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_GATE_DRV_MUX (at 0x129a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a30 0x129a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S8_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CORR_DUTY_MUX (at 0x129a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a40 0x129a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S8_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_EN_OPTIONS_DFT_1 (at 0x129a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a50 0x129a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S8_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_EN_OPTIONS_DFT_2 (at 0x129a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a60 0x129a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S8_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MPHASE_IDAC (at 0x129a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8129a70 0x129a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S8_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_ANTI_ESL_CFG_1 (at 0x129ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8129ac0 0x129ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_ANTI_ESL_CFG_2 (at 0x129ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8129ad0 0x129ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S8_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_ATEST1 (at 0x129b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b00 0x129b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S8_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_ATEST2 (at 0x129b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b10 0x129b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S8_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_ATEST3 (at 0x129b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b20 0x129b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S8_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_ATEST4 (at 0x129b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b30 0x129b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S8_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_DTEST1 (at 0x129b4)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b40 0x129b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S8_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_DTEST2 (at 0x129b5)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b50 0x129b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S8_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_DTEST3 (at 0x129b6)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b60 0x129b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S8_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CFG_DTEST4 (at 0x129b7)"
      tindex ezaxi:0xfc4cf980 %l 0x8129b70 0x129b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S8_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_GANG_CTL1 (at 0x129c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8129c00 0x129c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_GANG_CTL2 (at 0x129c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8129c10 0x129c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S8_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_SEC_ACCESS (at 0x129d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8129d00 0x129d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PERPH_RESET_CTL1 (at 0x129d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8129d80 0x129d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PERPH_RESET_CTL2 (at 0x129d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8129d90 0x129d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PERPH_RESET_CTL3 (at 0x129da)"
      tindex ezaxi:0xfc4cf980 %l 0x8129da0 0x129da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PERPH_RESET_CTL4 (at 0x129db)"
      tindex ezaxi:0xfc4cf980 %l 0x8129db0 0x129db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S8_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_TEST1 (at 0x129e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8129e00 0x129e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S8_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_INT_TEST_VAL (at 0x129e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8129e10 0x129e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S8_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CAL_REQUEST (at 0x129e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8129e20 0x129e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S8_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CAL_CTL_1 (at 0x129e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8129e30 0x129e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S8_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CAL_CTL_2 (at 0x129e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8129e40 0x129e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S8_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_MAN_CAL_VAL (at 0x129e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8129e50 0x129e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S8_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_REFDAC_CAL_VAL (at 0x129ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8129ea0 0x129ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S8_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_VDIP_CAL_VAL (at 0x129eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8129eb0 0x129eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S8_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_IDAC_CAL_VAL (at 0x129ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8129ec0 0x129ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S8_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_CORR_CAL_VAL (at 0x129ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8129ed0 0x129ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S8_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PWM_CAL_VAL (at 0x129ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8129ee0 0x129ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S8_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_PFM_CAL_VAL (at 0x129ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8129ef0 0x129ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S8_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_TRIM_NUM (at 0x129f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8129f00 0x129f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S8_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_REFDAC_TRIM (at 0x129f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8129f10 0x129f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S8_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_CTRL_RAMP_TRIM (at 0x129f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8129f20 0x129f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S8_FREQ"
  tree "S8_FREQ"
    tree "S8_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_REVISION1 (at 0x12b00)"
      tindex ezaxi:0xfc4cf980 %l 0x812b000 0x12b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_REVISION2 (at 0x12b01)"
      tindex ezaxi:0xfc4cf980 %l 0x812b010 0x12b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_PERPH_TYPE (at 0x12b04)"
      tindex ezaxi:0xfc4cf980 %l 0x812b040 0x12b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_PERPH_SUBTYPE (at 0x12b05)"
      tindex ezaxi:0xfc4cf980 %l 0x812b050 0x12b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_CLK_ENABLE (at 0x12b46)"
      tindex ezaxi:0xfc4cf980 %l 0x812b460 0x12b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S8_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_CLK_DIV (at 0x12b50)"
      tindex ezaxi:0xfc4cf980 %l 0x812b500 0x12b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S8_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_CLK_PHASE (at 0x12b51)"
      tindex ezaxi:0xfc4cf980 %l 0x812b510 0x12b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S8_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_GANG_CTL1 (at 0x12bc0)"
      tindex ezaxi:0xfc4cf980 %l 0x812bc00 0x12bc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_GANG_CTL2 (at 0x12bc1)"
      tindex ezaxi:0xfc4cf980 %l 0x812bc10 0x12bc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S8_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_SEC_ACCESS (at 0x12bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x812bd00 0x12bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_PERPH_RESET_CTL2 (at 0x12bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x812bd90 0x12bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_PERPH_RESET_CTL3 (at 0x12bda)"
      tindex ezaxi:0xfc4cf980 %l 0x812bda0 0x12bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_PERPH_RESET_CTL4 (at 0x12bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x812bdb0 0x12bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S8_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_FREQ_TEST1 (at 0x12be2)"
      tindex ezaxi:0xfc4cf980 %l 0x812be20 0x12be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S8_PS"
  tree "S8_PS"
    tree "S8_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_REVISION1 (at 0x12a00)"
      tindex ezaxi:0xfc4cf980 %l 0x812a000 0x12a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_REVISION2 (at 0x12a01)"
      tindex ezaxi:0xfc4cf980 %l 0x812a010 0x12a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_REVISION3 (at 0x12a02)"
      tindex ezaxi:0xfc4cf980 %l 0x812a020 0x12a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_REVISION4 (at 0x12a03)"
      tindex ezaxi:0xfc4cf980 %l 0x812a030 0x12a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PERPH_TYPE (at 0x12a04)"
      tindex ezaxi:0xfc4cf980 %l 0x812a040 0x12a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PERPH_SUBTYPE (at 0x12a05)"
      tindex ezaxi:0xfc4cf980 %l 0x812a050 0x12a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_STATUS_1 (at 0x12a08)"
      tindex ezaxi:0xfc4cf980 %l 0x812a080 0x12a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S8_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_STATUS_2 (at 0x12a09)"
      tindex ezaxi:0xfc4cf980 %l 0x812a090 0x12a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S8_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_VOLTAGE_CTL1 (at 0x12a40)"
      tindex ezaxi:0xfc4cf980 %l 0x812a400 0x12a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S8_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_VOLTAGE_CTL2 (at 0x12a41)"
      tindex ezaxi:0xfc4cf980 %l 0x812a410 0x12a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S8_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MODE_CTL (at 0x12a45)"
      tindex ezaxi:0xfc4cf980 %l 0x812a450 0x12a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S8_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_FREQ_CTL (at 0x12a50)"
      tindex ezaxi:0xfc4cf980 %l 0x812a500 0x12a500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S8_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MULTIPHASE_CTL (at 0x12a51)"
      tindex ezaxi:0xfc4cf980 %l 0x812a510 0x12a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S8_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PHASE_CTL (at 0x12a52)"
      tindex ezaxi:0xfc4cf980 %l 0x812a520 0x12a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S8_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PHASE_ID (at 0x12a53)"
      tindex ezaxi:0xfc4cf980 %l 0x812a530 0x12a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S8_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PHASE_CNT_MAX (at 0x12a54)"
      tindex ezaxi:0xfc4cf980 %l 0x812a540 0x12a540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S8_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PWM_CL_CTL (at 0x12a60)"
      tindex ezaxi:0xfc4cf980 %l 0x812a600 0x12a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S8_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LPM_CL_CTL (at 0x12a61)"
      tindex ezaxi:0xfc4cf980 %l 0x812a610 0x12a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S8_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_AUTO_CTL_1 (at 0x12a62)"
      tindex ezaxi:0xfc4cf980 %l 0x812a620 0x12a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S8_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LPM_ADC_VAL (at 0x12a63)"
      tindex ezaxi:0xfc4cf980 %l 0x812a630 0x12a630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S8_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LPM_ADC_CTL (at 0x12a64)"
      tindex ezaxi:0xfc4cf980 %l 0x812a640 0x12a640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ACTIVITY_DETECT (at 0x12a65)"
      tindex ezaxi:0xfc4cf980 %l 0x812a650 0x12a650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LPM_CFG (at 0x12a68)"
      tindex ezaxi:0xfc4cf980 %l 0x812a680 0x12a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S8_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_FSM_MINON_CFG (at 0x12a70)"
      tindex ezaxi:0xfc4cf980 %l 0x812a700 0x12a700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S8_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ZX_CAL_CFG (at 0x12a73)"
      tindex ezaxi:0xfc4cf980 %l 0x812a730 0x12a730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S8_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_NONOVLAP_CFG (at 0x12a74)"
      tindex ezaxi:0xfc4cf980 %l 0x812a740 0x12a740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S8_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ADC_FRONT_CFG (at 0x12a75)"
      tindex ezaxi:0xfc4cf980 %l 0x812a750 0x12a750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_P0_LUT_IN (at 0x12a78)"
      tindex ezaxi:0xfc4cf980 %l 0x812a780 0x12a780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S8_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MPH_STROBE (at 0x12a79)"
      tindex ezaxi:0xfc4cf980 %l 0x812a790 0x12a790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S8_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_OUT (at 0x12a7a)"
      tindex ezaxi:0xfc4cf980 %l 0x812a7a0 0x12a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S8_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ADC_OUT (at 0x12a7b)"
      tindex ezaxi:0xfc4cf980 %l 0x812a7b0 0x12a7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S8_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ADC_FRC (at 0x12a7c)"
      tindex ezaxi:0xfc4cf980 %l 0x812a7c0 0x12a7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S8_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MP_CORR_DFT (at 0x12a7d)"
      tindex ezaxi:0xfc4cf980 %l 0x812a7d0 0x12a7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S8_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_DAC_DATA (at 0x12a7e)"
      tindex ezaxi:0xfc4cf980 %l 0x812a7e0 0x12a7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S8_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_DAC_FRC (at 0x12a7f)"
      tindex ezaxi:0xfc4cf980 %l 0x812a7f0 0x12a7f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S8_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_DAC_PT_0 (at 0x12a80)"
      tindex ezaxi:0xfc4cf980 %l 0x812a800 0x12a800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S8_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_DAC_PT_1 (at 0x12a81)"
      tindex ezaxi:0xfc4cf980 %l 0x812a810 0x12a810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S8_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_DAC_PT_2 (at 0x12a82)"
      tindex ezaxi:0xfc4cf980 %l 0x812a820 0x12a820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S8_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_DAC_PT_3 (at 0x12a83)"
      tindex ezaxi:0xfc4cf980 %l 0x812a830 0x12a830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S8_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_ADC_PT_1 (at 0x12a87)"
      tindex ezaxi:0xfc4cf980 %l 0x812a870 0x12a870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S8_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_ADC_PT_2 (at 0x12a88)"
      tindex ezaxi:0xfc4cf980 %l 0x812a880 0x12a880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S8_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_ADC_PT_3 (at 0x12a89)"
      tindex ezaxi:0xfc4cf980 %l 0x812a890 0x12a890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S8_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_SLOPE_HI_0 (at 0x12a8c)"
      tindex ezaxi:0xfc4cf980 %l 0x812a8c0 0x12a8c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S8_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_SLOPE_LO_0 (at 0x12a8d)"
      tindex ezaxi:0xfc4cf980 %l 0x812a8d0 0x12a8d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S8_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_SLOPE_HI_1 (at 0x12a8e)"
      tindex ezaxi:0xfc4cf980 %l 0x812a8e0 0x12a8e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S8_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_SLOPE_LO_1 (at 0x12a8f)"
      tindex ezaxi:0xfc4cf980 %l 0x812a8f0 0x12a8f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S8_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_SLOPE_HI_2 (at 0x12a90)"
      tindex ezaxi:0xfc4cf980 %l 0x812a900 0x12a900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S8_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_LUT_SLOPE_LO_2 (at 0x12a91)"
      tindex ezaxi:0xfc4cf980 %l 0x812a910 0x12a910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MPHASE_PI_CFG1 (at 0x12a96)"
      tindex ezaxi:0xfc4cf980 %l 0x812a960 0x12a960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MPHASE_PI_CFG4 (at 0x12a97)"
      tindex ezaxi:0xfc4cf980 %l 0x812a970 0x12a970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S8_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MPHASE_PHASE_CNT (at 0x12a98)"
      tindex ezaxi:0xfc4cf980 %l 0x812a980 0x12a980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_EN_OPTIONS_DFT_1 (at 0x12aa8)"
      tindex ezaxi:0xfc4cf980 %l 0x812aa80 0x12aa80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S8_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_EN_OPTIONS_DFT_2 (at 0x12aa9)"
      tindex ezaxi:0xfc4cf980 %l 0x812aa90 0x12aa90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S8_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ZX_ADAPT_CTL (at 0x12aaa)"
      tindex ezaxi:0xfc4cf980 %l 0x812aaa0 0x12aaa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S8_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ZX_ADAPT_VAL (at 0x12aab)"
      tindex ezaxi:0xfc4cf980 %l 0x812aab0 0x12aab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S8_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ADC_CLK_CTL (at 0x12aac)"
      tindex ezaxi:0xfc4cf980 %l 0x812aac0 0x12aac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S8_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ATEST12 (at 0x12ab0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ab00 0x12ab00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S8_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ATEST34 (at 0x12ab1)"
      tindex ezaxi:0xfc4cf980 %l 0x812ab10 0x12ab10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S8_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_DTEST12 (at 0x12ab2)"
      tindex ezaxi:0xfc4cf980 %l 0x812ab20 0x12ab20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S8_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_DTEST43 (at 0x12ab3)"
      tindex ezaxi:0xfc4cf980 %l 0x812ab30 0x12ab30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S8_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_GANG_CTL1 (at 0x12ac0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ac00 0x12ac00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_GANG_CTL2 (at 0x12ac1)"
      tindex ezaxi:0xfc4cf980 %l 0x812ac10 0x12ac10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S8_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_SEC_ACCESS (at 0x12ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ad00 0x12ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PERPH_RESET_CTL2 (at 0x12ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x812ad90 0x12ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PERPH_RESET_CTL3 (at 0x12ada)"
      tindex ezaxi:0xfc4cf980 %l 0x812ada0 0x12ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_PERPH_RESET_CTL4 (at 0x12adb)"
      tindex ezaxi:0xfc4cf980 %l 0x812adb0 0x12adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S8_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_CAL_REQUEST (at 0x12ae2)"
      tindex ezaxi:0xfc4cf980 %l 0x812ae20 0x12ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S8_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_MAN_CAL_VAL (at 0x12ae5)"
      tindex ezaxi:0xfc4cf980 %l 0x812ae50 0x12ae50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S8_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_REPLICA_CFG (at 0x12ae6)"
      tindex ezaxi:0xfc4cf980 %l 0x812ae60 0x12ae60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S8_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_CAL_CTL_1 (at 0x12ae7)"
      tindex ezaxi:0xfc4cf980 %l 0x812ae70 0x12ae70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S8_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_CAL_CTL_2 (at 0x12ae8)"
      tindex ezaxi:0xfc4cf980 %l 0x812ae80 0x12ae80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S8_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_REPLICA_CAL_VAL (at 0x12aea)"
      tindex ezaxi:0xfc4cf980 %l 0x812aea0 0x12aea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S8_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_DACMID_BUF_CAL_VAL (at 0x12aec)"
      tindex ezaxi:0xfc4cf980 %l 0x812aec0 0x12aec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S8_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_FRONT_BUF_CAL_VAL (at 0x12aed)"
      tindex ezaxi:0xfc4cf980 %l 0x812aed0 0x12aed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S8_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_CL_CAL_VAL (at 0x12aee)"
      tindex ezaxi:0xfc4cf980 %l 0x812aee0 0x12aee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S8_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ZX_CAL_VAL (at 0x12aef)"
      tindex ezaxi:0xfc4cf980 %l 0x812aef0 0x12aef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S8_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_TRIM_NUM (at 0x12af0)"
      tindex ezaxi:0xfc4cf980 %l 0x812af00 0x12af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S8_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_ZX_TRIM (at 0x12af1)"
      tindex ezaxi:0xfc4cf980 %l 0x812af10 0x12af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S8_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_CL_TRIM (at 0x12af2)"
      tindex ezaxi:0xfc4cf980 %l 0x812af20 0x12af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S8_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S8_PS_REPLICA_TRIM (at 0x12af3)"
      tindex ezaxi:0xfc4cf980 %l 0x812af30 0x12af30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S9_CTRL"
  tree "S9_CTRL"
    tree "S9_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_REVISION1 (at 0x12c00)"
      tindex ezaxi:0xfc4cf980 %l 0x812c000 0x12c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S9_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_REVISION2 (at 0x12c01)"
      tindex ezaxi:0xfc4cf980 %l 0x812c010 0x12c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S9_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_REVISION3 (at 0x12c02)"
      tindex ezaxi:0xfc4cf980 %l 0x812c020 0x12c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S9_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_REVISION4 (at 0x12c03)"
      tindex ezaxi:0xfc4cf980 %l 0x812c030 0x12c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S9_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PERPH_TYPE (at 0x12c04)"
      tindex ezaxi:0xfc4cf980 %l 0x812c040 0x12c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S9_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PERPH_SUBTYPE (at 0x12c05)"
      tindex ezaxi:0xfc4cf980 %l 0x812c050 0x12c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S9_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_STATUS_1 (at 0x12c08)"
      tindex ezaxi:0xfc4cf980 %l 0x812c080 0x12c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S9_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_STATUS_2 (at 0x12c09)"
      tindex ezaxi:0xfc4cf980 %l 0x812c090 0x12c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S9_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_STATUS_3 (at 0x12c0a)"
      tindex ezaxi:0xfc4cf980 %l 0x812c0a0 0x12c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S9_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_STATUS_4 (at 0x12c0b)"
      tindex ezaxi:0xfc4cf980 %l 0x812c0b0 0x12c0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S9_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_STATUS_5 (at 0x12c0c)"
      tindex ezaxi:0xfc4cf980 %l 0x812c0c0 0x12c0c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S9_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_RT_STS (at 0x12c10)"
      tindex ezaxi:0xfc4cf980 %l 0x812c100 0x12c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S9_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_SET_TYPE (at 0x12c11)"
      tindex ezaxi:0xfc4cf980 %l 0x812c110 0x12c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S9_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_POLARITY_HIGH (at 0x12c12)"
      tindex ezaxi:0xfc4cf980 %l 0x812c120 0x12c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S9_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_POLARITY_LOW (at 0x12c13)"
      tindex ezaxi:0xfc4cf980 %l 0x812c130 0x12c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S9_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_LATCHED_CLR (at 0x12c14)"
      tindex ezaxi:0xfc4cf980 %l 0x812c140 0x12c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S9_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_EN_SET (at 0x12c15)"
      tindex ezaxi:0xfc4cf980 %l 0x812c150 0x12c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S9_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_EN_CLR (at 0x12c16)"
      tindex ezaxi:0xfc4cf980 %l 0x812c160 0x12c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S9_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_LATCHED_STS (at 0x12c18)"
      tindex ezaxi:0xfc4cf980 %l 0x812c180 0x12c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S9_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_PENDING_STS (at 0x12c19)"
      tindex ezaxi:0xfc4cf980 %l 0x812c190 0x12c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S9_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_MID_SEL (at 0x12c1a)"
      tindex ezaxi:0xfc4cf980 %l 0x812c1a0 0x12c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S9_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_PRIORITY (at 0x12c1b)"
      tindex ezaxi:0xfc4cf980 %l 0x812c1b0 0x12c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S9_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VOLTAGE_CTL1 (at 0x12c40)"
      tindex ezaxi:0xfc4cf980 %l 0x812c400 0x12c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S9_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VOLTAGE_CTL2 (at 0x12c41)"
      tindex ezaxi:0xfc4cf980 %l 0x812c410 0x12c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S9_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VSET_VALID (at 0x12c42)"
      tindex ezaxi:0xfc4cf980 %l 0x812c420 0x12c420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S9_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MPPFM_VOFFSET (at 0x12c44)"
      tindex ezaxi:0xfc4cf980 %l 0x812c440 0x12c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S9_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MODE_CTL (at 0x12c45)"
      tindex ezaxi:0xfc4cf980 %l 0x812c450 0x12c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S9_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_EN_CTL (at 0x12c46)"
      tindex ezaxi:0xfc4cf980 %l 0x812c460 0x12c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S9_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PD_CTL (at 0x12c48)"
      tindex ezaxi:0xfc4cf980 %l 0x812c480 0x12c480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S9_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_FREQ_CTL (at 0x12c50)"
      tindex ezaxi:0xfc4cf980 %l 0x812c500 0x12c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S9_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MULTIPHASE_CTL (at 0x12c51)"
      tindex ezaxi:0xfc4cf980 %l 0x812c510 0x12c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S9_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PHASE_CTL (at 0x12c52)"
      tindex ezaxi:0xfc4cf980 %l 0x812c520 0x12c520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S9_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PHASE_ID (at 0x12c53)"
      tindex ezaxi:0xfc4cf980 %l 0x812c530 0x12c530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S9_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PHASE_CNT_MAX (at 0x12c54)"
      tindex ezaxi:0xfc4cf980 %l 0x812c540 0x12c540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S9_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PH_READY (at 0x12c55)"
      tindex ezaxi:0xfc4cf980 %l 0x812c550 0x12c550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S9_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_SS_CTL (at 0x12c60)"
      tindex ezaxi:0xfc4cf980 %l 0x812c600 0x12c600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S9_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VS_CTL (at 0x12c61)"
      tindex ezaxi:0xfc4cf980 %l 0x812c610 0x12c610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S9_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CORR_CFG (at 0x12c62)"
      tindex ezaxi:0xfc4cf980 %l 0x812c620 0x12c620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S9_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_RAMP_CFG (at 0x12c63)"
      tindex ezaxi:0xfc4cf980 %l 0x812c630 0x12c630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S9_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_COMPENS_CFG (at 0x12c64)"
      tindex ezaxi:0xfc4cf980 %l 0x812c640 0x12c640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S9_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_VREG_MON (at 0x12c65)"
      tindex ezaxi:0xfc4cf980 %l 0x812c650 0x12c650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S9_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_VREG_OCP (at 0x12c66)"
      tindex ezaxi:0xfc4cf980 %l 0x812c660 0x12c660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S9_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_PFM_COMP (at 0x12c67)"
      tindex ezaxi:0xfc4cf980 %l 0x812c670 0x12c670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S9_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_UL_LL_CTL (at 0x12c68)"
      tindex ezaxi:0xfc4cf980 %l 0x812c680 0x12c680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S9_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VSET_ULS (at 0x12c69)"
      tindex ezaxi:0xfc4cf980 %l 0x812c690 0x12c690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S9_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_ULS_VALID (at 0x12c6a)"
      tindex ezaxi:0xfc4cf980 %l 0x812c6a0 0x12c6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S9_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VSET_LLS (at 0x12c6b)"
      tindex ezaxi:0xfc4cf980 %l 0x812c6b0 0x12c6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S9_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_LLS_VALID (at 0x12c6c)"
      tindex ezaxi:0xfc4cf980 %l 0x812c6c0 0x12c6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S9_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_GPL_HI (at 0x12c6d)"
      tindex ezaxi:0xfc4cf980 %l 0x812c6d0 0x12c6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S9_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_GPL_LO (at 0x12c6e)"
      tindex ezaxi:0xfc4cf980 %l 0x812c6e0 0x12c6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S9_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_FB_FILT_CFG (at 0x12c6f)"
      tindex ezaxi:0xfc4cf980 %l 0x812c6f0 0x12c6f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S9_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VDIP_CFG (at 0x12c71)"
      tindex ezaxi:0xfc4cf980 %l 0x812c710 0x12c710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S9_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MPH_STROBE (at 0x12c79)"
      tindex ezaxi:0xfc4cf980 %l 0x812c790 0x12c790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S9_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MODE_FSM_MASK (at 0x12ca0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca00 0x12ca00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S9_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MODE_FSM_WAITS_1 (at 0x12ca1)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca10 0x12ca10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S9_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MODE_FSM_WAIT_2 (at 0x12ca2)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca20 0x12ca20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S9_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_GATE_DRV_MUX (at 0x12ca3)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca30 0x12ca30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S9_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CORR_DUTY_MUX (at 0x12ca4)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca40 0x12ca40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S9_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_EN_OPTIONS_DFT_1 (at 0x12ca5)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca50 0x12ca50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S9_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_EN_OPTIONS_DFT_2 (at 0x12ca6)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca60 0x12ca60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S9_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MPHASE_IDAC (at 0x12ca7)"
      tindex ezaxi:0xfc4cf980 %l 0x812ca70 0x12ca70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S9_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_ANTI_ESL_CFG_1 (at 0x12cac)"
      tindex ezaxi:0xfc4cf980 %l 0x812cac0 0x12cac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S9_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_ANTI_ESL_CFG_2 (at 0x12cad)"
      tindex ezaxi:0xfc4cf980 %l 0x812cad0 0x12cad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S9_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_ATEST1 (at 0x12cb0)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb00 0x12cb00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S9_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_ATEST2 (at 0x12cb1)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb10 0x12cb10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S9_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_ATEST3 (at 0x12cb2)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb20 0x12cb20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S9_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_ATEST4 (at 0x12cb3)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb30 0x12cb30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S9_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_DTEST1 (at 0x12cb4)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb40 0x12cb40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S9_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_DTEST2 (at 0x12cb5)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb50 0x12cb50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S9_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_DTEST3 (at 0x12cb6)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb60 0x12cb60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S9_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CFG_DTEST4 (at 0x12cb7)"
      tindex ezaxi:0xfc4cf980 %l 0x812cb70 0x12cb70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S9_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_GANG_CTL1 (at 0x12cc0)"
      tindex ezaxi:0xfc4cf980 %l 0x812cc00 0x12cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S9_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_GANG_CTL2 (at 0x12cc1)"
      tindex ezaxi:0xfc4cf980 %l 0x812cc10 0x12cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S9_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_SEC_ACCESS (at 0x12cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x812cd00 0x12cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S9_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PERPH_RESET_CTL1 (at 0x12cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x812cd80 0x12cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S9_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PERPH_RESET_CTL2 (at 0x12cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x812cd90 0x12cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S9_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PERPH_RESET_CTL3 (at 0x12cda)"
      tindex ezaxi:0xfc4cf980 %l 0x812cda0 0x12cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S9_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PERPH_RESET_CTL4 (at 0x12cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x812cdb0 0x12cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S9_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_TEST1 (at 0x12ce0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ce00 0x12ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S9_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_INT_TEST_VAL (at 0x12ce1)"
      tindex ezaxi:0xfc4cf980 %l 0x812ce10 0x12ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S9_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CAL_REQUEST (at 0x12ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x812ce20 0x12ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S9_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CAL_CTL_1 (at 0x12ce3)"
      tindex ezaxi:0xfc4cf980 %l 0x812ce30 0x12ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S9_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CAL_CTL_2 (at 0x12ce4)"
      tindex ezaxi:0xfc4cf980 %l 0x812ce40 0x12ce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S9_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_MAN_CAL_VAL (at 0x12ce5)"
      tindex ezaxi:0xfc4cf980 %l 0x812ce50 0x12ce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S9_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_REFDAC_CAL_VAL (at 0x12cea)"
      tindex ezaxi:0xfc4cf980 %l 0x812cea0 0x12cea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S9_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_VDIP_CAL_VAL (at 0x12ceb)"
      tindex ezaxi:0xfc4cf980 %l 0x812ceb0 0x12ceb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S9_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_IDAC_CAL_VAL (at 0x12cec)"
      tindex ezaxi:0xfc4cf980 %l 0x812cec0 0x12cec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S9_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_CORR_CAL_VAL (at 0x12ced)"
      tindex ezaxi:0xfc4cf980 %l 0x812ced0 0x12ced0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S9_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PWM_CAL_VAL (at 0x12cee)"
      tindex ezaxi:0xfc4cf980 %l 0x812cee0 0x12cee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S9_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_PFM_CAL_VAL (at 0x12cef)"
      tindex ezaxi:0xfc4cf980 %l 0x812cef0 0x12cef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S9_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_TRIM_NUM (at 0x12cf0)"
      tindex ezaxi:0xfc4cf980 %l 0x812cf00 0x12cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S9_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_REFDAC_TRIM (at 0x12cf1)"
      tindex ezaxi:0xfc4cf980 %l 0x812cf10 0x12cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S9_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_CTRL_RAMP_TRIM (at 0x12cf2)"
      tindex ezaxi:0xfc4cf980 %l 0x812cf20 0x12cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S9_FREQ"
  tree "S9_FREQ"
    tree "S9_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_REVISION1 (at 0x12e00)"
      tindex ezaxi:0xfc4cf980 %l 0x812e000 0x12e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S9_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_REVISION2 (at 0x12e01)"
      tindex ezaxi:0xfc4cf980 %l 0x812e010 0x12e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S9_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_PERPH_TYPE (at 0x12e04)"
      tindex ezaxi:0xfc4cf980 %l 0x812e040 0x12e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S9_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_PERPH_SUBTYPE (at 0x12e05)"
      tindex ezaxi:0xfc4cf980 %l 0x812e050 0x12e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S9_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_CLK_ENABLE (at 0x12e46)"
      tindex ezaxi:0xfc4cf980 %l 0x812e460 0x12e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S9_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_CLK_DIV (at 0x12e50)"
      tindex ezaxi:0xfc4cf980 %l 0x812e500 0x12e500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S9_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_CLK_PHASE (at 0x12e51)"
      tindex ezaxi:0xfc4cf980 %l 0x812e510 0x12e510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S9_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_GANG_CTL1 (at 0x12ec0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ec00 0x12ec00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S9_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_GANG_CTL2 (at 0x12ec1)"
      tindex ezaxi:0xfc4cf980 %l 0x812ec10 0x12ec10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S9_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_SEC_ACCESS (at 0x12ed0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ed00 0x12ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S9_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_PERPH_RESET_CTL2 (at 0x12ed9)"
      tindex ezaxi:0xfc4cf980 %l 0x812ed90 0x12ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S9_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_PERPH_RESET_CTL3 (at 0x12eda)"
      tindex ezaxi:0xfc4cf980 %l 0x812eda0 0x12eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S9_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_PERPH_RESET_CTL4 (at 0x12edb)"
      tindex ezaxi:0xfc4cf980 %l 0x812edb0 0x12edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S9_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_FREQ_TEST1 (at 0x12ee2)"
      tindex ezaxi:0xfc4cf980 %l 0x812ee20 0x12ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S9_PS"
  tree "S9_PS"
    tree "S9_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_REVISION1 (at 0x12d00)"
      tindex ezaxi:0xfc4cf980 %l 0x812d000 0x12d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S9_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_REVISION2 (at 0x12d01)"
      tindex ezaxi:0xfc4cf980 %l 0x812d010 0x12d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S9_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_REVISION3 (at 0x12d02)"
      tindex ezaxi:0xfc4cf980 %l 0x812d020 0x12d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S9_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_REVISION4 (at 0x12d03)"
      tindex ezaxi:0xfc4cf980 %l 0x812d030 0x12d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S9_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PERPH_TYPE (at 0x12d04)"
      tindex ezaxi:0xfc4cf980 %l 0x812d040 0x12d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S9_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PERPH_SUBTYPE (at 0x12d05)"
      tindex ezaxi:0xfc4cf980 %l 0x812d050 0x12d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S9_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_STATUS_1 (at 0x12d08)"
      tindex ezaxi:0xfc4cf980 %l 0x812d080 0x12d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S9_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_STATUS_2 (at 0x12d09)"
      tindex ezaxi:0xfc4cf980 %l 0x812d090 0x12d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S9_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_VOLTAGE_CTL1 (at 0x12d40)"
      tindex ezaxi:0xfc4cf980 %l 0x812d400 0x12d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S9_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_VOLTAGE_CTL2 (at 0x12d41)"
      tindex ezaxi:0xfc4cf980 %l 0x812d410 0x12d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S9_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MODE_CTL (at 0x12d45)"
      tindex ezaxi:0xfc4cf980 %l 0x812d450 0x12d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S9_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_FREQ_CTL (at 0x12d50)"
      tindex ezaxi:0xfc4cf980 %l 0x812d500 0x12d500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S9_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MULTIPHASE_CTL (at 0x12d51)"
      tindex ezaxi:0xfc4cf980 %l 0x812d510 0x12d510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S9_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PHASE_CTL (at 0x12d52)"
      tindex ezaxi:0xfc4cf980 %l 0x812d520 0x12d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S9_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PHASE_ID (at 0x12d53)"
      tindex ezaxi:0xfc4cf980 %l 0x812d530 0x12d530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S9_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PHASE_CNT_MAX (at 0x12d54)"
      tindex ezaxi:0xfc4cf980 %l 0x812d540 0x12d540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S9_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PWM_CL_CTL (at 0x12d60)"
      tindex ezaxi:0xfc4cf980 %l 0x812d600 0x12d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S9_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LPM_CL_CTL (at 0x12d61)"
      tindex ezaxi:0xfc4cf980 %l 0x812d610 0x12d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S9_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_AUTO_CTL_1 (at 0x12d62)"
      tindex ezaxi:0xfc4cf980 %l 0x812d620 0x12d620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S9_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LPM_ADC_VAL (at 0x12d63)"
      tindex ezaxi:0xfc4cf980 %l 0x812d630 0x12d630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S9_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LPM_ADC_CTL (at 0x12d64)"
      tindex ezaxi:0xfc4cf980 %l 0x812d640 0x12d640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S9_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ACTIVITY_DETECT (at 0x12d65)"
      tindex ezaxi:0xfc4cf980 %l 0x812d650 0x12d650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S9_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LPM_CFG (at 0x12d68)"
      tindex ezaxi:0xfc4cf980 %l 0x812d680 0x12d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S9_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_FSM_MINON_CFG (at 0x12d70)"
      tindex ezaxi:0xfc4cf980 %l 0x812d700 0x12d700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S9_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ZX_CAL_CFG (at 0x12d73)"
      tindex ezaxi:0xfc4cf980 %l 0x812d730 0x12d730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S9_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_NONOVLAP_CFG (at 0x12d74)"
      tindex ezaxi:0xfc4cf980 %l 0x812d740 0x12d740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S9_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ADC_FRONT_CFG (at 0x12d75)"
      tindex ezaxi:0xfc4cf980 %l 0x812d750 0x12d750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S9_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_P0_LUT_IN (at 0x12d78)"
      tindex ezaxi:0xfc4cf980 %l 0x812d780 0x12d780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S9_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MPH_STROBE (at 0x12d79)"
      tindex ezaxi:0xfc4cf980 %l 0x812d790 0x12d790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S9_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_OUT (at 0x12d7a)"
      tindex ezaxi:0xfc4cf980 %l 0x812d7a0 0x12d7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S9_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ADC_OUT (at 0x12d7b)"
      tindex ezaxi:0xfc4cf980 %l 0x812d7b0 0x12d7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S9_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ADC_FRC (at 0x12d7c)"
      tindex ezaxi:0xfc4cf980 %l 0x812d7c0 0x12d7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S9_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MP_CORR_DFT (at 0x12d7d)"
      tindex ezaxi:0xfc4cf980 %l 0x812d7d0 0x12d7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S9_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_DAC_DATA (at 0x12d7e)"
      tindex ezaxi:0xfc4cf980 %l 0x812d7e0 0x12d7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S9_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_DAC_FRC (at 0x12d7f)"
      tindex ezaxi:0xfc4cf980 %l 0x812d7f0 0x12d7f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S9_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_DAC_PT_0 (at 0x12d80)"
      tindex ezaxi:0xfc4cf980 %l 0x812d800 0x12d800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S9_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_DAC_PT_1 (at 0x12d81)"
      tindex ezaxi:0xfc4cf980 %l 0x812d810 0x12d810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S9_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_DAC_PT_2 (at 0x12d82)"
      tindex ezaxi:0xfc4cf980 %l 0x812d820 0x12d820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S9_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_DAC_PT_3 (at 0x12d83)"
      tindex ezaxi:0xfc4cf980 %l 0x812d830 0x12d830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S9_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_ADC_PT_1 (at 0x12d87)"
      tindex ezaxi:0xfc4cf980 %l 0x812d870 0x12d870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S9_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_ADC_PT_2 (at 0x12d88)"
      tindex ezaxi:0xfc4cf980 %l 0x812d880 0x12d880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S9_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_ADC_PT_3 (at 0x12d89)"
      tindex ezaxi:0xfc4cf980 %l 0x812d890 0x12d890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S9_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_SLOPE_HI_0 (at 0x12d8c)"
      tindex ezaxi:0xfc4cf980 %l 0x812d8c0 0x12d8c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S9_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_SLOPE_LO_0 (at 0x12d8d)"
      tindex ezaxi:0xfc4cf980 %l 0x812d8d0 0x12d8d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S9_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_SLOPE_HI_1 (at 0x12d8e)"
      tindex ezaxi:0xfc4cf980 %l 0x812d8e0 0x12d8e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S9_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_SLOPE_LO_1 (at 0x12d8f)"
      tindex ezaxi:0xfc4cf980 %l 0x812d8f0 0x12d8f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S9_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_SLOPE_HI_2 (at 0x12d90)"
      tindex ezaxi:0xfc4cf980 %l 0x812d900 0x12d900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S9_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_LUT_SLOPE_LO_2 (at 0x12d91)"
      tindex ezaxi:0xfc4cf980 %l 0x812d910 0x12d910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S9_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MPHASE_PI_CFG1 (at 0x12d96)"
      tindex ezaxi:0xfc4cf980 %l 0x812d960 0x12d960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S9_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MPHASE_PI_CFG4 (at 0x12d97)"
      tindex ezaxi:0xfc4cf980 %l 0x812d970 0x12d970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S9_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MPHASE_PHASE_CNT (at 0x12d98)"
      tindex ezaxi:0xfc4cf980 %l 0x812d980 0x12d980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S9_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_EN_OPTIONS_DFT_1 (at 0x12da8)"
      tindex ezaxi:0xfc4cf980 %l 0x812da80 0x12da80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S9_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_EN_OPTIONS_DFT_2 (at 0x12da9)"
      tindex ezaxi:0xfc4cf980 %l 0x812da90 0x12da90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S9_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ZX_ADAPT_CTL (at 0x12daa)"
      tindex ezaxi:0xfc4cf980 %l 0x812daa0 0x12daa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S9_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ZX_ADAPT_VAL (at 0x12dab)"
      tindex ezaxi:0xfc4cf980 %l 0x812dab0 0x12dab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S9_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ADC_CLK_CTL (at 0x12dac)"
      tindex ezaxi:0xfc4cf980 %l 0x812dac0 0x12dac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S9_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ATEST12 (at 0x12db0)"
      tindex ezaxi:0xfc4cf980 %l 0x812db00 0x12db00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S9_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ATEST34 (at 0x12db1)"
      tindex ezaxi:0xfc4cf980 %l 0x812db10 0x12db10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S9_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_DTEST12 (at 0x12db2)"
      tindex ezaxi:0xfc4cf980 %l 0x812db20 0x12db20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S9_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_DTEST43 (at 0x12db3)"
      tindex ezaxi:0xfc4cf980 %l 0x812db30 0x12db30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S9_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_GANG_CTL1 (at 0x12dc0)"
      tindex ezaxi:0xfc4cf980 %l 0x812dc00 0x12dc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S9_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_GANG_CTL2 (at 0x12dc1)"
      tindex ezaxi:0xfc4cf980 %l 0x812dc10 0x12dc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S9_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_SEC_ACCESS (at 0x12dd0)"
      tindex ezaxi:0xfc4cf980 %l 0x812dd00 0x12dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S9_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PERPH_RESET_CTL2 (at 0x12dd9)"
      tindex ezaxi:0xfc4cf980 %l 0x812dd90 0x12dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S9_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PERPH_RESET_CTL3 (at 0x12dda)"
      tindex ezaxi:0xfc4cf980 %l 0x812dda0 0x12dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S9_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_PERPH_RESET_CTL4 (at 0x12ddb)"
      tindex ezaxi:0xfc4cf980 %l 0x812ddb0 0x12ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S9_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_CAL_REQUEST (at 0x12de2)"
      tindex ezaxi:0xfc4cf980 %l 0x812de20 0x12de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S9_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_MAN_CAL_VAL (at 0x12de5)"
      tindex ezaxi:0xfc4cf980 %l 0x812de50 0x12de50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S9_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_REPLICA_CFG (at 0x12de6)"
      tindex ezaxi:0xfc4cf980 %l 0x812de60 0x12de60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S9_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_CAL_CTL_1 (at 0x12de7)"
      tindex ezaxi:0xfc4cf980 %l 0x812de70 0x12de70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S9_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_CAL_CTL_2 (at 0x12de8)"
      tindex ezaxi:0xfc4cf980 %l 0x812de80 0x12de80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S9_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_REPLICA_CAL_VAL (at 0x12dea)"
      tindex ezaxi:0xfc4cf980 %l 0x812dea0 0x12dea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S9_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_DACMID_BUF_CAL_VAL (at 0x12dec)"
      tindex ezaxi:0xfc4cf980 %l 0x812dec0 0x12dec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S9_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_FRONT_BUF_CAL_VAL (at 0x12ded)"
      tindex ezaxi:0xfc4cf980 %l 0x812ded0 0x12ded0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S9_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_CL_CAL_VAL (at 0x12dee)"
      tindex ezaxi:0xfc4cf980 %l 0x812dee0 0x12dee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S9_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ZX_CAL_VAL (at 0x12def)"
      tindex ezaxi:0xfc4cf980 %l 0x812def0 0x12def0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S9_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_TRIM_NUM (at 0x12df0)"
      tindex ezaxi:0xfc4cf980 %l 0x812df00 0x12df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S9_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_ZX_TRIM (at 0x12df1)"
      tindex ezaxi:0xfc4cf980 %l 0x812df10 0x12df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S9_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_CL_TRIM (at 0x12df2)"
      tindex ezaxi:0xfc4cf980 %l 0x812df20 0x12df20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S9_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S9_PS_REPLICA_TRIM (at 0x12df3)"
      tindex ezaxi:0xfc4cf980 %l 0x812df30 0x12df30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "SLEEP_CLK1"
  tree "SLEEP_CLK1"
    tree "SLEEP_CLK1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_REVISION1 (at 0x5a00)"
      tindex ezaxi:0xfc4cf980 %l 0x805a000 0x5a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SLEEP_CLK1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_REVISION2 (at 0x5a01)"
      tindex ezaxi:0xfc4cf980 %l 0x805a010 0x5a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SLEEP_CLK1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_TYPE (at 0x5a04)"
      tindex ezaxi:0xfc4cf980 %l 0x805a040 0x5a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SLEEP_CLK1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_SUBTYPE (at 0x5a05)"
      tindex ezaxi:0xfc4cf980 %l 0x805a050 0x5a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SLEEP_CLK1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_STATUS1 (at 0x5a08)"
      tindex ezaxi:0xfc4cf980 %l 0x805a080 0x5a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_OK                               = " "0 (SLP_CLK_BUFFER_OFF),1 (SLP_CLK_BUFFER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLP_CLK_SOURCE                           = " "0 (XO_32K),1 (EXT_32K),2 (CALRC),3 (LFRC),4 (RC19M_DIV),5 (XO19M_DIV),6 (RESERVED_6),7 (RESERVED_7)"
    tree.end
    tree "SLEEP_CLK1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_RT_STS (at 0x5a10)"
      tindex ezaxi:0xfc4cf980 %l 0x805a100 0x5a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_RT_STS                    = " "0 (XO32K_NOT_HALT),1 (XO32K_HALT)"
    tree.end
    tree "SLEEP_CLK1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_SET_TYPE (at 0x5a11)"
      tindex ezaxi:0xfc4cf980 %l 0x805a110 0x5a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_POLARITY_HIGH (at 0x5a12)"
      tindex ezaxi:0xfc4cf980 %l 0x805a120 0x5a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_POLARITY_LOW (at 0x5a13)"
      tindex ezaxi:0xfc4cf980 %l 0x805a130 0x5a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_LATCHED_CLR (at 0x5a14)"
      tindex ezaxi:0xfc4cf980 %l 0x805a140 0x5a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_EN_SET (at 0x5a15)"
      tindex ezaxi:0xfc4cf980 %l 0x805a150 0x5a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_EN_CLR (at 0x5a16)"
      tindex ezaxi:0xfc4cf980 %l 0x805a160 0x5a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_LATCHED_STS (at 0x5a18)"
      tindex ezaxi:0xfc4cf980 %l 0x805a180 0x5a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "SLEEP_CLK1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_PENDING_STS (at 0x5a19)"
      tindex ezaxi:0xfc4cf980 %l 0x805a190 0x5a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "SLEEP_CLK1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_MID_SEL (at 0x5a1a)"
      tindex ezaxi:0xfc4cf980 %l 0x805a1a0 0x5a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SLEEP_CLK1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_PRIORITY (at 0x5a1b)"
      tindex ezaxi:0xfc4cf980 %l 0x805a1b0 0x5a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SLEEP_CLK1_DRV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_DRV_CTL1 (at 0x5a44)"
      tindex ezaxi:0xfc4cf980 %l 0x805a440 0x5a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "SLEEP_CLK1_HALT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_HALT_CTL (at 0x5a45)"
      tindex ezaxi:0xfc4cf980 %l 0x805a450 0x5a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_HALT_EN                            = " "0 (XO32K_HALT_DISABLED),1 (XO32K_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO32K_OSC_HALT                     = " "0 (XO32K_HALT_NOT_FORCED),1 (XO32K_HALT_FORCED)"
    tree.end
    tree "SLEEP_CLK1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_EN_CTL (at 0x5a46)"
      tindex ezaxi:0xfc4cf980 %l 0x805a460 0x5a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_PAD_EN                           = " "0 (SLP_CLK_BUF_DISABLED),1 (SLP_CLK_BUF_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_SMPL_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_SMPL_CTL1 (at 0x5a48)"
      tindex ezaxi:0xfc4cf980 %l 0x805a480 0x5a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SMPL_EN                                  = " "0 (SMPL_DISABLE),1 (SMPL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SMPL_DELAY                               = " "0 (HALF_SEC),1 (ONE_SEC),2 (ONEANDHALF_SEC),3 (TWO_SEC)"
    tree.end
    tree "SLEEP_CLK1_SLPSRC_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_SLPSRC_CTL1 (at 0x5a49)"
      tindex ezaxi:0xfc4cf980 %l 0x805a490 0x5a490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_EN                                 = " "0 (XO32K_DISABLED),1 (XO32K_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_OSC_SEL2I                          = " "0 (NORMAL_CURRENT),1 (MORE_CURRENT)"
    tree.end
    tree "SLEEP_CLK1_LFRC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_LFRC_CTL (at 0x5a57)"
      tindex ezaxi:0xfc4cf980 %l 0x805a570 0x5a570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CLKS_XVDD_BLEED                          = " "0 (NA_0),1 (NA_200),2 (reserved),3 (NA_600),4 (reserved),5 (reserved),6 (reserved),7 (NA_1600)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_CAL_RC1 (at 0x5a58)"
      tindex ezaxi:0xfc4cf980 %l 0x805a580 0x5a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CAL_FREQ_RTC_DEFAULT                     = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_CAL_RC2 (at 0x5a59)"
      tindex ezaxi:0xfc4cf980 %l 0x805a590 0x5a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DRIFT_LMT_RTC                            = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_CAL_RC3 (at 0x5a5a)"
      tindex ezaxi:0xfc4cf980 %l 0x805a5a0 0x5a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_BATT                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_CAL_RC4 (at 0x5a5b)"
      tindex ezaxi:0xfc4cf980 %l 0x805a5b0 0x5a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CALRC_EN                                 = " "0 (CALRC_DISABLED),1 (CALRC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   COINCELL_GOOD                            = " "0 (WEAK_COINCAP),1 (STRONG_COINCAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LFRC_DRIFT_DET_EN_COIN                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_DTEST_EN                           = " "0 (NORMAL),1 (CALRC_STATE_ON_DTEST)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_CAL_RC5 (at 0x5a5c)"
      tindex ezaxi:0xfc4cf980 %l 0x805a5c0 0x5a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MIN_XO_COUNT_LMT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_XO_COUNT_LMT                         = "
    tree.end
    tree "SLEEP_CLK1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_SEC_ACCESS (at 0x5ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x805ad00 0x5ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_RESET_CTL1 (at 0x5ad8)"
      tindex ezaxi:0xfc4cf980 %l 0x805ad80 0x5ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_RESET_CTL2 (at 0x5ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x805ad90 0x5ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_RESET_CTL3 (at 0x5ada)"
      tindex ezaxi:0xfc4cf980 %l 0x805ada0 0x5ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_RESET_CTL4 (at 0x5adb)"
      tindex ezaxi:0xfc4cf980 %l 0x805adb0 0x5adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_RESET_CTL5 (at 0x5adc)"
      tindex ezaxi:0xfc4cf980 %l 0x805adc0 0x5adc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_PERPH_RESET_CTL6 (at 0x5add)"
      tindex ezaxi:0xfc4cf980 %l 0x805add0 0x5add0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_TEST1 (at 0x5ae0)"
      tindex ezaxi:0xfc4cf980 %l 0x805ae00 0x5ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "SLEEP_CLK1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_INT_TEST_VAL (at 0x5ae1)"
      tindex ezaxi:0xfc4cf980 %l 0x805ae10 0x5ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TEST_VAL                  = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "SLEEP_CLK1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SLEEP_CLK1_TEST1 (at 0x5ae2)"
      tindex ezaxi:0xfc4cf980 %l 0x805ae20 0x5ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SMPL_TRIGGER_SEL                         = " "0 (HIZ),1 (CONNECT_TO_DTEST)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CXVDD_ATEST_EN                           = " "0 (HIZ),1 (CONNECT_TO_ATEST)"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION1 (at 0x600)"
      tindex ezaxi:0xfc4cf980 %l 0x8006000 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION2 (at 0x601)"
      tindex ezaxi:0xfc4cf980 %l 0x8006010 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION3 (at 0x602)"
      tindex ezaxi:0xfc4cf980 %l 0x8006020 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_REVISION4 (at 0x603)"
      tindex ezaxi:0xfc4cf980 %l 0x8006030 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_TYPE (at 0x604)"
      tindex ezaxi:0xfc4cf980 %l 0x8006040 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_SUBTYPE (at 0x605)"
      tindex ezaxi:0xfc4cf980 %l 0x8006050 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_SYNDROME (at 0x608)"
      tindex ezaxi:0xfc4cf980 %l 0x8006080 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_DATA (at 0x60b)"
      tindex ezaxi:0xfc4cf980 %l 0x80060b0 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_ADDR_LO (at 0x60c)"
      tindex ezaxi:0xfc4cf980 %l 0x80060c0 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_ADDR_MD (at 0x60d)"
      tindex ezaxi:0xfc4cf980 %l 0x80060d0 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_ERROR_ADDR_HI (at 0x60e)"
      tindex ezaxi:0xfc4cf980 %l 0x80060e0 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_RT_STS (at 0x610)"
      tindex ezaxi:0xfc4cf980 %l 0x8006100 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_SET_TYPE (at 0x611)"
      tindex ezaxi:0xfc4cf980 %l 0x8006110 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_POLARITY_HIGH (at 0x612)"
      tindex ezaxi:0xfc4cf980 %l 0x8006120 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_POLARITY_LOW (at 0x613)"
      tindex ezaxi:0xfc4cf980 %l 0x8006130 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_LATCHED_CLR (at 0x614)"
      tindex ezaxi:0xfc4cf980 %l 0x8006140 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_EN_SET (at 0x615)"
      tindex ezaxi:0xfc4cf980 %l 0x8006150 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_EN_CLR (at 0x616)"
      tindex ezaxi:0xfc4cf980 %l 0x8006160 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_LATCHED_STS (at 0x618)"
      tindex ezaxi:0xfc4cf980 %l 0x8006180 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_PENDING_STS (at 0x619)"
      tindex ezaxi:0xfc4cf980 %l 0x8006190 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_MID_SEL (at 0x61a)"
      tindex ezaxi:0xfc4cf980 %l 0x80061a0 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_PRIORITY (at 0x61b)"
      tindex ezaxi:0xfc4cf980 %l 0x80061b0 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_SPMI_BUF_CFG (at 0x640)"
      tindex ezaxi:0xfc4cf980 %l 0x8006400 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_SSC_DETECT_CFG (at 0x641)"
      tindex ezaxi:0xfc4cf980 %l 0x8006410 0x6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_SEC_ACCESS (at 0x6d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8006d00 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8006d90 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
      tindex ezaxi:0xfc4cf980 %l 0x8006da0 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
      tindex ezaxi:0xfc4cf980 %l 0x8006db0 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_TEST1 (at 0x6e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8006e00 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_INT_TEST_VAL (at 0x6e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8006e10 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_TEST1 (at 0x6e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8006e20 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
      tindex ezaxi:0xfc4cf980 %l 0x8206430 0x206430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
      tindex ezaxi:0xfc4cf980 %l 0x8206440 0x206440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
      tindex ezaxi:0xfc4cf980 %l 0x8206450 0x206450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
      tindex ezaxi:0xfc4cf980 %l 0x8206460 0x206460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
      tindex ezaxi:0xfc4cf980 %l 0x8206470 0x206470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_REVISION1 (at 0x2400)"
      tindex ezaxi:0xfc4cf980 %l 0x8024000 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_REVISION2 (at 0x2401)"
      tindex ezaxi:0xfc4cf980 %l 0x8024010 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_REVISION3 (at 0x2402)"
      tindex ezaxi:0xfc4cf980 %l 0x8024020 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_REVISION4 (at 0x2403)"
      tindex ezaxi:0xfc4cf980 %l 0x8024030 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
      tindex ezaxi:0xfc4cf980 %l 0x8024040 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
      tindex ezaxi:0xfc4cf980 %l 0x8024050 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_STATUS1 (at 0x2408)"
      tindex ezaxi:0xfc4cf980 %l 0x8024080 0x24080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0 (STAGE_0),1 (STAGE_1),2 (STAGE_2),3 (STAGE_3)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_RT_STS (at 0x2410)"
      tindex ezaxi:0xfc4cf980 %l 0x8024100 0x24100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
      tindex ezaxi:0xfc4cf980 %l 0x8024110 0x24110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
      tindex ezaxi:0xfc4cf980 %l 0x8024120 0x24120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
      tindex ezaxi:0xfc4cf980 %l 0x8024130 0x24130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
      tindex ezaxi:0xfc4cf980 %l 0x8024140 0x24140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_EN_SET (at 0x2415)"
      tindex ezaxi:0xfc4cf980 %l 0x8024150 0x24150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
      tindex ezaxi:0xfc4cf980 %l 0x8024160 0x24160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
      tindex ezaxi:0xfc4cf980 %l 0x8024180 0x24180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
      tindex ezaxi:0xfc4cf980 %l 0x8024190 0x24190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
      tindex ezaxi:0xfc4cf980 %l 0x80241a0 0x241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
      tindex ezaxi:0xfc4cf980 %l 0x80241b0 0x241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
      tindex ezaxi:0xfc4cf980 %l 0x8024400 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
      tindex ezaxi:0xfc4cf980 %l 0x8024420 0x24420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_EN_CTL1 (at 0x2446)"
      tindex ezaxi:0xfc4cf980 %l 0x8024460 0x24460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8024d00 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8024d80 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8024d90 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
      tindex ezaxi:0xfc4cf980 %l 0x8024da0 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
      tindex ezaxi:0xfc4cf980 %l 0x8024db0 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8024e00 0x24e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8024e10 0x24e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_TEST1 (at 0x24e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8024e20 0x24e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST1_UPR_STAT_I_DTEST2_LWR_STAT_I)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0 (USE_INTERNAL_VTEMP),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0 (OFF),1 (ATEST_VTEMP_BUF),2 (ATEST_UPR_DAC),3 (ATEST_LWR_DAC)"
    tree.end
    tree "TEMP_ALARM_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_TEST2 (at 0x24e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8024e30 0x24e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0 (BUFFERED),1 (UNBUFFERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST2_DTEST1_TEMP_STATUS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0 (NORMAL_OPERATION),1 (USE_ATEST_FOR_THRESHOLDS)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8024f00 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8024f10 0x24f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION1 (at 0xfe00)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe000 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION2 (at 0xfe01)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe010 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION3 (at 0xfe02)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe020 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_REVISION4 (at 0xfe03)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe030 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_TYPE (at 0xfe04)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe040 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_SUBTYPE (at 0xfe05)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe050 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe080 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_OTP_PROG_STATUS (at 0xfe09)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe090 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe0a0 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
      tindex ezaxi:0xfc4cf980 %l 0x80fe0b0 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_SEC_ACCESS (at 0xfed0)"
      tindex ezaxi:0xfc4cf980 %l 0x80fed00 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
      tindex ezaxi:0xfc4cf980 %l 0x80fed90 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
      tindex ezaxi:0xfc4cf980 %l 0x80feda0 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
      tindex ezaxi:0xfc4cf980 %l 0x80fedb0 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
      tindex ezaxi:0xfc4cf980 %l 0x80fee00 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
      tindex ezaxi:0xfc4cf980 %l 0x80fee10 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
      tindex ezaxi:0xfc4cf980 %l 0x80fee20 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
      tindex ezaxi:0xfc4cf980 %l 0x80fee30 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
      tindex ezaxi:0xfc4cf980 %l 0x80fee40 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TEST1 (at 0xfee5)"
      tindex ezaxi:0xfc4cf980 %l 0x80fee50 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
      tindex ezaxi:0xfc4cf980 %l 0x80fee60 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end
tree "VADC1_USR"
  tree "VADC1_USR"
    tree "VADC1_USR_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION1 (at 0x3100)"
      tindex ezaxi:0xfc4cf980 %l 0x8031000 0x31000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION2 (at 0x3101)"
      tindex ezaxi:0xfc4cf980 %l 0x8031010 0x31010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC1_USR_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION3 (at 0x3102)"
      tindex ezaxi:0xfc4cf980 %l 0x8031020 0x31020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_REVISION4 (at 0x3103)"
      tindex ezaxi:0xfc4cf980 %l 0x8031030 0x31030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC1_USR_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_TYPE (at 0x3104)"
      tindex ezaxi:0xfc4cf980 %l 0x8031040 0x31040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC1_USR_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_SUBTYPE (at 0x3105)"
      tindex ezaxi:0xfc4cf980 %l 0x8031050 0x31050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC1_USR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_STATUS1 (at 0x3108)"
      tindex ezaxi:0xfc4cf980 %l 0x8031080 0x31080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC1_USR_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_STATUS2 (at 0x3109)"
      tindex ezaxi:0xfc4cf980 %l 0x8031090 0x31090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_RT_STS (at 0x3110)"
      tindex ezaxi:0xfc4cf980 %l 0x8031100 0x31100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_SET_TYPE (at 0x3111)"
      tindex ezaxi:0xfc4cf980 %l 0x8031110 0x31110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_POLARITY_HIGH (at 0x3112)"
      tindex ezaxi:0xfc4cf980 %l 0x8031120 0x31120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_POLARITY_LOW (at 0x3113)"
      tindex ezaxi:0xfc4cf980 %l 0x8031130 0x31130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_LATCHED_CLR (at 0x3114)"
      tindex ezaxi:0xfc4cf980 %l 0x8031140 0x31140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC1_USR_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_EN_SET (at 0x3115)"
      tindex ezaxi:0xfc4cf980 %l 0x8031150 0x31150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_EN_CLR (at 0x3116)"
      tindex ezaxi:0xfc4cf980 %l 0x8031160 0x31160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_LATCHED_STS (at 0x3118)"
      tindex ezaxi:0xfc4cf980 %l 0x8031180 0x31180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC1_USR_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_PENDING_STS (at 0x3119)"
      tindex ezaxi:0xfc4cf980 %l 0x8031190 0x31190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC1_USR_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_MID_SEL (at 0x311a)"
      tindex ezaxi:0xfc4cf980 %l 0x80311a0 0x311a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC1_USR_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_PRIORITY (at 0x311b)"
      tindex ezaxi:0xfc4cf980 %l 0x80311b0 0x311b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC1_USR_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MODE_CTL (at 0x3140)"
      tindex ezaxi:0xfc4cf980 %l 0x8031400 0x31400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC1_USR_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_EN_CTL1 (at 0x3146)"
      tindex ezaxi:0xfc4cf980 %l 0x8031460 0x31460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC1_USR_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_ADC_CH_SEL_CTL (at 0x3148)"
      tindex ezaxi:0xfc4cf980 %l 0x8031480 0x31480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC1_USR_ADC_DIG_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_ADC_DIG_PARAM (at 0x3150)"
      tindex ezaxi:0xfc4cf980 %l 0x8031500 0x31500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC1_USR_HW_SETTLE_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_HW_SETTLE_DELAY (at 0x3151)"
      tindex ezaxi:0xfc4cf980 %l 0x8031510 0x31510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC1_USR_CONV_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_CONV_REQ (at 0x3152)"
      tindex ezaxi:0xfc4cf980 %l 0x8031520 0x31520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC1_USR_CONV_SEQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_CONV_SEQ_CTL (at 0x3154)"
      tindex ezaxi:0xfc4cf980 %l 0x8031540 0x31540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC1_USR_CONV_SEQ_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_CONV_SEQ_TRIG_CTL (at 0x3155)"
      tindex ezaxi:0xfc4cf980 %l 0x8031550 0x31550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MEAS_INTERVAL_CTL (at 0x3157)"
      tindex ezaxi:0xfc4cf980 %l 0x8031570 0x31570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_OP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MEAS_INTERVAL_OP_CTL (at 0x3159)"
      tindex ezaxi:0xfc4cf980 %l 0x8031590 0x31590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC1_USR_FAST_AVG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_FAST_AVG_CTL (at 0x315a)"
      tindex ezaxi:0xfc4cf980 %l 0x80315a0 0x315a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC1_USR_FAST_AVG_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_FAST_AVG_EN (at 0x315b)"
      tindex ezaxi:0xfc4cf980 %l 0x80315b0 0x315b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC1_USR_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_LOW_THR0 (at 0x315c)"
      tindex ezaxi:0xfc4cf980 %l 0x80315c0 0x315c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC1_USR_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_LOW_THR1 (at 0x315d)"
      tindex ezaxi:0xfc4cf980 %l 0x80315d0 0x315d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_HIGH_THR0 (at 0x315e)"
      tindex ezaxi:0xfc4cf980 %l 0x80315e0 0x315e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_HIGH_THR1 (at 0x315f)"
      tindex ezaxi:0xfc4cf980 %l 0x80315f0 0x315f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC1_USR_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_DATA0 (at 0x3160)"
      tindex ezaxi:0xfc4cf980 %l 0x8031600 0x31600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC1_USR_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_DATA1 (at 0x3161)"
      tindex ezaxi:0xfc4cf980 %l 0x8031610 0x31610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_LOW_THR0 (at 0x3162)"
      tindex ezaxi:0xfc4cf980 %l 0x8031620 0x31620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC1_USR_MIN_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_LOW_THR1 (at 0x3163)"
      tindex ezaxi:0xfc4cf980 %l 0x8031630 0x31630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC1_USR_MIN_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_DATA0 (at 0x3166)"
      tindex ezaxi:0xfc4cf980 %l 0x8031660 0x31660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC1_USR_MIN_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_MIN_DATA1 (at 0x3167)"
      tindex ezaxi:0xfc4cf980 %l 0x8031670 0x31670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC1_USR_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_SEC_ACCESS (at 0x31d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8031d00 0x31d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL1 (at 0x31d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8031d80 0x31d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL2 (at 0x31d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8031d90 0x31d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL3 (at 0x31da)"
      tindex ezaxi:0xfc4cf980 %l 0x8031da0 0x31da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_PERPH_RESET_CTL4 (at 0x31db)"
      tindex ezaxi:0xfc4cf980 %l 0x8031db0 0x31db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_TEST1 (at 0x31e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e00 0x31e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_INT_TEST_VAL (at 0x31e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e10 0x31e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC1_USR_TEST1_ADC_ANA_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST1_ADC_ANA_PARAM (at 0x31e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e20 0x31e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC1_USR_TEST2_ADC_DIG_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST2_ADC_DIG_PARAM (at 0x31e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e30 0x31e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0 (DEM_DISABLED),1 (DEM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0 (DECI_SEL),1 (FILTOUT_15_0),2 (FILTOUT_25_16),3 (DECI_SEL1)"
    tree.end
    tree "VADC1_USR_TEST3_ADC_RSV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST3_ADC_RSV (at 0x31e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e40 0x31e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0 (SINC2_OUTPUT),1 (SINC1_OUTPUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0 (RESET_DIG_FILT_FALSE),1 (RESET_DIG_FILT_TRUE)"
    tree.end
    tree "VADC1_USR_TEST4_ADC_ATEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST4_ADC_ATEST (at 0x31e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e50 0x31e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VOCM_0P60),1 (VOCM_0P65),2 (VOCM_0P70),3 (VOCM_0P75)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0 (ATEST3_DISABLED),1 (VTH_N),2 (VTH_P),3 (VICM),4 (VOCM),5 (VREFN),6 (VREFMID),7 (VREFP)"
    tree.end
    tree "VADC1_USR_TEST5_AMUX_ATEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST5_AMUX_ATEST (at 0x31e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e60 0x31e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_EN                                   = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
    tree.end
    tree "VADC1_USR_TEST6_DTEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TEST6_DTEST (at 0x31e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8031e70 0x31e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VADC1_USR_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM_NUM (at 0x31f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8031f00 0x31f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC1_USR_TRIM1_ADC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM1_ADC (at 0x31f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8031f10 0x31f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DAC_REF                                  = "
    tree.end
    tree "VADC1_USR_TRIM1_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM1_AMUX (at 0x31f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8031f20 0x31f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRESCALE_167_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM2_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM2_AMUX (at 0x31f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8031f30 0x31f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM4_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM4_AMUX (at 0x31f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8031f40 0x31f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_LOW_OFFSET                           = "
    tree.end
    tree "VADC1_USR_TRIM5_AMUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC1_USR_TRIM5_AMUX (at 0x31f5)"
      tindex ezaxi:0xfc4cf980 %l 0x8031f50 0x31f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_HIGH_OFFSET                          = "
    tree.end
  tree.end
tree.end
tree "VADC2_BTM"
  tree "VADC2_BTM"
    tree "VADC2_BTM_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_REVISION1 (at 0x3400)"
      tindex ezaxi:0xfc4cf980 %l 0x8034000 0x34000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_REVISION2 (at 0x3401)"
      tindex ezaxi:0xfc4cf980 %l 0x8034010 0x34010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_REVISION3 (at 0x3402)"
      tindex ezaxi:0xfc4cf980 %l 0x8034020 0x34020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_REVISION4 (at 0x3403)"
      tindex ezaxi:0xfc4cf980 %l 0x8034030 0x34030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC2_BTM_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_PERPH_TYPE (at 0x3404)"
      tindex ezaxi:0xfc4cf980 %l 0x8034040 0x34040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC2_BTM_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_PERPH_SUBTYPE (at 0x3405)"
      tindex ezaxi:0xfc4cf980 %l 0x8034050 0x34050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC2_BTM_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_STATUS1 (at 0x3408)"
      tindex ezaxi:0xfc4cf980 %l 0x8034080 0x34080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC2_BTM_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_STATUS2 (at 0x3409)"
      tindex ezaxi:0xfc4cf980 %l 0x8034090 0x34090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC2_BTM_STATUS_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_STATUS_LOW (at 0x340a)"
      tindex ezaxi:0xfc4cf980 %l 0x80340a0 0x340a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW                                   = " "0 (M7_LOW_FALSE),1 (M7_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW                                   = " "0 (M6_LOW_FALSE),1 (M6_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW                                   = " "0 (M5_LOW_FALSE),1 (M5_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW                                   = " "0 (M4_LOW_FALSE),1 (M4_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW                                   = " "0 (M3_LOW_FALSE),1 (M3_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW                                   = " "0 (M2_LOW_FALSE),1 (M2_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW                                   = " "0 (M1_LOW_FALSE),1 (M1_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW                                   = " "0 (M0_LOW_FALSE),1 (M0_LOW_TRUE)"
    tree.end
    tree "VADC2_BTM_STATUS_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_STATUS_HIGH (at 0x340b)"
      tindex ezaxi:0xfc4cf980 %l 0x80340b0 0x340b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH                                  = " "0 (M7_HIGH_FALSE),1 (M7_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH                                  = " "0 (M6_HIGH_FALSE),1 (M6_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH                                  = " "0 (M5_HIGH_FALSE),1 (M5_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH                                  = " "0 (M4_HIGH_FALSE),1 (M4_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH                                  = " "0 (M3_HIGH_FALSE),1 (M3_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH                                  = " "0 (M2_HIGH_FALSE),1 (M2_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH                                  = " "0 (M1_HIGH_FALSE),1 (M1_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH                                  = " "0 (M0_HIGH_FALSE),1 (M0_HIGH_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_RT_STS (at 0x3410)"
      tindex ezaxi:0xfc4cf980 %l 0x8034100 0x34100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC2_BTM_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_SET_TYPE (at 0x3411)"
      tindex ezaxi:0xfc4cf980 %l 0x8034110 0x34110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_POLARITY_HIGH (at 0x3412)"
      tindex ezaxi:0xfc4cf980 %l 0x8034120 0x34120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_POLARITY_LOW (at 0x3413)"
      tindex ezaxi:0xfc4cf980 %l 0x8034130 0x34130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_LATCHED_CLR (at 0x3414)"
      tindex ezaxi:0xfc4cf980 %l 0x8034140 0x34140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC2_BTM_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_EN_SET (at 0x3415)"
      tindex ezaxi:0xfc4cf980 %l 0x8034150 0x34150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_BTM_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_EN_CLR (at 0x3416)"
      tindex ezaxi:0xfc4cf980 %l 0x8034160 0x34160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_BTM_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_LATCHED_STS (at 0x3418)"
      tindex ezaxi:0xfc4cf980 %l 0x8034180 0x34180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_PENDING_STS (at 0x3419)"
      tindex ezaxi:0xfc4cf980 %l 0x8034190 0x34190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_MID_SEL (at 0x341a)"
      tindex ezaxi:0xfc4cf980 %l 0x80341a0 0x341a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC2_BTM_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_PRIORITY (at 0x341b)"
      tindex ezaxi:0xfc4cf980 %l 0x80341b0 0x341b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC2_BTM_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_MODE_CTL (at 0x3440)"
      tindex ezaxi:0xfc4cf980 %l 0x8034400 0x34400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC2_BTM_MULTI_MEAS_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_MULTI_MEAS_EN (at 0x3441)"
      tindex ezaxi:0xfc4cf980 %l 0x8034410 0x34410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_MEAS_EN                               = " "0 (M7_MEAS_DISABLE),1 (M7_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_MEAS_EN                               = " "0 (M6_MEAS_DISABLE),1 (M6_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_MEAS_EN                               = " "0 (M5_MEAS_DISABLE),1 (M5_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_MEAS_EN                               = " "0 (M4_MEAS_DISABLE),1 (M4_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_MEAS_EN                               = " "0 (M3_MEAS_DISABLE),1 (M3_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_MEAS_EN                               = " "0 (M2_MEAS_DISABLE),1 (M2_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_MEAS_EN                               = " "0 (M1_MEAS_DISABLE),1 (M1_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_MEAS_EN                               = " "0 (M0_MEAS_DISABLE),1 (M0_MEAS_ENABLE)"
    tree.end
    tree "VADC2_BTM_LOW_THR_INT_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_LOW_THR_INT_EN (at 0x3442)"
      tindex ezaxi:0xfc4cf980 %l 0x8034420 0x34420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW_THR_INT_EN                        = " "0 (M7_LOW_THR_INT_DISABLED),1 (M7_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW_THR_INT_EN                        = " "0 (M6_LOW_THR_INT_DISABLED),1 (M6_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW_THR_INT_EN                        = " "0 (M5_LOW_THR_INT_DISABLED),1 (M5_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW_THR_INT_EN                        = " "0 (M4_LOW_THR_INT_DISABLED),1 (M4_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW_THR_INT_EN                        = " "0 (M3_LOW_THR_INT_DISABLED),1 (M3_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW_THR_INT_EN                        = " "0 (M2_LOW_THR_INT_DISABLED),1 (M2_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW_THR_INT_EN                        = " "0 (M1_LOW_THR_INT_DISABLED),1 (M1_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW_THR_INT_EN                        = " "0 (M0_LOW_THR_INT_DISABLED),1 (M0_LOW_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_BTM_HIGH_THR_INT_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_HIGH_THR_INT_EN (at 0x3443)"
      tindex ezaxi:0xfc4cf980 %l 0x8034430 0x34430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH_THR_INT_EN                       = " "0 (M7_HIGH_THR_INT_DISABLED),1 (M7_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH_THR_INT_EN                       = " "0 (M6_HIGH_THR_INT_DISABLED),1 (M6_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH_THR_INT_EN                       = " "0 (M5_HIGH_THR_INT_DISABLED),1 (M5_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH_THR_INT_EN                       = " "0 (M4_HIGH_THR_INT_DISABLED),1 (M4_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH_THR_INT_EN                       = " "0 (M3_HIGH_THR_INT_DISABLED),1 (M3_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH_THR_INT_EN                       = " "0 (M2_HIGH_THR_INT_DISABLED),1 (M2_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH_THR_INT_EN                       = " "0 (M1_HIGH_THR_INT_DISABLED),1 (M1_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH_THR_INT_EN                       = " "0 (M0_HIGH_THR_INT_DISABLED),1 (M0_HIGH_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_BTM_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_EN_CTL1 (at 0x3446)"
      tindex ezaxi:0xfc4cf980 %l 0x8034460 0x34460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC2_BTM_M0_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M0_ADC_CH_SEL_CTL (at 0x3448)"
      tindex ezaxi:0xfc4cf980 %l 0x8034480 0x34480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_ADC_DIG_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_ADC_DIG_PARAM (at 0x3450)"
      tindex ezaxi:0xfc4cf980 %l 0x8034500 0x34500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC2_BTM_HW_SETTLE_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_HW_SETTLE_DELAY (at 0x3451)"
      tindex ezaxi:0xfc4cf980 %l 0x8034510 0x34510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC2_BTM_CONV_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_CONV_REQ (at 0x3452)"
      tindex ezaxi:0xfc4cf980 %l 0x8034520 0x34520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC2_BTM_CONV_SEQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_CONV_SEQ_CTL (at 0x3454)"
      tindex ezaxi:0xfc4cf980 %l 0x8034540 0x34540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC2_BTM_CONV_SEQ_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_CONV_SEQ_TRIG_CTL (at 0x3455)"
      tindex ezaxi:0xfc4cf980 %l 0x8034550 0x34550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_MEAS_INTERVAL_CTL (at 0x3457)"
      tindex ezaxi:0xfc4cf980 %l 0x8034570 0x34570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME1                      = "
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_MEAS_INTERVAL_CTL2 (at 0x3458)"
      tindex ezaxi:0xfc4cf980 %l 0x8034580 0x34580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MEAS_INTERVAL_TIME2                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME3                      = "
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_OP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_MEAS_INTERVAL_OP_CTL (at 0x3459)"
      tindex ezaxi:0xfc4cf980 %l 0x8034590 0x34590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M0_MEAS_INTERVAL_TIME                    = " "0 (M0_USING_TIMER1),1 (M0_USING_TIMER2),2 (M0_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_FAST_AVG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_FAST_AVG_CTL (at 0x345a)"
      tindex ezaxi:0xfc4cf980 %l 0x80345a0 0x345a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC2_BTM_FAST_AVG_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_FAST_AVG_EN (at 0x345b)"
      tindex ezaxi:0xfc4cf980 %l 0x80345b0 0x345b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC2_BTM_M0_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M0_LOW_THR0 (at 0x345c)"
      tindex ezaxi:0xfc4cf980 %l 0x80345c0 0x345c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M0_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M0_LOW_THR1 (at 0x345d)"
      tindex ezaxi:0xfc4cf980 %l 0x80345d0 0x345d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M0_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M0_HIGH_THR0 (at 0x345e)"
      tindex ezaxi:0xfc4cf980 %l 0x80345e0 0x345e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M0_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M0_HIGH_THR1 (at 0x345f)"
      tindex ezaxi:0xfc4cf980 %l 0x80345f0 0x345f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M0_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M0_DATA0 (at 0x3460)"
      tindex ezaxi:0xfc4cf980 %l 0x8034600 0x34600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M0_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M0_DATA1 (at 0x3461)"
      tindex ezaxi:0xfc4cf980 %l 0x8034610 0x34610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M1_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_ADC_CH_SEL_CTL (at 0x3468)"
      tindex ezaxi:0xfc4cf980 %l 0x8034680 0x34680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M1_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_LOW_THR0 (at 0x3469)"
      tindex ezaxi:0xfc4cf980 %l 0x8034690 0x34690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M1_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_LOW_THR1 (at 0x346a)"
      tindex ezaxi:0xfc4cf980 %l 0x80346a0 0x346a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M1_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_HIGH_THR0 (at 0x346b)"
      tindex ezaxi:0xfc4cf980 %l 0x80346b0 0x346b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M1_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_HIGH_THR1 (at 0x346c)"
      tindex ezaxi:0xfc4cf980 %l 0x80346c0 0x346c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M1_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_MEAS_INTERVAL_CTL (at 0x346d)"
      tindex ezaxi:0xfc4cf980 %l 0x80346d0 0x346d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M1_MEAS_INTERVAL_TIME                    = " "0 (M1_USING_TIMER1),1 (M1_USING_TIMER2),2 (M1_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M2_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_ADC_CH_SEL_CTL (at 0x3470)"
      tindex ezaxi:0xfc4cf980 %l 0x8034700 0x34700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M2_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_LOW_THR0 (at 0x3471)"
      tindex ezaxi:0xfc4cf980 %l 0x8034710 0x34710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M2_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_LOW_THR1 (at 0x3472)"
      tindex ezaxi:0xfc4cf980 %l 0x8034720 0x34720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M2_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_HIGH_THR0 (at 0x3473)"
      tindex ezaxi:0xfc4cf980 %l 0x8034730 0x34730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M2_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_HIGH_THR1 (at 0x3474)"
      tindex ezaxi:0xfc4cf980 %l 0x8034740 0x34740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M2_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_MEAS_INTERVAL_CTL (at 0x3475)"
      tindex ezaxi:0xfc4cf980 %l 0x8034750 0x34750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M2_MEAS_INTERVAL_TIME                    = " "0 (M2_USING_TIMER1),1 (M2_USING_TIMER2),2 (M2_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M3_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_ADC_CH_SEL_CTL (at 0x3478)"
      tindex ezaxi:0xfc4cf980 %l 0x8034780 0x34780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M3_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_LOW_THR0 (at 0x3479)"
      tindex ezaxi:0xfc4cf980 %l 0x8034790 0x34790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M3_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_LOW_THR1 (at 0x347a)"
      tindex ezaxi:0xfc4cf980 %l 0x80347a0 0x347a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M3_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_HIGH_THR0 (at 0x347b)"
      tindex ezaxi:0xfc4cf980 %l 0x80347b0 0x347b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M3_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_HIGH_THR1 (at 0x347c)"
      tindex ezaxi:0xfc4cf980 %l 0x80347c0 0x347c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M3_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_MEAS_INTERVAL_CTL (at 0x347d)"
      tindex ezaxi:0xfc4cf980 %l 0x80347d0 0x347d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M3_MEAS_INTERVAL_TIME                    = " "0 (M3_USING_TIMER1),1 (M3_USING_TIMER2),2 (M3_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M4_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_ADC_CH_SEL_CTL (at 0x3480)"
      tindex ezaxi:0xfc4cf980 %l 0x8034800 0x34800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M4_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_LOW_THR0 (at 0x3481)"
      tindex ezaxi:0xfc4cf980 %l 0x8034810 0x34810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M4_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_LOW_THR1 (at 0x3482)"
      tindex ezaxi:0xfc4cf980 %l 0x8034820 0x34820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M4_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_HIGH_THR0 (at 0x3483)"
      tindex ezaxi:0xfc4cf980 %l 0x8034830 0x34830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M4_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_HIGH_THR1 (at 0x3484)"
      tindex ezaxi:0xfc4cf980 %l 0x8034840 0x34840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M4_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_MEAS_INTERVAL_CTL (at 0x3485)"
      tindex ezaxi:0xfc4cf980 %l 0x8034850 0x34850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M4_MEAS_INTERVAL_TIME                    = " "0 (M4_USING_TIMER1),1 (M4_USING_TIMER2),2 (M4_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M5_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_ADC_CH_SEL_CTL (at 0x3488)"
      tindex ezaxi:0xfc4cf980 %l 0x8034880 0x34880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M5_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_LOW_THR0 (at 0x3489)"
      tindex ezaxi:0xfc4cf980 %l 0x8034890 0x34890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M5_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_LOW_THR1 (at 0x348a)"
      tindex ezaxi:0xfc4cf980 %l 0x80348a0 0x348a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M5_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_HIGH_THR0 (at 0x348b)"
      tindex ezaxi:0xfc4cf980 %l 0x80348b0 0x348b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M5_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_HIGH_THR1 (at 0x348c)"
      tindex ezaxi:0xfc4cf980 %l 0x80348c0 0x348c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M5_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_MEAS_INTERVAL_CTL (at 0x348d)"
      tindex ezaxi:0xfc4cf980 %l 0x80348d0 0x348d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M5_MEAS_INTERVAL_TIME                    = " "0 (M5_USING_TIMER1),1 (M5_USING_TIMER2),2 (M5_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M6_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_ADC_CH_SEL_CTL (at 0x3490)"
      tindex ezaxi:0xfc4cf980 %l 0x8034900 0x34900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M6_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_LOW_THR0 (at 0x3491)"
      tindex ezaxi:0xfc4cf980 %l 0x8034910 0x34910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M6_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_LOW_THR1 (at 0x3492)"
      tindex ezaxi:0xfc4cf980 %l 0x8034920 0x34920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M6_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_HIGH_THR0 (at 0x3493)"
      tindex ezaxi:0xfc4cf980 %l 0x8034930 0x34930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M6_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_HIGH_THR1 (at 0x3494)"
      tindex ezaxi:0xfc4cf980 %l 0x8034940 0x34940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M6_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_MEAS_INTERVAL_CTL (at 0x3495)"
      tindex ezaxi:0xfc4cf980 %l 0x8034950 0x34950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M6_MEAS_INTERVAL_TIME                    = " "0 (M6_USING_TIMER1),1 (M6_USING_TIMER2),2 (M6_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M7_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_ADC_CH_SEL_CTL (at 0x3498)"
      tindex ezaxi:0xfc4cf980 %l 0x8034980 0x34980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M7_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_LOW_THR0 (at 0x3499)"
      tindex ezaxi:0xfc4cf980 %l 0x8034990 0x34990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M7_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_LOW_THR1 (at 0x349a)"
      tindex ezaxi:0xfc4cf980 %l 0x80349a0 0x349a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M7_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_HIGH_THR0 (at 0x349b)"
      tindex ezaxi:0xfc4cf980 %l 0x80349b0 0x349b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M7_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_HIGH_THR1 (at 0x349c)"
      tindex ezaxi:0xfc4cf980 %l 0x80349c0 0x349c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M7_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_MEAS_INTERVAL_CTL (at 0x349d)"
      tindex ezaxi:0xfc4cf980 %l 0x80349d0 0x349d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M7_MEAS_INTERVAL_TIME                    = " "0 (M7_USING_TIMER1),1 (M7_USING_TIMER2),2 (M7_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M1_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_DATA0 (at 0x34a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a00 0x34a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M1_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M1_DATA1 (at 0x34a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a10 0x34a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M2_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_DATA0 (at 0x34a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a20 0x34a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M2_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M2_DATA1 (at 0x34a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a30 0x34a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M3_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_DATA0 (at 0x34a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a40 0x34a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M3_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M3_DATA1 (at 0x34a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a50 0x34a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M4_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_DATA0 (at 0x34a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a60 0x34a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M4_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M4_DATA1 (at 0x34a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a70 0x34a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M5_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_DATA0 (at 0x34a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a80 0x34a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M5_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M5_DATA1 (at 0x34a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8034a90 0x34a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M6_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_DATA0 (at 0x34aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8034aa0 0x34aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M6_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M6_DATA1 (at 0x34ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8034ab0 0x34ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M7_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_DATA0 (at 0x34ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8034ac0 0x34ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M7_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_M7_DATA1 (at 0x34ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8034ad0 0x34ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_SEC_ACCESS (at 0x34d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8034d00 0x34d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_PERPH_RESET_CTL1 (at 0x34d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8034d80 0x34d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_PERPH_RESET_CTL2 (at 0x34d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8034d90 0x34d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_PERPH_RESET_CTL3 (at 0x34da)"
      tindex ezaxi:0xfc4cf980 %l 0x8034da0 0x34da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_PERPH_RESET_CTL4 (at 0x34db)"
      tindex ezaxi:0xfc4cf980 %l 0x8034db0 0x34db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_TEST1 (at 0x34e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8034e00 0x34e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_INT_TEST_VAL (at 0x34e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8034e10 0x34e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC2_BTM_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC2_BTM_TEST1 (at 0x34e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8034e20 0x34e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEL_FSM                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "VADC3_MDM"
  tree "VADC3_MDM"
    tree "VADC3_MDM_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_REVISION1 (at 0x3200)"
      tindex ezaxi:0xfc4cf980 %l 0x8032000 0x32000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_REVISION2 (at 0x3201)"
      tindex ezaxi:0xfc4cf980 %l 0x8032010 0x32010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_REVISION3 (at 0x3202)"
      tindex ezaxi:0xfc4cf980 %l 0x8032020 0x32020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_REVISION4 (at 0x3203)"
      tindex ezaxi:0xfc4cf980 %l 0x8032030 0x32030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_MDM_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_PERPH_TYPE (at 0x3204)"
      tindex ezaxi:0xfc4cf980 %l 0x8032040 0x32040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_MDM_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_PERPH_SUBTYPE (at 0x3205)"
      tindex ezaxi:0xfc4cf980 %l 0x8032050 0x32050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_MDM_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_STATUS1 (at 0x3208)"
      tindex ezaxi:0xfc4cf980 %l 0x8032080 0x32080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_MDM_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_STATUS2 (at 0x3209)"
      tindex ezaxi:0xfc4cf980 %l 0x8032090 0x32090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_RT_STS (at 0x3210)"
      tindex ezaxi:0xfc4cf980 %l 0x8032100 0x32100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_RT_STS                   = " "0 (MIN_LOW_THR_INT_FALSE),1 (MIN_LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_SET_TYPE (at 0x3211)"
      tindex ezaxi:0xfc4cf980 %l 0x8032110 0x32110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_SET_TYPE                 = " "0 (MIN_LOW_THR_INT_LEVEL),1 (MIN_LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_MDM_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_POLARITY_HIGH (at 0x3212)"
      tindex ezaxi:0xfc4cf980 %l 0x8032120 0x32120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_HIGH_DISABLED),1 (MIN_LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_MDM_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_POLARITY_LOW (at 0x3213)"
      tindex ezaxi:0xfc4cf980 %l 0x8032130 0x32130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_HIGH                     = " "0 (MIN_LOW_THR_INT_POL_LOW_DISABLED),1 (MIN_LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_MDM_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_LATCHED_CLR (at 0x3214)"
      tindex ezaxi:0xfc4cf980 %l 0x8032140 0x32140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_MDM_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_EN_SET (at 0x3215)"
      tindex ezaxi:0xfc4cf980 %l 0x8032150 0x32150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_SET                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_MDM_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_EN_CLR (at 0x3216)"
      tindex ezaxi:0xfc4cf980 %l 0x8032160 0x32160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_EN_CLR                   = " "0 (MIN_LOW_THR_INT_DISABLED),1 (MIN_LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_MDM_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_LATCHED_STS (at 0x3218)"
      tindex ezaxi:0xfc4cf980 %l 0x8032180 0x32180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_LATCHED_STS              = " "0 (MIN_LOW_THR_INT_LATCHED_FALSE),1 (MIN_LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_PENDING_STS (at 0x3219)"
      tindex ezaxi:0xfc4cf980 %l 0x8032190 0x32190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_PENDING_STS              = " "0 (MIN_LOW_THR_INT_PENDING_FALSE),1 (MIN_LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_MID_SEL (at 0x321a)"
      tindex ezaxi:0xfc4cf980 %l 0x80321a0 0x321a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_MDM_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_PRIORITY (at 0x321b)"
      tindex ezaxi:0xfc4cf980 %l 0x80321b0 0x321b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_MDM_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_MODE_CTL (at 0x3240)"
      tindex ezaxi:0xfc4cf980 %l 0x8032400 0x32400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_MDM_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_EN_CTL1 (at 0x3246)"
      tindex ezaxi:0xfc4cf980 %l 0x8032460 0x32460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_MDM_ADC_CH_SEL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_ADC_CH_SEL_CTL (at 0x3248)"
      tindex ezaxi:0xfc4cf980 %l 0x8032480 0x32480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_MDM_ADC_DIG_PARAM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_ADC_DIG_PARAM (at 0x3250)"
      tindex ezaxi:0xfc4cf980 %l 0x8032500 0x32500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_MDM_HW_SETTLE_DELAY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_HW_SETTLE_DELAY (at 0x3251)"
      tindex ezaxi:0xfc4cf980 %l 0x8032510 0x32510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_MDM_CONV_REQ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_CONV_REQ (at 0x3252)"
      tindex ezaxi:0xfc4cf980 %l 0x8032520 0x32520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_MDM_CONV_SEQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_CONV_SEQ_CTL (at 0x3254)"
      tindex ezaxi:0xfc4cf980 %l 0x8032540 0x32540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_MDM_CONV_SEQ_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_CONV_SEQ_TRIG_CTL (at 0x3255)"
      tindex ezaxi:0xfc4cf980 %l 0x8032550 0x32550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_MEAS_INTERVAL_CTL (at 0x3257)"
      tindex ezaxi:0xfc4cf980 %l 0x8032570 0x32570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_OP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_MEAS_INTERVAL_OP_CTL (at 0x3259)"
      tindex ezaxi:0xfc4cf980 %l 0x8032590 0x32590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_MDM_FAST_AVG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_FAST_AVG_CTL (at 0x325a)"
      tindex ezaxi:0xfc4cf980 %l 0x80325a0 0x325a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_MDM_FAST_AVG_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_FAST_AVG_EN (at 0x325b)"
      tindex ezaxi:0xfc4cf980 %l 0x80325b0 0x325b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_MDM_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_LOW_THR0 (at 0x325c)"
      tindex ezaxi:0xfc4cf980 %l 0x80325c0 0x325c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_MDM_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_LOW_THR1 (at 0x325d)"
      tindex ezaxi:0xfc4cf980 %l 0x80325d0 0x325d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_HIGH_THR0 (at 0x325e)"
      tindex ezaxi:0xfc4cf980 %l 0x80325e0 0x325e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_HIGH_THR1 (at 0x325f)"
      tindex ezaxi:0xfc4cf980 %l 0x80325f0 0x325f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_MDM_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_DATA0 (at 0x3260)"
      tindex ezaxi:0xfc4cf980 %l 0x8032600 0x32600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_MDM_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_DATA1 (at 0x3261)"
      tindex ezaxi:0xfc4cf980 %l 0x8032610 0x32610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_MDM_MIN_LOW_THR0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_MIN_LOW_THR0 (at 0x3262)"
      tindex ezaxi:0xfc4cf980 %l 0x8032620 0x32620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_7_0                          = "
    tree.end
    tree "VADC3_MDM_MIN_LOW_THR1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_MIN_LOW_THR1 (at 0x3263)"
      tindex ezaxi:0xfc4cf980 %l 0x8032630 0x32630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_LOW_THR_15_8                         = "
    tree.end
    tree "VADC3_MDM_MIN_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_MIN_DATA0 (at 0x3266)"
      tindex ezaxi:0xfc4cf980 %l 0x8032660 0x32660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_7_0                             = "
    tree.end
    tree "VADC3_MDM_MIN_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_MIN_DATA1 (at 0x3267)"
      tindex ezaxi:0xfc4cf980 %l 0x8032670 0x32670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIN_DATA_15_8                            = "
    tree.end
    tree "VADC3_MDM_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_SEC_ACCESS (at 0x32d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8032d00 0x32d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_PERPH_RESET_CTL1 (at 0x32d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8032d80 0x32d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_PERPH_RESET_CTL2 (at 0x32d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8032d90 0x32d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_PERPH_RESET_CTL3 (at 0x32da)"
      tindex ezaxi:0xfc4cf980 %l 0x8032da0 0x32da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_PERPH_RESET_CTL4 (at 0x32db)"
      tindex ezaxi:0xfc4cf980 %l 0x8032db0 0x32db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_TEST1 (at 0x32e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8032e00 0x32e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_INT_TEST_VAL (at 0x32e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8032e10 0x32e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MIN_LOW_THR_INT_TEST_VAL                 = " "0 (MIN_LOW_THR_INT_TEST_FALSE),1 (MIN_LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_MDM_TEST6_DTEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VADC3_MDM_TEST6_DTEST (at 0x32e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8032e70 0x32e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VREFLPDDR"
  tree "VREFLPDDR"
    tree "VREFLPDDR_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_REVISION1 (at 0xa00)"
      tindex ezaxi:0xfc4cf980 %l 0x800a000 0xa000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_REVISION2 (at 0xa01)"
      tindex ezaxi:0xfc4cf980 %l 0x800a010 0xa010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_REVISION3 (at 0xa02)"
      tindex ezaxi:0xfc4cf980 %l 0x800a020 0xa020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_REVISION4 (at 0xa03)"
      tindex ezaxi:0xfc4cf980 %l 0x800a030 0xa030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_PERPH_TYPE (at 0xa04)"
      tindex ezaxi:0xfc4cf980 %l 0x800a040 0xa040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREFLPDDR_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_PERPH_SUBTYPE (at 0xa05)"
      tindex ezaxi:0xfc4cf980 %l 0x800a050 0xa050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREFLPDDR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_STATUS1 (at 0xa08)"
      tindex ezaxi:0xfc4cf980 %l 0x800a080 0xa080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_OK                                  = " "0 (VREF_CA_DQ_DISABLED),1 (VREF_CA_DQ_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_EBI1_DQ_OK                          = " "0 (VREF_EBI1_DQ_DISABLED),1 (VREF_EBI1_DQ_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREF_EBI1_CA_OK                          = " "0 (VREF_EBI1_CA_DISABLED),1 (VREF_EBI1_CA_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VREF_EBI0_DQ_OK                          = " "0 (VREF_EBI0_DQ_DISABLED),1 (VREF_EBI0_DQ_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREF_EBI0_CA_OK                          = " "0 (VREF_EBI0_CA_DISABLED),1 (VREF_EBI0_CA_ENABLED)"
    tree.end
    tree "VREFLPDDR_VREF_CA_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_VREF_CA_VOLTAGE (at 0xa40)"
      tindex ezaxi:0xfc4cf980 %l 0x800a400 0xa400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ODT_EN_CA1                               = " "0 (VREF_CA1_ODT_DISABLED),1 (VREF_CA1_ODT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ODT_EN_CA0                               = " "0 (VREF_CA0_ODT_DISABLED),1 (VREF_CA0_ODT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   VOLTAGE_SEL_CA1                          = " "0 (VREF_CA1_VSEL_0),1 (VREF_CA1_VSEL_1),2 (VREF_CA1_VSEL_2),3 (VREF_CA1_VSEL_3),4 (VREF_CA1_VSEL_4),5 (VREF_CA1_VSEL_5),6 (VREF_CA1_VSEL_6),7 (VREF_CA1_VSEL_7)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL_CA0                          = " "0 (VREF_CA0_VSEL_0),1 (VREF_CA0_VSEL_1),2 (VREF_CA0_VSEL_2),3 (VREF_CA0_VSEL_3),4 (VREF_CA0_VSEL_4),5 (VREF_CA0_VSEL_5),6 (VREF_CA0_VSEL_6),7 (VREF_CA0_VSEL_7)"
    tree.end
    tree "VREFLPDDR_VREF_DQ_VOLTAGE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_VREF_DQ_VOLTAGE (at 0xa41)"
      tindex ezaxi:0xfc4cf980 %l 0x800a410 0xa410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ODT_EN_DQ1                               = " "0 (VREF_DQ1_ODT_DISABLED),1 (VREF_DQ1_ODT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ODT_EN_DQ0                               = " "0 (VREF_DQ0_ODT_DISABLED),1 (VREF_DQ0_ODT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   VOLTAGE_SEL_DQ1                          = " "0 (VREF_DQ1_VSEL_0),1 (VREF_DQ1_VSEL_1),2 (VREF_DQ1_VSEL_2),3 (VREF_DQ1_VSEL_3),4 (VREF_DQ1_VSEL_4),5 (VREF_DQ1_VSEL_5),6 (VREF_DQ1_VSEL_6),7 (VREF_DQ1_VSEL_7)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL_DQ0                          = " "0 (VREF_DQ0_VSEL_0),1 (VREF_DQ0_VSEL_1),2 (VREF_DQ0_VSEL_2),3 (VREF_DQ0_VSEL_3),4 (VREF_DQ0_VSEL_4),5 (VREF_DQ0_VSEL_5),6 (VREF_DQ0_VSEL_6),7 (VREF_DQ0_VSEL_7)"
    tree.end
    tree "VREFLPDDR_VREF_CA_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_VREF_CA_EN (at 0xa44)"
      tindex ezaxi:0xfc4cf980 %l 0x800a440 0xa440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN_CA1                               = " "0 (VREF_CA1_DISABLED),1 (VREF_CA1_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   REF_EN_CA0                               = " "0 (VREF_CA0_DISABLED),1 (VREF_CA0_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN2_CA1                        = " "0 (VREF_CA1_FOLLOW_SLEEPB_DISABLED),1 (VREF_CA1_FOLLOW_SLEEPB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN1_CA1                        = " "0 (VREF_CA1_FOLLOW_VREGOK_DISABLED),1 (VREF_CA1_FOLLOW_VREGOK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN2_CA0                        = " "0 (VREF_CA0_FOLLOW_SLEEPB_DISABLED),1 (VREF_CA0_FOLLOW_SLEEPB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN1_CA0                        = " "0 (VREF_CA0_FOLLOW_VREGOK_DISABLED),1 (VREF_CA0_FOLLOW_VREGOK_ENABLED)"
    tree.end
    tree "VREFLPDDR_VREF_DQ_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_VREF_DQ_EN (at 0xa45)"
      tindex ezaxi:0xfc4cf980 %l 0x800a450 0xa450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN_DQ1                               = " "0 (VREF_DQ1_DISABLED),1 (VREF_DQ1_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   REF_EN_DQ0                               = " "0 (VREF_DQ0_DISABLED),1 (VREF_DQ0_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN2_DQ1                        = " "0 (VREF_DQ1_FOLLOW_SLEEPB_DISABLED),1 (VREF_DQ1_FOLLOW_SLEEPB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN1_DQ1                        = " "0 (VREF_DQ1_FOLLOW_VREGOK_DISABLED),1 (VREF_DQ1_FOLLOW_VREGOK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN2_DQ0                        = " "0 (VREF_DQ0_FOLLOW_SLEEPB_DISABLED),1 (VREF_DQ0_FOLLOW_SLEEPB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN1_DQ0                        = " "0 (VREF_DQ0_FOLLOW_VREGOK_DISABLED),1 (VREF_DQ0_FOLLOW_VREGOK_ENABLED)"
    tree.end
    tree "VREFLPDDR_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_EN_CTL1 (at 0xa46)"
      tindex ezaxi:0xfc4cf980 %l 0x800a460 0xa460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (VREF_DISABLED),1 (VREF_ENABLED)"
    tree.end
    tree "VREFLPDDR_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_SEC_ACCESS (at 0xad0)"
      tindex ezaxi:0xfc4cf980 %l 0x800ad00 0xad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_PERPH_RESET_CTL1 (at 0xad8)"
      tindex ezaxi:0xfc4cf980 %l 0x800ad80 0xad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_PERPH_RESET_CTL2 (at 0xad9)"
      tindex ezaxi:0xfc4cf980 %l 0x800ad90 0xad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_PERPH_RESET_CTL3 (at 0xada)"
      tindex ezaxi:0xfc4cf980 %l 0x800ada0 0xada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_PERPH_RESET_CTL4 (at 0xadb)"
      tindex ezaxi:0xfc4cf980 %l 0x800adb0 0xadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "VREFLPDDR_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_TRIM_NUM (at 0xaf0)"
      tindex ezaxi:0xfc4cf980 %l 0x800af00 0xaf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREFLPDDR_TRIM_VAL_EBI0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_TRIM_VAL_EBI0 (at 0xaf1)"
      tindex ezaxi:0xfc4cf980 %l 0x800af10 0xaf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VREF_DQ0_TRIM_VALUE                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_CA0_TRIM_VALUE                      = "
    tree.end
    tree "VREFLPDDR_TRIM_VAL_EBI1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "VREFLPDDR_TRIM_VAL_EBI1 (at 0xaf2)"
      tindex ezaxi:0xfc4cf980 %l 0x800af20 0xaf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VREF_DQ1_TRIM_VALUE                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_CA1_TRIM_VALUE                      = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_REVISION1 (at 0x5000)"
      tindex ezaxi:0xfc4cf980 %l 0x8050000 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_REVISION2 (at 0x5001)"
      tindex ezaxi:0xfc4cf980 %l 0x8050010 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_REVISION3 (at 0x5002)"
      tindex ezaxi:0xfc4cf980 %l 0x8050020 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_REVISION4 (at 0x5003)"
      tindex ezaxi:0xfc4cf980 %l 0x8050030 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_PERPH_TYPE (at 0x5004)"
      tindex ezaxi:0xfc4cf980 %l 0x8050040 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_PERPH_SUBTYPE (at 0x5005)"
      tindex ezaxi:0xfc4cf980 %l 0x8050050 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_STATUS1 (at 0x5008)"
      tindex ezaxi:0xfc4cf980 %l 0x8050080 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_OK                                = " "0 (XO19M_OFF),1 (XO19M_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SLEEP_B                                  = " "0 (PMIC_HW_SLEEP),1 (PMIC_HW_AWAKE)"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_VOLTAGE_CTL1 (at 0x5040)"
      tindex ezaxi:0xfc4cf980 %l 0x8050400 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0 (AUTO),1 (VREG_XO),2 (VREG_SMPS),3 (XVDD)"
    tree.end
    tree "XO_MODE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_MODE_CTL1 (at 0x5044)"
      tindex ezaxi:0xfc4cf980 %l 0x8050440 0x50440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUFF_CORNER                        = " "0 (LOW_CORNER),1 (HIGH_CORNER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_PREBUFF_MODE                          = " "0 (NPM),1 (HPM)"
    tree.end
    tree "XO_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_EN_CTL (at 0x5046)"
      tindex ezaxi:0xfc4cf980 %l 0x8050460 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0 (XO19M_NOT_FORCED),1 (XO19M_FORCED_ON)"
    tree.end
    tree "XO_XO_TIMER1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_XO_TIMER1 (at 0x504c)"
      tindex ezaxi:0xfc4cf980 %l 0x80504c0 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   XO_TIMER_LSB                             = "
    tree.end
    tree "XO_XO_TIMER2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_XO_TIMER2 (at 0x504d)"
      tindex ezaxi:0xfc4cf980 %l 0x80504d0 0x504d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   XO_TIMER_MSB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "XO_XO_STEPPER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_XO_STEPPER (at 0x505a)"
      tindex ezaxi:0xfc4cf980 %l 0x80505a0 0x505a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_SS_DELAY_EN                           = " "0 (XO_FASTSTART_DIS),1 (XO_FAST_START_EN)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_SS_DELAY                              = "
    tree.end
    tree "XO_XO_ADJ_FINE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_XO_ADJ_FINE (at 0x505c)"
      tindex ezaxi:0xfc4cf980 %l 0x80505c0 0x505c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   XO_ADJUST_CAP                            = "
    tree.end
    tree "XO_XO_ADJ_COARSE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_XO_ADJ_COARSE (at 0x505b)"
      tindex ezaxi:0xfc4cf980 %l 0x80505b0 0x505b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_FIXED_CAP_EN1                         = " "0 (FIX_CAP1_DIS),1 (FIX_CAP1_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XO_FIXED_CAP_EN2                         = " "0 (FIX_CAP2_DIS),1 (FIX_CAP2_EN)"
    tree.end
    tree "XO_XO_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_XO_CTL (at 0x505e)"
      tindex ezaxi:0xfc4cf980 %l 0x80505e0 0x505e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICTL_MIS4                                = " "0 (XO_BIAS3_DIS),1 (XO_BIAS3_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ICTL_MIS3                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ICTL_MIS2                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICTL_MIS1                                = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ICTL_SLP                                 = " "0 (XO_BIAS1_DIS),1 (XO_BIAS1_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_RATE                                  = " "0 (TCXO_DIV_8),1 (TCXO_DIV_16),2 (TCXO_DIV_128),3 (TCXO_DIV_256)"
    tree.end
    tree "XO_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_SEC_ACCESS (at 0x50d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8050d00 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "XO_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_PERPH_RESET_CTL2 (at 0x50d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8050d90 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_PERPH_RESET_CTL3 (at 0x50da)"
      tindex ezaxi:0xfc4cf980 %l 0x8050da0 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_PERPH_RESET_CTL4 (at 0x50db)"
      tindex ezaxi:0xfc4cf980 %l 0x8050db0 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "XO_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_TEST1 (at 0x50e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8050e20 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST1_SEL                               = " "0 (HIZ),1 (XO19M),2 (OUTBUG_EN),3 (OUTBUFF_EN_DLY),4 (STEPPER_DONE),5 (SLEEP_B),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   XO_AGC_TEST_EN                           = " "0 (ATEST1_HI_Z),1 (XO_AGC_ON_ATEST)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADJ_CODE_TEST                            = " "0 (GRAY_CODE),1 (BINARY_CODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SS_RESET                                 = " "0 (NORMAL),1 (RESET_STEPPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUF_FOLLOW_BB                      = " "0 (RFPREBUFF_NOT_FOLLOW_BB),1 (RFPREBUFF_FOLLOW_BB)"
    tree.end
    tree "XO_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "XO_TEST2 (at 0x50e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8050e40 0x50e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RF_DIV2_EN                               = " "0 (RF_DIV2_DIS),1 (RF_DIV2_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RF_OUT_DTEST                             = " "0 (DRIVE_RF_NORMAL),1 (DRIVE_RF_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RF_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   XO_38P4_MODE_EN                          = " "0 (XO_19P2_MODE),1 (XO_38P4_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BB_OUT_DTEST                             = " "0 (DRIVE_BB_NORMAL),1 (DRIVE_BB_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BB_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
    tree.end
  tree.end
tree.end

