tree "BB_CLK1"
  tree "BB_CLK1"
    tree "BB_CLK1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_REVISION1 (at 0x5100)"
      tindex ezaxi:0xfc4cf980 %l 0x8051000 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_REVISION2 (at 0x5101)"
      tindex ezaxi:0xfc4cf980 %l 0x8051010 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_REVISION3 (at 0x5102)"
      tindex ezaxi:0xfc4cf980 %l 0x8051020 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_REVISION4 (at 0x5103)"
      tindex ezaxi:0xfc4cf980 %l 0x8051030 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_PERPH_TYPE (at 0x5104)"
      tindex ezaxi:0xfc4cf980 %l 0x8051040 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_PERPH_SUBTYPE (at 0x5105)"
      tindex ezaxi:0xfc4cf980 %l 0x8051050 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_STATUS1 (at 0x5108)"
      tindex ezaxi:0xfc4cf980 %l 0x8051080 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "BB_CLK1_EDGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_EDGE_CTL1 (at 0x5143)"
      tindex ezaxi:0xfc4cf980 %l 0x8051430 0x51430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "BB_CLK1_DRV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_DRV_CTL1 (at 0x5144)"
      tindex ezaxi:0xfc4cf980 %l 0x8051440 0x51440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "BB_CLK1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_EN_CTL (at 0x5146)"
      tindex ezaxi:0xfc4cf980 %l 0x8051460 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "BB_CLK1_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_PD_CTL (at 0x5148)"
      tindex ezaxi:0xfc4cf980 %l 0x8051480 0x51480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "BB_CLK1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_SEC_ACCESS (at 0x51d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8051d00 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_PERPH_RESET_CTL1 (at 0x51d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8051d80 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_PERPH_RESET_CTL2 (at 0x51d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8051d90 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_PERPH_RESET_CTL3 (at 0x51da)"
      tindex ezaxi:0xfc4cf980 %l 0x8051da0 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK1_PERPH_RESET_CTL4 (at 0x51db)"
      tindex ezaxi:0xfc4cf980 %l 0x8051db0 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "BB_CLK2"
  tree "BB_CLK2"
    tree "BB_CLK2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_REVISION1 (at 0x5200)"
      tindex ezaxi:0xfc4cf980 %l 0x8052000 0x52000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_REVISION2 (at 0x5201)"
      tindex ezaxi:0xfc4cf980 %l 0x8052010 0x52010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_REVISION3 (at 0x5202)"
      tindex ezaxi:0xfc4cf980 %l 0x8052020 0x52020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_REVISION4 (at 0x5203)"
      tindex ezaxi:0xfc4cf980 %l 0x8052030 0x52030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_PERPH_TYPE (at 0x5204)"
      tindex ezaxi:0xfc4cf980 %l 0x8052040 0x52040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_PERPH_SUBTYPE (at 0x5205)"
      tindex ezaxi:0xfc4cf980 %l 0x8052050 0x52050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_STATUS1 (at 0x5208)"
      tindex ezaxi:0xfc4cf980 %l 0x8052080 0x52080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "BB_CLK2_EDGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_EDGE_CTL1 (at 0x5243)"
      tindex ezaxi:0xfc4cf980 %l 0x8052430 0x52430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "BB_CLK2_DRV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_DRV_CTL1 (at 0x5244)"
      tindex ezaxi:0xfc4cf980 %l 0x8052440 0x52440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "BB_CLK2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_EN_CTL (at 0x5246)"
      tindex ezaxi:0xfc4cf980 %l 0x8052460 0x52460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "BB_CLK2_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_PD_CTL (at 0x5248)"
      tindex ezaxi:0xfc4cf980 %l 0x8052480 0x52480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "BB_CLK2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_SEC_ACCESS (at 0x52d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8052d00 0x52d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_PERPH_RESET_CTL1 (at 0x52d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8052d80 0x52d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_PERPH_RESET_CTL2 (at 0x52d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8052d90 0x52d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_PERPH_RESET_CTL3 (at 0x52da)"
      tindex ezaxi:0xfc4cf980 %l 0x8052da0 0x52da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BB_CLK2_PERPH_RESET_CTL4 (at 0x52db)"
      tindex ezaxi:0xfc4cf980 %l 0x8052db0 0x52db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
      tindex ezaxi:0xfc4cf980 %l 0x8110000 0x110000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
      tindex ezaxi:0xfc4cf980 %l 0x8110010 0x110010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
      tindex ezaxi:0xfc4cf980 %l 0x8110020 0x110020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
      tindex ezaxi:0xfc4cf980 %l 0x8110030 0x110030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
      tindex ezaxi:0xfc4cf980 %l 0x8110040 0x110040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
      tindex ezaxi:0xfc4cf980 %l 0x8110050 0x110050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_STATUS (at 0x11008)"
      tindex ezaxi:0xfc4cf980 %l 0x8110080 0x110080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0 (STATUS_DLL_NOT_LOCKED),1 (STATUS_DLL_LOCKED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
      tindex ezaxi:0xfc4cf980 %l 0x8110100 0x110100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
      tindex ezaxi:0xfc4cf980 %l 0x8110110 0x110110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
      tindex ezaxi:0xfc4cf980 %l 0x8110120 0x110120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
      tindex ezaxi:0xfc4cf980 %l 0x8110130 0x110130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
      tindex ezaxi:0xfc4cf980 %l 0x8110140 0x110140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
      tindex ezaxi:0xfc4cf980 %l 0x8110150 0x110150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
      tindex ezaxi:0xfc4cf980 %l 0x8110160 0x110160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
      tindex ezaxi:0xfc4cf980 %l 0x8110180 0x110180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
      tindex ezaxi:0xfc4cf980 %l 0x8110190 0x110190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
      tindex ezaxi:0xfc4cf980 %l 0x81101a0 0x1101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
      tindex ezaxi:0xfc4cf980 %l 0x81101b0 0x1101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
      tindex ezaxi:0xfc4cf980 %l 0x8110460 0x110460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
      tindex ezaxi:0xfc4cf980 %l 0x8110500 0x110500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0 (DLL_LOCK_CHECK_DISABLED_0),1 (DLL_LOCK_CHECK_DISABLED_1),2 (WAIT_FOR_DLL_LOCK),3 (WAIT_FOR_10_US)"
    tree.end
    tree "BCLK_GEN_MAIN_QM_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_QM_MODE (at 0x11051)"
      tindex ezaxi:0xfc4cf980 %l 0x8110510 0x110510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0 (QUIET_MODE_DISABLED),1 (QUIET_MODE_ENABLED)"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8110d00 0x110d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8110d90 0x110d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
      tindex ezaxi:0xfc4cf980 %l 0x8110da0 0x110da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
      tindex ezaxi:0xfc4cf980 %l 0x8110db0 0x110db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8110e00 0x110e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8110e10 0x110e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8110e20 0x110e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8110e30 0x110e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8110e40 0x110e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_TRISTATE),1 (ATEST_1S_2T_3T),2 (ATEST_1T_2S_3T),3 (ATEST_1S_2S_3T),4 (ATEST_1T_2T_3S),5 (ATEST_1S_2T_3S),6 (ATEST_1T_2S_3S),7 (ATEST_1S_2S_3S)"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8110e50 0x110e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0 (USE_MAIN_CLK),1 (USE_ALT_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0 (ALT_CLK_DTEST1),1 (ALT_CLK_DTEST2),2 (ALT_CLK_DTEST3),3 (ALT_CLK_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BUA_EXT_CHARGER"
  tree "BUA_EXT_CHARGER"
    tree "BUA_EXT_CHARGER_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_REVISION1 (at 0x1c00)"
      tindex ezaxi:0xfc4cf980 %l 0x801c000 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_EXT_CHARGER_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_REVISION2 (at 0x1c01)"
      tindex ezaxi:0xfc4cf980 %l 0x801c010 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_EXT_CHARGER_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_PERPH_TYPE (at 0x1c04)"
      tindex ezaxi:0xfc4cf980 %l 0x801c040 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_EXT_CHARGER_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_PERPH_SUBTYPE (at 0x1c05)"
      tindex ezaxi:0xfc4cf980 %l 0x801c050 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_EXT_CHARGER_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_STATUS1 (at 0x1c08)"
      tindex ezaxi:0xfc4cf980 %l 0x801c080 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_GONE_DETECTED                       = " "0 (BAT_PRESENT),1 (BATT_GONE)"
    tree.end
    tree "BUA_EXT_CHARGER_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_STATUS2 (at 0x1c09)"
      tindex ezaxi:0xfc4cf980 %l 0x801c090 0x1c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC4_ALARM_DETECTED                     = " "0 (ALARM_NOT_DETECTED),1 (ALARM_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC3_ALARM_DETECTED                     = " "0 (ALARM_NOT_DETECTED),1 (ALARM_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC2_ALARM_DETECTED                     = " "0 (ALARM_NOT_DETECTED),1 (ALARM_DETECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UICC1_ALARM_DETECTED                     = " "0 (ALARM_NOT_DETECTED),1 (ALARM_DETECTED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_RT_STS (at 0x1c10)"
      tindex ezaxi:0xfc4cf980 %l 0x801c100 0x1c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_SET_TYPE (at 0x1c11)"
      tindex ezaxi:0xfc4cf980 %l 0x801c110 0x1c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_POLARITY_HIGH (at 0x1c12)"
      tindex ezaxi:0xfc4cf980 %l 0x801c120 0x1c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_POLARITY_LOW (at 0x1c13)"
      tindex ezaxi:0xfc4cf980 %l 0x801c130 0x1c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_LATCHED_CLR (at 0x1c14)"
      tindex ezaxi:0xfc4cf980 %l 0x801c140 0x1c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "BUA_EXT_CHARGER_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_EN_SET (at 0x1c15)"
      tindex ezaxi:0xfc4cf980 %l 0x801c150 0x1c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_EN_CLR (at 0x1c16)"
      tindex ezaxi:0xfc4cf980 %l 0x801c160 0x1c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_LATCHED_STS (at 0x1c18)"
      tindex ezaxi:0xfc4cf980 %l 0x801c180 0x1c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_PENDING_STS (at 0x1c19)"
      tindex ezaxi:0xfc4cf980 %l 0x801c190 0x1c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARMPENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_MID_SEL (at 0x1c1a)"
      tindex ezaxi:0xfc4cf980 %l 0x801c1a0 0x1c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_PRIORITY (at 0x1c1b)"
      tindex ezaxi:0xfc4cf980 %l 0x801c1b0 0x1c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BUA_EXT_CHARGER_BUA_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_BUA_CTL1 (at 0x1c40)"
      tindex ezaxi:0xfc4cf980 %l 0x801c400 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_GONE_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0 (SCLK_0_TO_1),1 (SCLK_1_TO_2),2 (SCLK_2_TO_3),3 (SCLK_5_TO_6),4 (SCLK_8_TO_9),5 (SCLK_11_TO_12),6 (SCLK_15_TO_16),7 (SCLK_31_TO_32)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LDO_SHUTDOWN_DELAY                       = " "0 (SCLK2P5),1 (SCLK3P5),2 (SCLK4P5),3 (SCLK5P5),4 (SCLK6P5),5 (SCLK8P5),6 (SCLK9P5),7 (SCLK11P5)"
    tree.end
    tree "BUA_EXT_CHARGER_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_EN_CTL1 (at 0x1c46)"
      tindex ezaxi:0xfc4cf980 %l 0x801c460 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
    tree.end
    tree "BUA_EXT_CHARGER_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_SEC_ACCESS (at 0x1cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x801cd00 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_EXT_CHARGER_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_PERPH_RESET_CTL1 (at 0x1cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x801cd80 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BUA_EXT_CHARGER_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_PERPH_RESET_CTL2 (at 0x1cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x801cd90 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_EXT_CHARGER_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_PERPH_RESET_CTL3 (at 0x1cda)"
      tindex ezaxi:0xfc4cf980 %l 0x801cda0 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_EXT_CHARGER_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_PERPH_RESET_CTL4 (at 0x1cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x801cdb0 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_TEST1 (at 0x1ce0)"
      tindex ezaxi:0xfc4cf980 %l 0x801ce00 0x1ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BUA_EXT_CHARGER_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_INT_TEST_VAL (at 0x1ce1)"
      tindex ezaxi:0xfc4cf980 %l 0x801ce10 0x1ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TEST_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "BUA_EXT_CHARGER_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUA_EXT_CHARGER_TEST1 (at 0x1ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x801ce20 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST_SEL2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_REVISION1 (at 0x400)"
      tindex ezaxi:0xfc4cf980 %l 0x8004000 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_REVISION2 (at 0x401)"
      tindex ezaxi:0xfc4cf980 %l 0x8004010 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_TYPE (at 0x404)"
      tindex ezaxi:0xfc4cf980 %l 0x8004040 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_SUBTYPE (at 0x405)"
      tindex ezaxi:0xfc4cf980 %l 0x8004050 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_STATUS1 (at 0x408)"
      tindex ezaxi:0xfc4cf980 %l 0x8004080 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_TIMEOUT (at 0x444)"
      tindex ezaxi:0xfc4cf980 %l 0x8004440 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_SEC_ACCESS (at 0x4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8004d00 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8004d90 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_RESET_CTL3 (at 0x4da)"
      tindex ezaxi:0xfc4cf980 %l 0x8004da0 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_PERPH_RESET_CTL4 (at 0x4db)"
      tindex ezaxi:0xfc4cf980 %l 0x8004db0 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "BUS_TEST1 (at 0x4e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8004e20 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION1 (at 0x5900)"
      tindex ezaxi:0xfc4cf980 %l 0x8059000 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION2 (at 0x5901)"
      tindex ezaxi:0xfc4cf980 %l 0x8059010 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION3 (at 0x5902)"
      tindex ezaxi:0xfc4cf980 %l 0x8059020 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_REVISION4 (at 0x5903)"
      tindex ezaxi:0xfc4cf980 %l 0x8059030 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_TYPE (at 0x5904)"
      tindex ezaxi:0xfc4cf980 %l 0x8059040 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
      tindex ezaxi:0xfc4cf980 %l 0x8059050 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_STATUS1 (at 0x5908)"
      tindex ezaxi:0xfc4cf980 %l 0x8059080 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_RT_STS (at 0x5910)"
      tindex ezaxi:0xfc4cf980 %l 0x8059100 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_SET_TYPE (at 0x5911)"
      tindex ezaxi:0xfc4cf980 %l 0x8059110 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
      tindex ezaxi:0xfc4cf980 %l 0x8059120 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
      tindex ezaxi:0xfc4cf980 %l 0x8059130 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
      tindex ezaxi:0xfc4cf980 %l 0x8059140 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_EN_SET (at 0x5915)"
      tindex ezaxi:0xfc4cf980 %l 0x8059150 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_EN_CLR (at 0x5916)"
      tindex ezaxi:0xfc4cf980 %l 0x8059160 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
      tindex ezaxi:0xfc4cf980 %l 0x8059180 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_PENDING_STS (at 0x5919)"
      tindex ezaxi:0xfc4cf980 %l 0x8059190 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_MID_SEL (at 0x591a)"
      tindex ezaxi:0xfc4cf980 %l 0x80591a0 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_PRIORITY (at 0x591b)"
      tindex ezaxi:0xfc4cf980 %l 0x80591b0 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL1 (at 0x5940)"
      tindex ezaxi:0xfc4cf980 %l 0x8059400 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL2 (at 0x5941)"
      tindex ezaxi:0xfc4cf980 %l 0x8059410 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL3 (at 0x5942)"
      tindex ezaxi:0xfc4cf980 %l 0x8059420 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_CLK_CTL4 (at 0x5943)"
      tindex ezaxi:0xfc4cf980 %l 0x8059430 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_HALT_CTL (at 0x5945)"
      tindex ezaxi:0xfc4cf980 %l 0x8059450 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_RC_CTL (at 0x5946)"
      tindex ezaxi:0xfc4cf980 %l 0x8059460 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PD_CTL (at 0x5948)"
      tindex ezaxi:0xfc4cf980 %l 0x8059480 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
      tindex ezaxi:0xfc4cf980 %l 0x80594a0 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0 (NOT_FORCE_AWAKE),1 (FORCE_PMIC_AWAKE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (PMIC_AWAKE_NOT_FOLLOW_HW),1 (PMIC_AWAKE_FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_SPARE1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SPARE1 (at 0x5951)"
      tindex ezaxi:0xfc4cf980 %l 0x8059510 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SPARE2 (at 0x5952)"
      tindex ezaxi:0xfc4cf980 %l 0x8059520 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SPARE3 (at 0x5953)"
      tindex ezaxi:0xfc4cf980 %l 0x8059530 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_SEC_ACCESS (at 0x59d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8059d00 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8059d90 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
      tindex ezaxi:0xfc4cf980 %l 0x8059da0 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
      tindex ezaxi:0xfc4cf980 %l 0x8059db0 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_TEST1 (at 0x59e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8059e00 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8059e10 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_TEST1 (at 0x59e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8059e20 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_TEST2 (at 0x59e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8059e40 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_TRIM_NUM (at 0x59f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8059f00 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8059f10 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "CLK_DIST_RCLF_TRIM (at 0x59f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8059f20 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "COIN"
  tree "COIN"
    tree "COIN_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_REVISION1 (at 0x2800)"
      tindex ezaxi:0xfc4cf980 %l 0x8028000 0x28000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "COIN_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_REVISION2 (at 0x2801)"
      tindex ezaxi:0xfc4cf980 %l 0x8028010 0x28010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "COIN_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_REVISION3 (at 0x2802)"
      tindex ezaxi:0xfc4cf980 %l 0x8028020 0x28020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "COIN_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_REVISION4 (at 0x2803)"
      tindex ezaxi:0xfc4cf980 %l 0x8028030 0x28030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "COIN_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_PERPH_TYPE (at 0x2804)"
      tindex ezaxi:0xfc4cf980 %l 0x8028040 0x28040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "COIN_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_PERPH_SUBTYPE (at 0x2805)"
      tindex ezaxi:0xfc4cf980 %l 0x8028050 0x28050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "COIN_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_STATUS1 (at 0x2808)"
      tindex ezaxi:0xfc4cf980 %l 0x8028080 0x28080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COINCELL_OK                              = " "0 (CC_DISABLED),1 (CC_ENABLED)"
    tree.end
    tree "COIN_COIN_CHG_RSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_COIN_CHG_RSET (at 0x2844)"
      tindex ezaxi:0xfc4cf980 %l 0x8028440 0x28440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_RSET                            = " "0 (CC_RSET_2K1),1 (CC_RSET_1K7),2 (CC_RSET_1K2),3 (CC_RSET_0K8)"
    tree.end
    tree "COIN_COIN_CHG_VSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_COIN_CHG_VSET (at 0x2845)"
      tindex ezaxi:0xfc4cf980 %l 0x8028450 0x28450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_VSET                            = " "0 (CC_VSET_2V5),1 (CC_VSET_3V2),2 (CC_VSET_3V1),3 (CC_VSET_3V0)"
    tree.end
    tree "COIN_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_EN_CTL (at 0x2846)"
      tindex ezaxi:0xfc4cf980 %l 0x8028460 0x28460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COINCELL_EN                              = " "0 (CC_DISABLED),1 (CC_ENABLED)"
    tree.end
    tree "COIN_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_SEC_ACCESS (at 0x28d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8028d00 0x28d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "COIN_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_PERPH_RESET_CTL2 (at 0x28d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8028d90 0x28d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "COIN_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_PERPH_RESET_CTL3 (at 0x28da)"
      tindex ezaxi:0xfc4cf980 %l 0x8028da0 0x28da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
    tree.end
    tree "COIN_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_PERPH_RESET_CTL4 (at 0x28db)"
      tindex ezaxi:0xfc4cf980 %l 0x8028db0 0x28db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "COIN_TEST_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_TEST_CTRL (at 0x28e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8028e00 0x28e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_VCOIN                               = " "0 (CC_TEST_MODE_DISABLED),1 (CC_TEST_MODE_ENABLED)"
    tree.end
    tree "COIN_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_TRIM_NUM (at 0x28f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8028f00 0x28f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_NUM                                 = " "0, 1"
    tree.end
    tree "COIN_TRIM_OFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "COIN_TRIM_OFFSET (at 0x28f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8028f10 0x28f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_RSET_TRIM                       = " "0 (reserved),1 (CC_RSET_MINUS_254),2 (CC_RESET_NOM),3 (CC_RSET_PLUS_227)"
    tree.end
  tree.end
tree.end
tree "DIV_CLK1"
  tree "DIV_CLK1"
    tree "DIV_CLK1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_REVISION1 (at 0x5b00)"
      tindex ezaxi:0xfc4cf980 %l 0x805b000 0x5b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_REVISION2 (at 0x5b01)"
      tindex ezaxi:0xfc4cf980 %l 0x805b010 0x5b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_PERPH_TYPE (at 0x5b04)"
      tindex ezaxi:0xfc4cf980 %l 0x805b040 0x5b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_PERPH_SUBTYPE (at 0x5b05)"
      tindex ezaxi:0xfc4cf980 %l 0x805b050 0x5b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_STATUS1 (at 0x5b08)"
      tindex ezaxi:0xfc4cf980 %l 0x805b080 0x5b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK1_DIV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_DIV_CTL1 (at 0x5b43)"
      tindex ezaxi:0xfc4cf980 %l 0x805b430 0x5b430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_EN_CTL (at 0x5b46)"
      tindex ezaxi:0xfc4cf980 %l 0x805b460 0x5b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_SEC_ACCESS (at 0x5bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x805bd00 0x5bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_PERPH_RESET_CTL1 (at 0x5bd8)"
      tindex ezaxi:0xfc4cf980 %l 0x805bd80 0x5bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_PERPH_RESET_CTL2 (at 0x5bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x805bd90 0x5bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_PERPH_RESET_CTL3 (at 0x5bda)"
      tindex ezaxi:0xfc4cf980 %l 0x805bda0 0x5bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK1_PERPH_RESET_CTL4 (at 0x5bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x805bdb0 0x5bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK2"
  tree "DIV_CLK2"
    tree "DIV_CLK2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_REVISION1 (at 0x5c00)"
      tindex ezaxi:0xfc4cf980 %l 0x805c000 0x5c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_REVISION2 (at 0x5c01)"
      tindex ezaxi:0xfc4cf980 %l 0x805c010 0x5c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_PERPH_TYPE (at 0x5c04)"
      tindex ezaxi:0xfc4cf980 %l 0x805c040 0x5c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_PERPH_SUBTYPE (at 0x5c05)"
      tindex ezaxi:0xfc4cf980 %l 0x805c050 0x5c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_STATUS1 (at 0x5c08)"
      tindex ezaxi:0xfc4cf980 %l 0x805c080 0x5c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK2_DIV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_DIV_CTL1 (at 0x5c43)"
      tindex ezaxi:0xfc4cf980 %l 0x805c430 0x5c430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_EN_CTL (at 0x5c46)"
      tindex ezaxi:0xfc4cf980 %l 0x805c460 0x5c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_SEC_ACCESS (at 0x5cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x805cd00 0x5cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_PERPH_RESET_CTL1 (at 0x5cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x805cd80 0x5cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_PERPH_RESET_CTL2 (at 0x5cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x805cd90 0x5cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_PERPH_RESET_CTL3 (at 0x5cda)"
      tindex ezaxi:0xfc4cf980 %l 0x805cda0 0x5cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK2_PERPH_RESET_CTL4 (at 0x5cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x805cdb0 0x5cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK3"
  tree "DIV_CLK3"
    tree "DIV_CLK3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_REVISION1 (at 0x5d00)"
      tindex ezaxi:0xfc4cf980 %l 0x805d000 0x5d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_REVISION2 (at 0x5d01)"
      tindex ezaxi:0xfc4cf980 %l 0x805d010 0x5d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_PERPH_TYPE (at 0x5d04)"
      tindex ezaxi:0xfc4cf980 %l 0x805d040 0x5d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_PERPH_SUBTYPE (at 0x5d05)"
      tindex ezaxi:0xfc4cf980 %l 0x805d050 0x5d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_STATUS1 (at 0x5d08)"
      tindex ezaxi:0xfc4cf980 %l 0x805d080 0x5d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK3_DIV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_DIV_CTL1 (at 0x5d43)"
      tindex ezaxi:0xfc4cf980 %l 0x805d430 0x5d430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1),1 (reserved),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_EN_CTL (at 0x5d46)"
      tindex ezaxi:0xfc4cf980 %l 0x805d460 0x5d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_SEC_ACCESS (at 0x5dd0)"
      tindex ezaxi:0xfc4cf980 %l 0x805dd00 0x5dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_PERPH_RESET_CTL1 (at 0x5dd8)"
      tindex ezaxi:0xfc4cf980 %l 0x805dd80 0x5dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_PERPH_RESET_CTL2 (at 0x5dd9)"
      tindex ezaxi:0xfc4cf980 %l 0x805dd90 0x5dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_PERPH_RESET_CTL3 (at 0x5dda)"
      tindex ezaxi:0xfc4cf980 %l 0x805dda0 0x5dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "DIV_CLK3_PERPH_RESET_CTL4 (at 0x5ddb)"
      tindex ezaxi:0xfc4cf980 %l 0x805ddb0 0x5ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION1 (at 0xc000)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0000 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION2 (at 0xc001)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0010 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION3 (at 0xc002)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0020 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_REVISION4 (at 0xc003)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0030 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_TYPE (at 0xc004)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0040 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_SUBTYPE (at 0xc005)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0050 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_STATUS1 (at 0xc008)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0080 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_RT_STS (at 0xc010)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0100 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_SET_TYPE (at 0xc011)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0110 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0120 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_POLARITY_LOW (at 0xc013)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0130 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_LATCHED_CLR (at 0xc014)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0140 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_EN_SET (at 0xc015)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0150 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_EN_CLR (at 0xc016)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0160 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_LATCHED_STS (at 0xc018)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0180 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_PENDING_STS (at 0xc019)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0190 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_MID_SEL (at 0xc01a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c01a0 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_INT_PRIORITY (at 0xc01b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c01b0 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_MODE_CTL (at 0xc040)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0400 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_VIN_CTL (at 0xc041)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0410 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_PULL_CTL (at 0xc042)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0420 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO1_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_IN_CTL (at 0xc043)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0430 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO1_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_DIG_OUT_CTL (at 0xc045)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0450 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_EN_CTL (at 0xc046)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0460 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_SEC_ACCESS (at 0xc0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0d00 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0d80 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0d90 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0da0 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c0db0 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO10"
  tree "GPIO10"
    tree "GPIO10_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION1 (at 0xc900)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9000 0xc9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION2 (at 0xc901)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9010 0xc9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO10_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION3 (at 0xc902)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9020 0xc9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_REVISION4 (at 0xc903)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9030 0xc9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO10_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_TYPE (at 0xc904)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9040 0xc9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO10_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_SUBTYPE (at 0xc905)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9050 0xc9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO10_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_STATUS1 (at 0xc908)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9080 0xc9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO10_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_RT_STS (at 0xc910)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9100 0xc9100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO10_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_SET_TYPE (at 0xc911)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9110 0xc9110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO10_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_POLARITY_HIGH (at 0xc912)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9120 0xc9120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_POLARITY_LOW (at 0xc913)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9130 0xc9130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_LATCHED_CLR (at 0xc914)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9140 0xc9140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO10_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_EN_SET (at 0xc915)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9150 0xc9150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_EN_CLR (at 0xc916)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9160 0xc9160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_LATCHED_STS (at 0xc918)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9180 0xc9180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO10_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_PENDING_STS (at 0xc919)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9190 0xc9190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO10_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_MID_SEL (at 0xc91a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c91a0 0xc91a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO10_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_INT_PRIORITY (at 0xc91b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c91b0 0xc91b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO10_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_MODE_CTL (at 0xc940)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9400 0xc9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO10_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_VIN_CTL (at 0xc941)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9410 0xc9410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO10_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_PULL_CTL (at 0xc942)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9420 0xc9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO10_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_IN_CTL (at 0xc943)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9430 0xc9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO10_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_DIG_OUT_CTL (at 0xc945)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9450 0xc9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO10_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_EN_CTL (at 0xc946)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9460 0xc9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO10_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_SEC_ACCESS (at 0xc9d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9d00 0xc9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO10_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL1 (at 0xc9d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9d80 0xc9d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL2 (at 0xc9d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9d90 0xc9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL3 (at 0xc9da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9da0 0xc9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO10_PERPH_RESET_CTL4 (at 0xc9db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c9db0 0xc9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO11"
  tree "GPIO11"
    tree "GPIO11_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_REVISION1 (at 0xca00)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca000 0xca000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO11_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_REVISION2 (at 0xca01)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca010 0xca010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO11_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_REVISION3 (at 0xca02)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca020 0xca020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO11_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_REVISION4 (at 0xca03)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca030 0xca030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO11_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_PERPH_TYPE (at 0xca04)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca040 0xca040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO11_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_PERPH_SUBTYPE (at 0xca05)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca050 0xca050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO11_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_STATUS1 (at 0xca08)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca080 0xca080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO11_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_RT_STS (at 0xca10)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca100 0xca100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO11_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_SET_TYPE (at 0xca11)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca110 0xca110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO11_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_POLARITY_HIGH (at 0xca12)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca120 0xca120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO11_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_POLARITY_LOW (at 0xca13)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca130 0xca130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO11_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_LATCHED_CLR (at 0xca14)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca140 0xca140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO11_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_EN_SET (at 0xca15)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca150 0xca150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO11_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_EN_CLR (at 0xca16)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca160 0xca160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO11_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_LATCHED_STS (at 0xca18)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca180 0xca180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO11_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_PENDING_STS (at 0xca19)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca190 0xca190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO11_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_MID_SEL (at 0xca1a)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca1a0 0xca1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO11_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_INT_PRIORITY (at 0xca1b)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca1b0 0xca1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO11_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_MODE_CTL (at 0xca40)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca400 0xca400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO11_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_DIG_VIN_CTL (at 0xca41)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca410 0xca410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO11_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_DIG_PULL_CTL (at 0xca42)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca420 0xca420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO11_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_DIG_IN_CTL (at 0xca43)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca430 0xca430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO11_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_DIG_OUT_CTL (at 0xca45)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca450 0xca450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO11_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_EN_CTL (at 0xca46)"
      tindex ezaxi:0xfc4cf980 %l 0x80ca460 0xca460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO11_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_SEC_ACCESS (at 0xcad0)"
      tindex ezaxi:0xfc4cf980 %l 0x80cad00 0xcad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO11_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_PERPH_RESET_CTL1 (at 0xcad8)"
      tindex ezaxi:0xfc4cf980 %l 0x80cad80 0xcad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_PERPH_RESET_CTL2 (at 0xcad9)"
      tindex ezaxi:0xfc4cf980 %l 0x80cad90 0xcad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_PERPH_RESET_CTL3 (at 0xcada)"
      tindex ezaxi:0xfc4cf980 %l 0x80cada0 0xcada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO11_PERPH_RESET_CTL4 (at 0xcadb)"
      tindex ezaxi:0xfc4cf980 %l 0x80cadb0 0xcadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO12"
  tree "GPIO12"
    tree "GPIO12_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_REVISION1 (at 0xcb00)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb000 0xcb000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO12_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_REVISION2 (at 0xcb01)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb010 0xcb010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO12_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_REVISION3 (at 0xcb02)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb020 0xcb020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO12_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_REVISION4 (at 0xcb03)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb030 0xcb030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO12_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_PERPH_TYPE (at 0xcb04)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb040 0xcb040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO12_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_PERPH_SUBTYPE (at 0xcb05)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb050 0xcb050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO12_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_STATUS1 (at 0xcb08)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb080 0xcb080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO12_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_RT_STS (at 0xcb10)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb100 0xcb100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO12_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_SET_TYPE (at 0xcb11)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb110 0xcb110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO12_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_POLARITY_HIGH (at 0xcb12)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb120 0xcb120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO12_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_POLARITY_LOW (at 0xcb13)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb130 0xcb130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO12_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_LATCHED_CLR (at 0xcb14)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb140 0xcb140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO12_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_EN_SET (at 0xcb15)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb150 0xcb150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO12_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_EN_CLR (at 0xcb16)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb160 0xcb160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO12_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_LATCHED_STS (at 0xcb18)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb180 0xcb180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO12_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_PENDING_STS (at 0xcb19)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb190 0xcb190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO12_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_MID_SEL (at 0xcb1a)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb1a0 0xcb1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO12_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_INT_PRIORITY (at 0xcb1b)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb1b0 0xcb1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO12_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_MODE_CTL (at 0xcb40)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb400 0xcb400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO12_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_DIG_VIN_CTL (at 0xcb41)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb410 0xcb410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO12_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_DIG_PULL_CTL (at 0xcb42)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb420 0xcb420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO12_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_DIG_IN_CTL (at 0xcb43)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb430 0xcb430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO12_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_DIG_OUT_CTL (at 0xcb45)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb450 0xcb450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO12_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_EN_CTL (at 0xcb46)"
      tindex ezaxi:0xfc4cf980 %l 0x80cb460 0xcb460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO12_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_SEC_ACCESS (at 0xcbd0)"
      tindex ezaxi:0xfc4cf980 %l 0x80cbd00 0xcbd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO12_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_PERPH_RESET_CTL1 (at 0xcbd8)"
      tindex ezaxi:0xfc4cf980 %l 0x80cbd80 0xcbd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_PERPH_RESET_CTL2 (at 0xcbd9)"
      tindex ezaxi:0xfc4cf980 %l 0x80cbd90 0xcbd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_PERPH_RESET_CTL3 (at 0xcbda)"
      tindex ezaxi:0xfc4cf980 %l 0x80cbda0 0xcbda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO12_PERPH_RESET_CTL4 (at 0xcbdb)"
      tindex ezaxi:0xfc4cf980 %l 0x80cbdb0 0xcbdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO13"
  tree "GPIO13"
    tree "GPIO13_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_REVISION1 (at 0xcc00)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc000 0xcc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO13_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_REVISION2 (at 0xcc01)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc010 0xcc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO13_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_REVISION3 (at 0xcc02)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc020 0xcc020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO13_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_REVISION4 (at 0xcc03)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc030 0xcc030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO13_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_PERPH_TYPE (at 0xcc04)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc040 0xcc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO13_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_PERPH_SUBTYPE (at 0xcc05)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc050 0xcc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO13_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_STATUS1 (at 0xcc08)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc080 0xcc080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO13_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_RT_STS (at 0xcc10)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc100 0xcc100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO13_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_SET_TYPE (at 0xcc11)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc110 0xcc110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO13_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_POLARITY_HIGH (at 0xcc12)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc120 0xcc120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO13_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_POLARITY_LOW (at 0xcc13)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc130 0xcc130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO13_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_LATCHED_CLR (at 0xcc14)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc140 0xcc140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO13_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_EN_SET (at 0xcc15)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc150 0xcc150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO13_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_EN_CLR (at 0xcc16)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc160 0xcc160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO13_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_LATCHED_STS (at 0xcc18)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc180 0xcc180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO13_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_PENDING_STS (at 0xcc19)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc190 0xcc190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO13_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_MID_SEL (at 0xcc1a)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc1a0 0xcc1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO13_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_INT_PRIORITY (at 0xcc1b)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc1b0 0xcc1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO13_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_MODE_CTL (at 0xcc40)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc400 0xcc400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO13_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_DIG_VIN_CTL (at 0xcc41)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc410 0xcc410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO13_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_DIG_PULL_CTL (at 0xcc42)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc420 0xcc420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO13_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_DIG_IN_CTL (at 0xcc43)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc430 0xcc430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO13_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_DIG_OUT_CTL (at 0xcc45)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc450 0xcc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO13_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_EN_CTL (at 0xcc46)"
      tindex ezaxi:0xfc4cf980 %l 0x80cc460 0xcc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO13_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_SEC_ACCESS (at 0xccd0)"
      tindex ezaxi:0xfc4cf980 %l 0x80ccd00 0xccd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO13_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_PERPH_RESET_CTL1 (at 0xccd8)"
      tindex ezaxi:0xfc4cf980 %l 0x80ccd80 0xccd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO13_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_PERPH_RESET_CTL2 (at 0xccd9)"
      tindex ezaxi:0xfc4cf980 %l 0x80ccd90 0xccd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO13_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_PERPH_RESET_CTL3 (at 0xccda)"
      tindex ezaxi:0xfc4cf980 %l 0x80ccda0 0xccda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO13_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO13_PERPH_RESET_CTL4 (at 0xccdb)"
      tindex ezaxi:0xfc4cf980 %l 0x80ccdb0 0xccdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO14"
  tree "GPIO14"
    tree "GPIO14_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_REVISION1 (at 0xcd00)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd000 0xcd000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO14_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_REVISION2 (at 0xcd01)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd010 0xcd010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO14_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_REVISION3 (at 0xcd02)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd020 0xcd020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO14_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_REVISION4 (at 0xcd03)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd030 0xcd030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO14_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_PERPH_TYPE (at 0xcd04)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd040 0xcd040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO14_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_PERPH_SUBTYPE (at 0xcd05)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd050 0xcd050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO14_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_STATUS1 (at 0xcd08)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd080 0xcd080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO14_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_RT_STS (at 0xcd10)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd100 0xcd100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO14_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_SET_TYPE (at 0xcd11)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd110 0xcd110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO14_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_POLARITY_HIGH (at 0xcd12)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd120 0xcd120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO14_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_POLARITY_LOW (at 0xcd13)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd130 0xcd130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO14_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_LATCHED_CLR (at 0xcd14)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd140 0xcd140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO14_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_EN_SET (at 0xcd15)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd150 0xcd150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO14_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_EN_CLR (at 0xcd16)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd160 0xcd160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO14_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_LATCHED_STS (at 0xcd18)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd180 0xcd180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO14_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_PENDING_STS (at 0xcd19)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd190 0xcd190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO14_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_MID_SEL (at 0xcd1a)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd1a0 0xcd1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO14_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_INT_PRIORITY (at 0xcd1b)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd1b0 0xcd1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO14_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_MODE_CTL (at 0xcd40)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd400 0xcd400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO14_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_DIG_VIN_CTL (at 0xcd41)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd410 0xcd410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO14_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_DIG_PULL_CTL (at 0xcd42)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd420 0xcd420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO14_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_DIG_IN_CTL (at 0xcd43)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd430 0xcd430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO14_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_DIG_OUT_CTL (at 0xcd45)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd450 0xcd450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO14_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_EN_CTL (at 0xcd46)"
      tindex ezaxi:0xfc4cf980 %l 0x80cd460 0xcd460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO14_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_SEC_ACCESS (at 0xcdd0)"
      tindex ezaxi:0xfc4cf980 %l 0x80cdd00 0xcdd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO14_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_PERPH_RESET_CTL1 (at 0xcdd8)"
      tindex ezaxi:0xfc4cf980 %l 0x80cdd80 0xcdd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO14_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_PERPH_RESET_CTL2 (at 0xcdd9)"
      tindex ezaxi:0xfc4cf980 %l 0x80cdd90 0xcdd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO14_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_PERPH_RESET_CTL3 (at 0xcdda)"
      tindex ezaxi:0xfc4cf980 %l 0x80cdda0 0xcdda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO14_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO14_PERPH_RESET_CTL4 (at 0xcddb)"
      tindex ezaxi:0xfc4cf980 %l 0x80cddb0 0xcddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO15"
  tree "GPIO15"
    tree "GPIO15_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_REVISION1 (at 0xce00)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce000 0xce000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO15_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_REVISION2 (at 0xce01)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce010 0xce010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO15_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_REVISION3 (at 0xce02)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce020 0xce020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO15_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_REVISION4 (at 0xce03)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce030 0xce030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO15_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_PERPH_TYPE (at 0xce04)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce040 0xce040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO15_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_PERPH_SUBTYPE (at 0xce05)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce050 0xce050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO15_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_STATUS1 (at 0xce08)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce080 0xce080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO15_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_RT_STS (at 0xce10)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce100 0xce100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO15_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_SET_TYPE (at 0xce11)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce110 0xce110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO15_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_POLARITY_HIGH (at 0xce12)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce120 0xce120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO15_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_POLARITY_LOW (at 0xce13)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce130 0xce130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO15_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_LATCHED_CLR (at 0xce14)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce140 0xce140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO15_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_EN_SET (at 0xce15)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce150 0xce150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO15_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_EN_CLR (at 0xce16)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce160 0xce160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO15_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_LATCHED_STS (at 0xce18)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce180 0xce180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO15_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_PENDING_STS (at 0xce19)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce190 0xce190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO15_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_MID_SEL (at 0xce1a)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce1a0 0xce1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO15_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_INT_PRIORITY (at 0xce1b)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce1b0 0xce1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO15_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_MODE_CTL (at 0xce40)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce400 0xce400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO15_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_DIG_VIN_CTL (at 0xce41)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce410 0xce410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO15_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_DIG_PULL_CTL (at 0xce42)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce420 0xce420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO15_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_DIG_IN_CTL (at 0xce43)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce430 0xce430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO15_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_DIG_OUT_CTL (at 0xce45)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce450 0xce450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO15_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_EN_CTL (at 0xce46)"
      tindex ezaxi:0xfc4cf980 %l 0x80ce460 0xce460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO15_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_SEC_ACCESS (at 0xced0)"
      tindex ezaxi:0xfc4cf980 %l 0x80ced00 0xced00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO15_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_PERPH_RESET_CTL1 (at 0xced8)"
      tindex ezaxi:0xfc4cf980 %l 0x80ced80 0xced80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO15_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_PERPH_RESET_CTL2 (at 0xced9)"
      tindex ezaxi:0xfc4cf980 %l 0x80ced90 0xced90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO15_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_PERPH_RESET_CTL3 (at 0xceda)"
      tindex ezaxi:0xfc4cf980 %l 0x80ceda0 0xceda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO15_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO15_PERPH_RESET_CTL4 (at 0xcedb)"
      tindex ezaxi:0xfc4cf980 %l 0x80cedb0 0xcedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO16"
  tree "GPIO16"
    tree "GPIO16_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_REVISION1 (at 0xcf00)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf000 0xcf000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO16_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_REVISION2 (at 0xcf01)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf010 0xcf010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO16_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_REVISION3 (at 0xcf02)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf020 0xcf020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO16_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_REVISION4 (at 0xcf03)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf030 0xcf030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO16_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_PERPH_TYPE (at 0xcf04)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf040 0xcf040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO16_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_PERPH_SUBTYPE (at 0xcf05)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf050 0xcf050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO16_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_STATUS1 (at 0xcf08)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf080 0xcf080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO16_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_RT_STS (at 0xcf10)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf100 0xcf100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO16_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_SET_TYPE (at 0xcf11)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf110 0xcf110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO16_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_POLARITY_HIGH (at 0xcf12)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf120 0xcf120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO16_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_POLARITY_LOW (at 0xcf13)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf130 0xcf130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO16_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_LATCHED_CLR (at 0xcf14)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf140 0xcf140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO16_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_EN_SET (at 0xcf15)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf150 0xcf150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO16_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_EN_CLR (at 0xcf16)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf160 0xcf160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO16_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_LATCHED_STS (at 0xcf18)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf180 0xcf180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO16_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_PENDING_STS (at 0xcf19)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf190 0xcf190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO16_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_MID_SEL (at 0xcf1a)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf1a0 0xcf1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO16_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_INT_PRIORITY (at 0xcf1b)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf1b0 0xcf1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO16_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_MODE_CTL (at 0xcf40)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf400 0xcf400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO16_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_DIG_VIN_CTL (at 0xcf41)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf410 0xcf410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO16_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_DIG_PULL_CTL (at 0xcf42)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf420 0xcf420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO16_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_DIG_IN_CTL (at 0xcf43)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf430 0xcf430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO16_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_DIG_OUT_CTL (at 0xcf45)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf450 0xcf450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO16_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_EN_CTL (at 0xcf46)"
      tindex ezaxi:0xfc4cf980 %l 0x80cf460 0xcf460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO16_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_SEC_ACCESS (at 0xcfd0)"
      tindex ezaxi:0xfc4cf980 %l 0x80cfd00 0xcfd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO16_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_PERPH_RESET_CTL1 (at 0xcfd8)"
      tindex ezaxi:0xfc4cf980 %l 0x80cfd80 0xcfd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO16_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_PERPH_RESET_CTL2 (at 0xcfd9)"
      tindex ezaxi:0xfc4cf980 %l 0x80cfd90 0xcfd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO16_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_PERPH_RESET_CTL3 (at 0xcfda)"
      tindex ezaxi:0xfc4cf980 %l 0x80cfda0 0xcfda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO16_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO16_PERPH_RESET_CTL4 (at 0xcfdb)"
      tindex ezaxi:0xfc4cf980 %l 0x80cfdb0 0xcfdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO17"
  tree "GPIO17"
    tree "GPIO17_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_REVISION1 (at 0xd000)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0000 0xd0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO17_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_REVISION2 (at 0xd001)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0010 0xd0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO17_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_REVISION3 (at 0xd002)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0020 0xd0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO17_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_REVISION4 (at 0xd003)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0030 0xd0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO17_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_PERPH_TYPE (at 0xd004)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0040 0xd0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO17_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_PERPH_SUBTYPE (at 0xd005)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0050 0xd0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO17_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_STATUS1 (at 0xd008)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0080 0xd0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO17_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_RT_STS (at 0xd010)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0100 0xd0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO17_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_SET_TYPE (at 0xd011)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0110 0xd0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO17_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_POLARITY_HIGH (at 0xd012)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0120 0xd0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO17_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_POLARITY_LOW (at 0xd013)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0130 0xd0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO17_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_LATCHED_CLR (at 0xd014)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0140 0xd0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO17_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_EN_SET (at 0xd015)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0150 0xd0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO17_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_EN_CLR (at 0xd016)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0160 0xd0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO17_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_LATCHED_STS (at 0xd018)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0180 0xd0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO17_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_PENDING_STS (at 0xd019)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0190 0xd0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO17_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_MID_SEL (at 0xd01a)"
      tindex ezaxi:0xfc4cf980 %l 0x80d01a0 0xd01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO17_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_INT_PRIORITY (at 0xd01b)"
      tindex ezaxi:0xfc4cf980 %l 0x80d01b0 0xd01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO17_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_MODE_CTL (at 0xd040)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0400 0xd0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO17_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_DIG_VIN_CTL (at 0xd041)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0410 0xd0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO17_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_DIG_PULL_CTL (at 0xd042)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0420 0xd0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO17_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_DIG_IN_CTL (at 0xd043)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0430 0xd0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO17_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_DIG_OUT_CTL (at 0xd045)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0450 0xd0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO17_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_EN_CTL (at 0xd046)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0460 0xd0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO17_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_SEC_ACCESS (at 0xd0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0d00 0xd0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO17_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_PERPH_RESET_CTL1 (at 0xd0d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0d80 0xd0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO17_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_PERPH_RESET_CTL2 (at 0xd0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0d90 0xd0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO17_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_PERPH_RESET_CTL3 (at 0xd0da)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0da0 0xd0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO17_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO17_PERPH_RESET_CTL4 (at 0xd0db)"
      tindex ezaxi:0xfc4cf980 %l 0x80d0db0 0xd0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO18"
  tree "GPIO18"
    tree "GPIO18_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_REVISION1 (at 0xd100)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1000 0xd1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO18_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_REVISION2 (at 0xd101)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1010 0xd1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO18_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_REVISION3 (at 0xd102)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1020 0xd1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO18_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_REVISION4 (at 0xd103)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1030 0xd1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO18_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_PERPH_TYPE (at 0xd104)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1040 0xd1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO18_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_PERPH_SUBTYPE (at 0xd105)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1050 0xd1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO18_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_STATUS1 (at 0xd108)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1080 0xd1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO18_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_RT_STS (at 0xd110)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1100 0xd1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO18_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_SET_TYPE (at 0xd111)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1110 0xd1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO18_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_POLARITY_HIGH (at 0xd112)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1120 0xd1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO18_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_POLARITY_LOW (at 0xd113)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1130 0xd1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO18_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_LATCHED_CLR (at 0xd114)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1140 0xd1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO18_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_EN_SET (at 0xd115)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1150 0xd1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO18_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_EN_CLR (at 0xd116)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1160 0xd1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO18_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_LATCHED_STS (at 0xd118)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1180 0xd1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO18_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_PENDING_STS (at 0xd119)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1190 0xd1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO18_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_MID_SEL (at 0xd11a)"
      tindex ezaxi:0xfc4cf980 %l 0x80d11a0 0xd11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO18_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_INT_PRIORITY (at 0xd11b)"
      tindex ezaxi:0xfc4cf980 %l 0x80d11b0 0xd11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO18_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_MODE_CTL (at 0xd140)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1400 0xd1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO18_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_DIG_VIN_CTL (at 0xd141)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1410 0xd1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO18_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_DIG_PULL_CTL (at 0xd142)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1420 0xd1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO18_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_DIG_IN_CTL (at 0xd143)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1430 0xd1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO18_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_DIG_OUT_CTL (at 0xd145)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1450 0xd1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO18_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_EN_CTL (at 0xd146)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1460 0xd1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO18_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_SEC_ACCESS (at 0xd1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1d00 0xd1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO18_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_PERPH_RESET_CTL1 (at 0xd1d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1d80 0xd1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO18_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_PERPH_RESET_CTL2 (at 0xd1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1d90 0xd1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO18_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_PERPH_RESET_CTL3 (at 0xd1da)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1da0 0xd1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO18_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO18_PERPH_RESET_CTL4 (at 0xd1db)"
      tindex ezaxi:0xfc4cf980 %l 0x80d1db0 0xd1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO19"
  tree "GPIO19"
    tree "GPIO19_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_REVISION1 (at 0xd200)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2000 0xd2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO19_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_REVISION2 (at 0xd201)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2010 0xd2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO19_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_REVISION3 (at 0xd202)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2020 0xd2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO19_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_REVISION4 (at 0xd203)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2030 0xd2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO19_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_PERPH_TYPE (at 0xd204)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2040 0xd2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO19_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_PERPH_SUBTYPE (at 0xd205)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2050 0xd2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO19_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_STATUS1 (at 0xd208)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2080 0xd2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO19_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_RT_STS (at 0xd210)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2100 0xd2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO19_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_SET_TYPE (at 0xd211)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2110 0xd2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO19_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_POLARITY_HIGH (at 0xd212)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2120 0xd2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO19_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_POLARITY_LOW (at 0xd213)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2130 0xd2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO19_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_LATCHED_CLR (at 0xd214)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2140 0xd2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO19_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_EN_SET (at 0xd215)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2150 0xd2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO19_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_EN_CLR (at 0xd216)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2160 0xd2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO19_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_LATCHED_STS (at 0xd218)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2180 0xd2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO19_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_PENDING_STS (at 0xd219)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2190 0xd2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO19_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_MID_SEL (at 0xd21a)"
      tindex ezaxi:0xfc4cf980 %l 0x80d21a0 0xd21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO19_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_INT_PRIORITY (at 0xd21b)"
      tindex ezaxi:0xfc4cf980 %l 0x80d21b0 0xd21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO19_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_MODE_CTL (at 0xd240)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2400 0xd2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO19_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_DIG_VIN_CTL (at 0xd241)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2410 0xd2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO19_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_DIG_PULL_CTL (at 0xd242)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2420 0xd2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO19_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_DIG_IN_CTL (at 0xd243)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2430 0xd2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO19_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_DIG_OUT_CTL (at 0xd245)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2450 0xd2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO19_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_EN_CTL (at 0xd246)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2460 0xd2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO19_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_SEC_ACCESS (at 0xd2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2d00 0xd2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO19_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_PERPH_RESET_CTL1 (at 0xd2d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2d80 0xd2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO19_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_PERPH_RESET_CTL2 (at 0xd2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2d90 0xd2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO19_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_PERPH_RESET_CTL3 (at 0xd2da)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2da0 0xd2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO19_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO19_PERPH_RESET_CTL4 (at 0xd2db)"
      tindex ezaxi:0xfc4cf980 %l 0x80d2db0 0xd2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION1 (at 0xc100)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1000 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION2 (at 0xc101)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1010 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION3 (at 0xc102)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1020 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_REVISION4 (at 0xc103)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1030 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_TYPE (at 0xc104)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1040 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_SUBTYPE (at 0xc105)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1050 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_STATUS1 (at 0xc108)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1080 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_RT_STS (at 0xc110)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1100 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_SET_TYPE (at 0xc111)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1110 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1120 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_POLARITY_LOW (at 0xc113)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1130 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_LATCHED_CLR (at 0xc114)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1140 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_EN_SET (at 0xc115)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1150 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_EN_CLR (at 0xc116)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1160 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_LATCHED_STS (at 0xc118)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1180 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_PENDING_STS (at 0xc119)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1190 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_MID_SEL (at 0xc11a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c11a0 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_INT_PRIORITY (at 0xc11b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c11b0 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_MODE_CTL (at 0xc140)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1400 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_VIN_CTL (at 0xc141)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1410 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_PULL_CTL (at 0xc142)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1420 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO2_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_IN_CTL (at 0xc143)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1430 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO2_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_DIG_OUT_CTL (at 0xc145)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1450 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_EN_CTL (at 0xc146)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1460 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_SEC_ACCESS (at 0xc1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1d00 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1d80 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1d90 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1da0 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c1db0 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO20"
  tree "GPIO20"
    tree "GPIO20_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_REVISION1 (at 0xd300)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3000 0xd3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO20_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_REVISION2 (at 0xd301)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3010 0xd3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO20_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_REVISION3 (at 0xd302)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3020 0xd3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO20_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_REVISION4 (at 0xd303)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3030 0xd3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO20_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_PERPH_TYPE (at 0xd304)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3040 0xd3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO20_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_PERPH_SUBTYPE (at 0xd305)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3050 0xd3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO20_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_STATUS1 (at 0xd308)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3080 0xd3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO20_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_RT_STS (at 0xd310)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3100 0xd3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO20_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_SET_TYPE (at 0xd311)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3110 0xd3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO20_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_POLARITY_HIGH (at 0xd312)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3120 0xd3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO20_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_POLARITY_LOW (at 0xd313)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3130 0xd3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO20_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_LATCHED_CLR (at 0xd314)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3140 0xd3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO20_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_EN_SET (at 0xd315)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3150 0xd3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO20_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_EN_CLR (at 0xd316)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3160 0xd3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO20_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_LATCHED_STS (at 0xd318)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3180 0xd3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO20_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_PENDING_STS (at 0xd319)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3190 0xd3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO20_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_MID_SEL (at 0xd31a)"
      tindex ezaxi:0xfc4cf980 %l 0x80d31a0 0xd31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO20_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_INT_PRIORITY (at 0xd31b)"
      tindex ezaxi:0xfc4cf980 %l 0x80d31b0 0xd31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO20_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_MODE_CTL (at 0xd340)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3400 0xd3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO20_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_DIG_VIN_CTL (at 0xd341)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3410 0xd3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO20_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_DIG_PULL_CTL (at 0xd342)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3420 0xd3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO20_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_DIG_IN_CTL (at 0xd343)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3430 0xd3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO20_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_DIG_OUT_CTL (at 0xd345)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3450 0xd3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO20_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_EN_CTL (at 0xd346)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3460 0xd3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO20_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_SEC_ACCESS (at 0xd3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3d00 0xd3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO20_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_PERPH_RESET_CTL1 (at 0xd3d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3d80 0xd3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO20_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_PERPH_RESET_CTL2 (at 0xd3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3d90 0xd3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO20_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_PERPH_RESET_CTL3 (at 0xd3da)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3da0 0xd3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO20_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO20_PERPH_RESET_CTL4 (at 0xd3db)"
      tindex ezaxi:0xfc4cf980 %l 0x80d3db0 0xd3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO21"
  tree "GPIO21"
    tree "GPIO21_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_REVISION1 (at 0xd400)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4000 0xd4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO21_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_REVISION2 (at 0xd401)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4010 0xd4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO21_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_REVISION3 (at 0xd402)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4020 0xd4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO21_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_REVISION4 (at 0xd403)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4030 0xd4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO21_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_PERPH_TYPE (at 0xd404)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4040 0xd4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO21_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_PERPH_SUBTYPE (at 0xd405)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4050 0xd4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO21_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_STATUS1 (at 0xd408)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4080 0xd4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO21_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_RT_STS (at 0xd410)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4100 0xd4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO21_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_SET_TYPE (at 0xd411)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4110 0xd4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO21_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_POLARITY_HIGH (at 0xd412)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4120 0xd4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO21_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_POLARITY_LOW (at 0xd413)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4130 0xd4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO21_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_LATCHED_CLR (at 0xd414)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4140 0xd4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO21_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_EN_SET (at 0xd415)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4150 0xd4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO21_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_EN_CLR (at 0xd416)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4160 0xd4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO21_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_LATCHED_STS (at 0xd418)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4180 0xd4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO21_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_PENDING_STS (at 0xd419)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4190 0xd4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO21_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_MID_SEL (at 0xd41a)"
      tindex ezaxi:0xfc4cf980 %l 0x80d41a0 0xd41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO21_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_INT_PRIORITY (at 0xd41b)"
      tindex ezaxi:0xfc4cf980 %l 0x80d41b0 0xd41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO21_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_MODE_CTL (at 0xd440)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4400 0xd4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO21_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_DIG_VIN_CTL (at 0xd441)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4410 0xd4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO21_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_DIG_PULL_CTL (at 0xd442)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4420 0xd4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO21_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_DIG_IN_CTL (at 0xd443)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4430 0xd4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO21_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_DIG_OUT_CTL (at 0xd445)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4450 0xd4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO21_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_EN_CTL (at 0xd446)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4460 0xd4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO21_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_SEC_ACCESS (at 0xd4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4d00 0xd4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO21_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_PERPH_RESET_CTL1 (at 0xd4d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4d80 0xd4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO21_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_PERPH_RESET_CTL2 (at 0xd4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4d90 0xd4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO21_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_PERPH_RESET_CTL3 (at 0xd4da)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4da0 0xd4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO21_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO21_PERPH_RESET_CTL4 (at 0xd4db)"
      tindex ezaxi:0xfc4cf980 %l 0x80d4db0 0xd4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO22"
  tree "GPIO22"
    tree "GPIO22_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_REVISION1 (at 0xd500)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5000 0xd5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO22_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_REVISION2 (at 0xd501)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5010 0xd5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO22_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_REVISION3 (at 0xd502)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5020 0xd5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO22_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_REVISION4 (at 0xd503)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5030 0xd5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO22_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_PERPH_TYPE (at 0xd504)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5040 0xd5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO22_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_PERPH_SUBTYPE (at 0xd505)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5050 0xd5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO22_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_STATUS1 (at 0xd508)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5080 0xd5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO22_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_RT_STS (at 0xd510)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5100 0xd5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO22_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_SET_TYPE (at 0xd511)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5110 0xd5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO22_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_POLARITY_HIGH (at 0xd512)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5120 0xd5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO22_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_POLARITY_LOW (at 0xd513)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5130 0xd5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO22_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_LATCHED_CLR (at 0xd514)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5140 0xd5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO22_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_EN_SET (at 0xd515)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5150 0xd5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO22_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_EN_CLR (at 0xd516)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5160 0xd5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO22_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_LATCHED_STS (at 0xd518)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5180 0xd5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO22_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_PENDING_STS (at 0xd519)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5190 0xd5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO22_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_MID_SEL (at 0xd51a)"
      tindex ezaxi:0xfc4cf980 %l 0x80d51a0 0xd51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO22_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_INT_PRIORITY (at 0xd51b)"
      tindex ezaxi:0xfc4cf980 %l 0x80d51b0 0xd51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO22_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_MODE_CTL (at 0xd540)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5400 0xd5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO22_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_DIG_VIN_CTL (at 0xd541)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5410 0xd5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO22_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_DIG_PULL_CTL (at 0xd542)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5420 0xd5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO22_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_DIG_IN_CTL (at 0xd543)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5430 0xd5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO22_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_DIG_OUT_CTL (at 0xd545)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5450 0xd5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO22_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_EN_CTL (at 0xd546)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5460 0xd5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO22_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_SEC_ACCESS (at 0xd5d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5d00 0xd5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO22_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_PERPH_RESET_CTL1 (at 0xd5d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5d80 0xd5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO22_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_PERPH_RESET_CTL2 (at 0xd5d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5d90 0xd5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO22_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_PERPH_RESET_CTL3 (at 0xd5da)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5da0 0xd5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO22_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO22_PERPH_RESET_CTL4 (at 0xd5db)"
      tindex ezaxi:0xfc4cf980 %l 0x80d5db0 0xd5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO3"
  tree "GPIO3"
    tree "GPIO3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION1 (at 0xc200)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2000 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION2 (at 0xc201)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2010 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO3_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION3 (at 0xc202)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2020 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_REVISION4 (at 0xc203)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2030 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_TYPE (at 0xc204)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2040 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_SUBTYPE (at 0xc205)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2050 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_STATUS1 (at 0xc208)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2080 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_RT_STS (at 0xc210)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2100 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_SET_TYPE (at 0xc211)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2110 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_POLARITY_HIGH (at 0xc212)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2120 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_POLARITY_LOW (at 0xc213)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2130 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_LATCHED_CLR (at 0xc214)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2140 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_EN_SET (at 0xc215)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2150 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_EN_CLR (at 0xc216)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2160 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_LATCHED_STS (at 0xc218)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2180 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_PENDING_STS (at 0xc219)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2190 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_MID_SEL (at 0xc21a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c21a0 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_INT_PRIORITY (at 0xc21b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c21b0 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO3_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_MODE_CTL (at 0xc240)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2400 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO3_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_VIN_CTL (at 0xc241)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2410 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO3_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_PULL_CTL (at 0xc242)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2420 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO3_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_IN_CTL (at 0xc243)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2430 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO3_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_DIG_OUT_CTL (at 0xc245)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2450 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_EN_CTL (at 0xc246)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2460 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_SEC_ACCESS (at 0xc2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2d00 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL1 (at 0xc2d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2d80 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL2 (at 0xc2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2d90 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL3 (at 0xc2da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2da0 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO3_PERPH_RESET_CTL4 (at 0xc2db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c2db0 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO4"
  tree "GPIO4"
    tree "GPIO4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION1 (at 0xc300)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3000 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION2 (at 0xc301)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3010 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO4_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION3 (at 0xc302)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3020 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_REVISION4 (at 0xc303)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3030 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_TYPE (at 0xc304)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3040 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_SUBTYPE (at 0xc305)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3050 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO4_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_STATUS1 (at 0xc308)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3080 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_RT_STS (at 0xc310)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3100 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_SET_TYPE (at 0xc311)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3110 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_POLARITY_HIGH (at 0xc312)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3120 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_POLARITY_LOW (at 0xc313)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3130 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_LATCHED_CLR (at 0xc314)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3140 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_EN_SET (at 0xc315)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3150 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_EN_CLR (at 0xc316)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3160 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_LATCHED_STS (at 0xc318)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3180 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_PENDING_STS (at 0xc319)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3190 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_MID_SEL (at 0xc31a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c31a0 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_INT_PRIORITY (at 0xc31b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c31b0 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO4_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_MODE_CTL (at 0xc340)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3400 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO4_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_VIN_CTL (at 0xc341)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3410 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO4_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_PULL_CTL (at 0xc342)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3420 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO4_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_IN_CTL (at 0xc343)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3430 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO4_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_DIG_OUT_CTL (at 0xc345)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3450 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO4_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_EN_CTL (at 0xc346)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3460 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_SEC_ACCESS (at 0xc3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3d00 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO4_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL1 (at 0xc3d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3d80 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL2 (at 0xc3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3d90 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL3 (at 0xc3da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3da0 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO4_PERPH_RESET_CTL4 (at 0xc3db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c3db0 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO5"
  tree "GPIO5"
    tree "GPIO5_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION1 (at 0xc400)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4000 0xc4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION2 (at 0xc401)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4010 0xc4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO5_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION3 (at 0xc402)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4020 0xc4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_REVISION4 (at 0xc403)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4030 0xc4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO5_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_TYPE (at 0xc404)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4040 0xc4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO5_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_SUBTYPE (at 0xc405)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4050 0xc4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO5_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_STATUS1 (at 0xc408)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4080 0xc4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO5_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_RT_STS (at 0xc410)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4100 0xc4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO5_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_SET_TYPE (at 0xc411)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4110 0xc4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO5_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_POLARITY_HIGH (at 0xc412)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4120 0xc4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_POLARITY_LOW (at 0xc413)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4130 0xc4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_LATCHED_CLR (at 0xc414)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4140 0xc4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO5_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_EN_SET (at 0xc415)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4150 0xc4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_EN_CLR (at 0xc416)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4160 0xc4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO5_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_LATCHED_STS (at 0xc418)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4180 0xc4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO5_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_PENDING_STS (at 0xc419)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4190 0xc4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO5_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_MID_SEL (at 0xc41a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c41a0 0xc41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO5_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_INT_PRIORITY (at 0xc41b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c41b0 0xc41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO5_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_MODE_CTL (at 0xc440)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4400 0xc4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO5_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_VIN_CTL (at 0xc441)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4410 0xc4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO5_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_PULL_CTL (at 0xc442)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4420 0xc4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO5_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_IN_CTL (at 0xc443)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4430 0xc4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO5_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_DIG_OUT_CTL (at 0xc445)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4450 0xc4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO5_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_EN_CTL (at 0xc446)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4460 0xc4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO5_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_SEC_ACCESS (at 0xc4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4d00 0xc4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO5_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL1 (at 0xc4d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4d80 0xc4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL2 (at 0xc4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4d90 0xc4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL3 (at 0xc4da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4da0 0xc4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO5_PERPH_RESET_CTL4 (at 0xc4db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c4db0 0xc4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO6"
  tree "GPIO6"
    tree "GPIO6_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION1 (at 0xc500)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5000 0xc5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION2 (at 0xc501)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5010 0xc5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO6_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION3 (at 0xc502)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5020 0xc5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_REVISION4 (at 0xc503)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5030 0xc5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO6_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_TYPE (at 0xc504)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5040 0xc5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO6_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_SUBTYPE (at 0xc505)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5050 0xc5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO6_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_STATUS1 (at 0xc508)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5080 0xc5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO6_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_RT_STS (at 0xc510)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5100 0xc5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO6_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_SET_TYPE (at 0xc511)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5110 0xc5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO6_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_POLARITY_HIGH (at 0xc512)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5120 0xc5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_POLARITY_LOW (at 0xc513)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5130 0xc5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_LATCHED_CLR (at 0xc514)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5140 0xc5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO6_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_EN_SET (at 0xc515)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5150 0xc5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_EN_CLR (at 0xc516)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5160 0xc5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO6_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_LATCHED_STS (at 0xc518)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5180 0xc5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO6_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_PENDING_STS (at 0xc519)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5190 0xc5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO6_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_MID_SEL (at 0xc51a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c51a0 0xc51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO6_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_INT_PRIORITY (at 0xc51b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c51b0 0xc51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO6_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_MODE_CTL (at 0xc540)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5400 0xc5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO6_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_VIN_CTL (at 0xc541)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5410 0xc5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO6_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_PULL_CTL (at 0xc542)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5420 0xc5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO6_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_IN_CTL (at 0xc543)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5430 0xc5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO6_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_DIG_OUT_CTL (at 0xc545)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5450 0xc5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO6_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_EN_CTL (at 0xc546)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5460 0xc5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO6_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_SEC_ACCESS (at 0xc5d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5d00 0xc5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO6_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL1 (at 0xc5d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5d80 0xc5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL2 (at 0xc5d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5d90 0xc5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL3 (at 0xc5da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5da0 0xc5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO6_PERPH_RESET_CTL4 (at 0xc5db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c5db0 0xc5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO7"
  tree "GPIO7"
    tree "GPIO7_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION1 (at 0xc600)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6000 0xc6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO7_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION2 (at 0xc601)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6010 0xc6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO7_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION3 (at 0xc602)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6020 0xc6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO7_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_REVISION4 (at 0xc603)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6030 0xc6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO7_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_TYPE (at 0xc604)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6040 0xc6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO7_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_SUBTYPE (at 0xc605)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6050 0xc6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO7_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_STATUS1 (at 0xc608)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6080 0xc6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO7_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_RT_STS (at 0xc610)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6100 0xc6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO7_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_SET_TYPE (at 0xc611)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6110 0xc6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO7_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_POLARITY_HIGH (at 0xc612)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6120 0xc6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO7_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_POLARITY_LOW (at 0xc613)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6130 0xc6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO7_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_LATCHED_CLR (at 0xc614)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6140 0xc6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO7_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_EN_SET (at 0xc615)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6150 0xc6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO7_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_EN_CLR (at 0xc616)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6160 0xc6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO7_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_LATCHED_STS (at 0xc618)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6180 0xc6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO7_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_PENDING_STS (at 0xc619)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6190 0xc6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO7_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_MID_SEL (at 0xc61a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c61a0 0xc61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO7_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_INT_PRIORITY (at 0xc61b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c61b0 0xc61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO7_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_MODE_CTL (at 0xc640)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6400 0xc6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO7_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_VIN_CTL (at 0xc641)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6410 0xc6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO7_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_PULL_CTL (at 0xc642)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6420 0xc6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO7_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_IN_CTL (at 0xc643)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6430 0xc6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO7_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_DIG_OUT_CTL (at 0xc645)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6450 0xc6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO7_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_EN_CTL (at 0xc646)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6460 0xc6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO7_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_SEC_ACCESS (at 0xc6d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6d00 0xc6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO7_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL1 (at 0xc6d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6d80 0xc6d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL2 (at 0xc6d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6d90 0xc6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL3 (at 0xc6da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6da0 0xc6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO7_PERPH_RESET_CTL4 (at 0xc6db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c6db0 0xc6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO8"
  tree "GPIO8"
    tree "GPIO8_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION1 (at 0xc700)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7000 0xc7000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO8_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION2 (at 0xc701)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7010 0xc7010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO8_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION3 (at 0xc702)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7020 0xc7020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO8_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_REVISION4 (at 0xc703)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7030 0xc7030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO8_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_TYPE (at 0xc704)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7040 0xc7040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO8_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_SUBTYPE (at 0xc705)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7050 0xc7050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO8_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_STATUS1 (at 0xc708)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7080 0xc7080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO8_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_RT_STS (at 0xc710)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7100 0xc7100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO8_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_SET_TYPE (at 0xc711)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7110 0xc7110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO8_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_POLARITY_HIGH (at 0xc712)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7120 0xc7120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO8_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_POLARITY_LOW (at 0xc713)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7130 0xc7130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO8_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_LATCHED_CLR (at 0xc714)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7140 0xc7140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO8_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_EN_SET (at 0xc715)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7150 0xc7150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO8_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_EN_CLR (at 0xc716)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7160 0xc7160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO8_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_LATCHED_STS (at 0xc718)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7180 0xc7180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO8_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_PENDING_STS (at 0xc719)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7190 0xc7190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO8_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_MID_SEL (at 0xc71a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c71a0 0xc71a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO8_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_INT_PRIORITY (at 0xc71b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c71b0 0xc71b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO8_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_MODE_CTL (at 0xc740)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7400 0xc7400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO8_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_VIN_CTL (at 0xc741)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7410 0xc7410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO8_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_PULL_CTL (at 0xc742)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7420 0xc7420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO8_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_IN_CTL (at 0xc743)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7430 0xc7430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO8_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_DIG_OUT_CTL (at 0xc745)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7450 0xc7450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO8_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_EN_CTL (at 0xc746)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7460 0xc7460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO8_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_SEC_ACCESS (at 0xc7d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7d00 0xc7d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO8_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL1 (at 0xc7d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7d80 0xc7d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL2 (at 0xc7d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7d90 0xc7d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL3 (at 0xc7da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7da0 0xc7da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO8_PERPH_RESET_CTL4 (at 0xc7db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c7db0 0xc7db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO9"
  tree "GPIO9"
    tree "GPIO9_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION1 (at 0xc800)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8000 0xc8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO9_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION2 (at 0xc801)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8010 0xc8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO9_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION3 (at 0xc802)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8020 0xc8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO9_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_REVISION4 (at 0xc803)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8030 0xc8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO9_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_TYPE (at 0xc804)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8040 0xc8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO9_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_SUBTYPE (at 0xc805)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8050 0xc8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO9_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_STATUS1 (at 0xc808)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8080 0xc8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO9_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_RT_STS (at 0xc810)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8100 0xc8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO9_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_SET_TYPE (at 0xc811)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8110 0xc8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO9_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_POLARITY_HIGH (at 0xc812)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8120 0xc8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO9_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_POLARITY_LOW (at 0xc813)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8130 0xc8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO9_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_LATCHED_CLR (at 0xc814)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8140 0xc8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO9_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_EN_SET (at 0xc815)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8150 0xc8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO9_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_EN_CLR (at 0xc816)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8160 0xc8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO9_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_LATCHED_STS (at 0xc818)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8180 0xc8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO9_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_PENDING_STS (at 0xc819)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8190 0xc8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO9_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_MID_SEL (at 0xc81a)"
      tindex ezaxi:0xfc4cf980 %l 0x80c81a0 0xc81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO9_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_INT_PRIORITY (at 0xc81b)"
      tindex ezaxi:0xfc4cf980 %l 0x80c81b0 0xc81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO9_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_MODE_CTL (at 0xc840)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8400 0xc8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO9_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_VIN_CTL (at 0xc841)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8410 0xc8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (VIN4),5 (VIN5),6 (VIN6),7 (VIN7)"
    tree.end
    tree "GPIO9_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_PULL_CTL (at 0xc842)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8420 0xc8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO9_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_IN_CTL (at 0xc843)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8430 0xc8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO9_DIG_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_DIG_OUT_CTL (at 0xc845)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8450 0xc8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO9_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_EN_CTL (at 0xc846)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8460 0xc8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO9_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_SEC_ACCESS (at 0xc8d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8d00 0xc8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO9_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL1 (at 0xc8d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8d80 0xc8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO9_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL2 (at 0xc8d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8d90 0xc8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO9_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL3 (at 0xc8da)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8da0 0xc8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO9_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "GPIO9_PERPH_RESET_CTL4 (at 0xc8db)"
      tindex ezaxi:0xfc4cf980 %l 0x80c8db0 0xc8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_REVISION1 (at 0x500)"
      tindex ezaxi:0xfc4cf980 %l 0x8005000 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_REVISION2 (at 0x501)"
      tindex ezaxi:0xfc4cf980 %l 0x8005010 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_TYPE (at 0x504)"
      tindex ezaxi:0xfc4cf980 %l 0x8005040 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_SUBTYPE (at 0x505)"
      tindex ezaxi:0xfc4cf980 %l 0x8005050 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_STATUS1 (at 0x508)"
      tindex ezaxi:0xfc4cf980 %l 0x8005080 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_STATUS2 (at 0x509)"
      tindex ezaxi:0xfc4cf980 %l 0x8005090 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_INT_RESEND_ALL (at 0x540)"
      tindex ezaxi:0xfc4cf980 %l 0x8005400 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_EN_CTL1 (at 0x546)"
      tindex ezaxi:0xfc4cf980 %l 0x8005460 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_SEC_ACCESS (at 0x5d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8005d00 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL1 (at 0x5d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8005d80 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL2 (at 0x5d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8005d90 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL3 (at 0x5da)"
      tindex ezaxi:0xfc4cf980 %l 0x8005da0 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_PERPH_RESET_CTL4 (at 0x5db)"
      tindex ezaxi:0xfc4cf980 %l 0x8005db0 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "INT_TEST1 (at 0x5e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8005e00 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION1 (at 0x14000)"
      tindex ezaxi:0xfc4cf980 %l 0x8140000 0x140000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION2 (at 0x14001)"
      tindex ezaxi:0xfc4cf980 %l 0x8140010 0x140010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION3 (at 0x14002)"
      tindex ezaxi:0xfc4cf980 %l 0x8140020 0x140020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_REVISION4 (at 0x14003)"
      tindex ezaxi:0xfc4cf980 %l 0x8140030 0x140030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_TYPE (at 0x14004)"
      tindex ezaxi:0xfc4cf980 %l 0x8140040 0x140040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_SUBTYPE (at 0x14005)"
      tindex ezaxi:0xfc4cf980 %l 0x8140050 0x140050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_STATUS1 (at 0x14008)"
      tindex ezaxi:0xfc4cf980 %l 0x8140080 0x140080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO1_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_STATUS2 (at 0x14009)"
      tindex ezaxi:0xfc4cf980 %l 0x8140090 0x140090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO1_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_STATUS3 (at 0x1400a)"
      tindex ezaxi:0xfc4cf980 %l 0x81400a0 0x1400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_RT_STS (at 0x14010)"
      tindex ezaxi:0xfc4cf980 %l 0x8140100 0x140100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_SET_TYPE (at 0x14011)"
      tindex ezaxi:0xfc4cf980 %l 0x8140110 0x140110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_POLARITY_HIGH (at 0x14012)"
      tindex ezaxi:0xfc4cf980 %l 0x8140120 0x140120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_POLARITY_LOW (at 0x14013)"
      tindex ezaxi:0xfc4cf980 %l 0x8140130 0x140130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_LATCHED_CLR (at 0x14014)"
      tindex ezaxi:0xfc4cf980 %l 0x8140140 0x140140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_EN_SET (at 0x14015)"
      tindex ezaxi:0xfc4cf980 %l 0x8140150 0x140150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_EN_CLR (at 0x14016)"
      tindex ezaxi:0xfc4cf980 %l 0x8140160 0x140160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_LATCHED_STS (at 0x14018)"
      tindex ezaxi:0xfc4cf980 %l 0x8140180 0x140180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_PENDING_STS (at 0x14019)"
      tindex ezaxi:0xfc4cf980 %l 0x8140190 0x140190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_MID_SEL (at 0x1401a)"
      tindex ezaxi:0xfc4cf980 %l 0x81401a0 0x1401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_PRIORITY (at 0x1401b)"
      tindex ezaxi:0xfc4cf980 %l 0x81401b0 0x1401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO1_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_VOLTAGE_CTL1 (at 0x14040)"
      tindex ezaxi:0xfc4cf980 %l 0x8140400 0x140400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_VOLTAGE_CTL2 (at 0x14041)"
      tindex ezaxi:0xfc4cf980 %l 0x8140410 0x140410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_MODE_CTL2 (at 0x14045)"
      tindex ezaxi:0xfc4cf980 %l 0x8140450 0x140450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_EN_CTL (at 0x14046)"
      tindex ezaxi:0xfc4cf980 %l 0x8140460 0x140460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO1_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PD_CTL (at 0x14048)"
      tindex ezaxi:0xfc4cf980 %l 0x8140480 0x140480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO1_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_CURRENT_LIM_CTL (at 0x1404a)"
      tindex ezaxi:0xfc4cf980 %l 0x81404a0 0x1404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_SOFT_START_CTL (at 0x1404c)"
      tindex ezaxi:0xfc4cf980 %l 0x81404c0 0x1404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO1_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_CONFIG_CTL (at 0x14052)"
      tindex ezaxi:0xfc4cf980 %l 0x8140520 0x140520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO1_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_VS_CTL (at 0x14061)"
      tindex ezaxi:0xfc4cf980 %l 0x8140610 0x140610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_LL_VOLTAGE_CTL1 (at 0x14068)"
      tindex ezaxi:0xfc4cf980 %l 0x8140680 0x140680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_LL_VOLTAGE_CTL2 (at 0x14069)"
      tindex ezaxi:0xfc4cf980 %l 0x8140690 0x140690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_UL_VOLTAGE_CTL1 (at 0x1406a)"
      tindex ezaxi:0xfc4cf980 %l 0x81406a0 0x1406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_UL_VOLTAGE_CTL2 (at 0x1406b)"
      tindex ezaxi:0xfc4cf980 %l 0x81406b0 0x1406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_SEC_ACCESS (at 0x140d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8140d00 0x140d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8140d80 0x140d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8140d90 0x140d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
      tindex ezaxi:0xfc4cf980 %l 0x8140da0 0x140da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
      tindex ezaxi:0xfc4cf980 %l 0x8140db0 0x140db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_TEST1 (at 0x140e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8140e00 0x140e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_INT_TEST_VAL (at 0x140e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8140e10 0x140e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TEST1 (at 0x140e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8140e20 0x140e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TEST2 (at 0x140e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8140e30 0x140e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO1_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TRIM_NUM (at 0x140f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8140f00 0x140f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO1_TRIM_CTRL (at 0x140f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8140f10 0x140f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO10"
  tree "LDO10"
    tree "LDO10_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_REVISION1 (at 0x14900)"
      tindex ezaxi:0xfc4cf980 %l 0x8149000 0x149000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO10_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_REVISION2 (at 0x14901)"
      tindex ezaxi:0xfc4cf980 %l 0x8149010 0x149010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO10_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_REVISION3 (at 0x14902)"
      tindex ezaxi:0xfc4cf980 %l 0x8149020 0x149020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO10_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_REVISION4 (at 0x14903)"
      tindex ezaxi:0xfc4cf980 %l 0x8149030 0x149030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO10_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_PERPH_TYPE (at 0x14904)"
      tindex ezaxi:0xfc4cf980 %l 0x8149040 0x149040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO10_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_PERPH_SUBTYPE (at 0x14905)"
      tindex ezaxi:0xfc4cf980 %l 0x8149050 0x149050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO10_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_STATUS1 (at 0x14908)"
      tindex ezaxi:0xfc4cf980 %l 0x8149080 0x149080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO10_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_STATUS2 (at 0x14909)"
      tindex ezaxi:0xfc4cf980 %l 0x8149090 0x149090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO10_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_STATUS3 (at 0x1490a)"
      tindex ezaxi:0xfc4cf980 %l 0x81490a0 0x1490a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO10_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_RT_STS (at 0x14910)"
      tindex ezaxi:0xfc4cf980 %l 0x8149100 0x149100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_SET_TYPE (at 0x14911)"
      tindex ezaxi:0xfc4cf980 %l 0x8149110 0x149110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_POLARITY_HIGH (at 0x14912)"
      tindex ezaxi:0xfc4cf980 %l 0x8149120 0x149120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_POLARITY_LOW (at 0x14913)"
      tindex ezaxi:0xfc4cf980 %l 0x8149130 0x149130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO10_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_LATCHED_CLR (at 0x14914)"
      tindex ezaxi:0xfc4cf980 %l 0x8149140 0x149140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO10_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_EN_SET (at 0x14915)"
      tindex ezaxi:0xfc4cf980 %l 0x8149150 0x149150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_EN_CLR (at 0x14916)"
      tindex ezaxi:0xfc4cf980 %l 0x8149160 0x149160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO10_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_LATCHED_STS (at 0x14918)"
      tindex ezaxi:0xfc4cf980 %l 0x8149180 0x149180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO10_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_PENDING_STS (at 0x14919)"
      tindex ezaxi:0xfc4cf980 %l 0x8149190 0x149190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO10_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_MID_SEL (at 0x1491a)"
      tindex ezaxi:0xfc4cf980 %l 0x81491a0 0x1491a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO10_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_PRIORITY (at 0x1491b)"
      tindex ezaxi:0xfc4cf980 %l 0x81491b0 0x1491b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO10_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_VOLTAGE_CTL1 (at 0x14940)"
      tindex ezaxi:0xfc4cf980 %l 0x8149400 0x149400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_VOLTAGE_CTL2 (at 0x14941)"
      tindex ezaxi:0xfc4cf980 %l 0x8149410 0x149410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO10_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_MODE_CTL2 (at 0x14945)"
      tindex ezaxi:0xfc4cf980 %l 0x8149450 0x149450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO10_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_EN_CTL (at 0x14946)"
      tindex ezaxi:0xfc4cf980 %l 0x8149460 0x149460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO10_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_PD_CTL (at 0x14948)"
      tindex ezaxi:0xfc4cf980 %l 0x8149480 0x149480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO10_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_CURRENT_LIM_CTL (at 0x1494a)"
      tindex ezaxi:0xfc4cf980 %l 0x81494a0 0x1494a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO10_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_SOFT_START_CTL (at 0x1494c)"
      tindex ezaxi:0xfc4cf980 %l 0x81494c0 0x1494c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO10_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_CONFIG_CTL (at 0x14952)"
      tindex ezaxi:0xfc4cf980 %l 0x8149520 0x149520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_LL_VOLTAGE_CTL1 (at 0x14968)"
      tindex ezaxi:0xfc4cf980 %l 0x8149680 0x149680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_LL_VOLTAGE_CTL2 (at 0x14969)"
      tindex ezaxi:0xfc4cf980 %l 0x8149690 0x149690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_UL_VOLTAGE_CTL1 (at 0x1496a)"
      tindex ezaxi:0xfc4cf980 %l 0x81496a0 0x1496a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_UL_VOLTAGE_CTL2 (at 0x1496b)"
      tindex ezaxi:0xfc4cf980 %l 0x81496b0 0x1496b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO10_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_SEC_ACCESS (at 0x149d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8149d00 0x149d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO10_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_PERPH_RESET_CTL1 (at 0x149d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8149d80 0x149d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_PERPH_RESET_CTL2 (at 0x149d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8149d90 0x149d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_PERPH_RESET_CTL3 (at 0x149da)"
      tindex ezaxi:0xfc4cf980 %l 0x8149da0 0x149da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_PERPH_RESET_CTL4 (at 0x149db)"
      tindex ezaxi:0xfc4cf980 %l 0x8149db0 0x149db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO10_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_TEST1 (at 0x149e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8149e00 0x149e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO10_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_INT_TEST_VAL (at 0x149e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8149e10 0x149e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO10_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_TEST1 (at 0x149e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8149e20 0x149e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO10_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_TEST2 (at 0x149e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8149e30 0x149e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO10_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_TRIM_NUM (at 0x149f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8149f00 0x149f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO10_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO10_TRIM_CTRL (at 0x149f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8149f10 0x149f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO11"
  tree "LDO11"
    tree "LDO11_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_REVISION1 (at 0x14a00)"
      tindex ezaxi:0xfc4cf980 %l 0x814a000 0x14a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO11_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_REVISION2 (at 0x14a01)"
      tindex ezaxi:0xfc4cf980 %l 0x814a010 0x14a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO11_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_REVISION3 (at 0x14a02)"
      tindex ezaxi:0xfc4cf980 %l 0x814a020 0x14a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO11_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_REVISION4 (at 0x14a03)"
      tindex ezaxi:0xfc4cf980 %l 0x814a030 0x14a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO11_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_PERPH_TYPE (at 0x14a04)"
      tindex ezaxi:0xfc4cf980 %l 0x814a040 0x14a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO11_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_PERPH_SUBTYPE (at 0x14a05)"
      tindex ezaxi:0xfc4cf980 %l 0x814a050 0x14a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO11_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_STATUS1 (at 0x14a08)"
      tindex ezaxi:0xfc4cf980 %l 0x814a080 0x14a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO11_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_STATUS2 (at 0x14a09)"
      tindex ezaxi:0xfc4cf980 %l 0x814a090 0x14a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO11_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_STATUS3 (at 0x14a0a)"
      tindex ezaxi:0xfc4cf980 %l 0x814a0a0 0x14a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO11_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_RT_STS (at 0x14a10)"
      tindex ezaxi:0xfc4cf980 %l 0x814a100 0x14a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_SET_TYPE (at 0x14a11)"
      tindex ezaxi:0xfc4cf980 %l 0x814a110 0x14a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_POLARITY_HIGH (at 0x14a12)"
      tindex ezaxi:0xfc4cf980 %l 0x814a120 0x14a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_POLARITY_LOW (at 0x14a13)"
      tindex ezaxi:0xfc4cf980 %l 0x814a130 0x14a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO11_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_LATCHED_CLR (at 0x14a14)"
      tindex ezaxi:0xfc4cf980 %l 0x814a140 0x14a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO11_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_EN_SET (at 0x14a15)"
      tindex ezaxi:0xfc4cf980 %l 0x814a150 0x14a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_EN_CLR (at 0x14a16)"
      tindex ezaxi:0xfc4cf980 %l 0x814a160 0x14a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO11_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_LATCHED_STS (at 0x14a18)"
      tindex ezaxi:0xfc4cf980 %l 0x814a180 0x14a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO11_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_PENDING_STS (at 0x14a19)"
      tindex ezaxi:0xfc4cf980 %l 0x814a190 0x14a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO11_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_MID_SEL (at 0x14a1a)"
      tindex ezaxi:0xfc4cf980 %l 0x814a1a0 0x14a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO11_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_PRIORITY (at 0x14a1b)"
      tindex ezaxi:0xfc4cf980 %l 0x814a1b0 0x14a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO11_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_VOLTAGE_CTL1 (at 0x14a40)"
      tindex ezaxi:0xfc4cf980 %l 0x814a400 0x14a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_VOLTAGE_CTL2 (at 0x14a41)"
      tindex ezaxi:0xfc4cf980 %l 0x814a410 0x14a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO11_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_MODE_CTL2 (at 0x14a45)"
      tindex ezaxi:0xfc4cf980 %l 0x814a450 0x14a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO11_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_EN_CTL (at 0x14a46)"
      tindex ezaxi:0xfc4cf980 %l 0x814a460 0x14a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO11_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_PD_CTL (at 0x14a48)"
      tindex ezaxi:0xfc4cf980 %l 0x814a480 0x14a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO11_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_CURRENT_LIM_CTL (at 0x14a4a)"
      tindex ezaxi:0xfc4cf980 %l 0x814a4a0 0x14a4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO11_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_SOFT_START_CTL (at 0x14a4c)"
      tindex ezaxi:0xfc4cf980 %l 0x814a4c0 0x14a4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO11_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_CONFIG_CTL (at 0x14a52)"
      tindex ezaxi:0xfc4cf980 %l 0x814a520 0x14a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO11_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_LL_VOLTAGE_CTL1 (at 0x14a68)"
      tindex ezaxi:0xfc4cf980 %l 0x814a680 0x14a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_LL_VOLTAGE_CTL2 (at 0x14a69)"
      tindex ezaxi:0xfc4cf980 %l 0x814a690 0x14a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO11_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_UL_VOLTAGE_CTL1 (at 0x14a6a)"
      tindex ezaxi:0xfc4cf980 %l 0x814a6a0 0x14a6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_UL_VOLTAGE_CTL2 (at 0x14a6b)"
      tindex ezaxi:0xfc4cf980 %l 0x814a6b0 0x14a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO11_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_SEC_ACCESS (at 0x14ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x814ad00 0x14ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO11_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_PERPH_RESET_CTL1 (at 0x14ad8)"
      tindex ezaxi:0xfc4cf980 %l 0x814ad80 0x14ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_PERPH_RESET_CTL2 (at 0x14ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x814ad90 0x14ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_PERPH_RESET_CTL3 (at 0x14ada)"
      tindex ezaxi:0xfc4cf980 %l 0x814ada0 0x14ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_PERPH_RESET_CTL4 (at 0x14adb)"
      tindex ezaxi:0xfc4cf980 %l 0x814adb0 0x14adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO11_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_TEST1 (at 0x14ae0)"
      tindex ezaxi:0xfc4cf980 %l 0x814ae00 0x14ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO11_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_INT_TEST_VAL (at 0x14ae1)"
      tindex ezaxi:0xfc4cf980 %l 0x814ae10 0x14ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO11_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_TEST1 (at 0x14ae2)"
      tindex ezaxi:0xfc4cf980 %l 0x814ae20 0x14ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO11_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_TEST2 (at 0x14ae3)"
      tindex ezaxi:0xfc4cf980 %l 0x814ae30 0x14ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO11_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_TRIM_NUM (at 0x14af0)"
      tindex ezaxi:0xfc4cf980 %l 0x814af00 0x14af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO11_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO11_TRIM_CTRL (at 0x14af1)"
      tindex ezaxi:0xfc4cf980 %l 0x814af10 0x14af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO12"
  tree "LDO12"
    tree "LDO12_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_REVISION1 (at 0x14b00)"
      tindex ezaxi:0xfc4cf980 %l 0x814b000 0x14b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO12_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_REVISION2 (at 0x14b01)"
      tindex ezaxi:0xfc4cf980 %l 0x814b010 0x14b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO12_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_REVISION3 (at 0x14b02)"
      tindex ezaxi:0xfc4cf980 %l 0x814b020 0x14b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO12_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_REVISION4 (at 0x14b03)"
      tindex ezaxi:0xfc4cf980 %l 0x814b030 0x14b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO12_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_PERPH_TYPE (at 0x14b04)"
      tindex ezaxi:0xfc4cf980 %l 0x814b040 0x14b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO12_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_PERPH_SUBTYPE (at 0x14b05)"
      tindex ezaxi:0xfc4cf980 %l 0x814b050 0x14b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO12_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_STATUS1 (at 0x14b08)"
      tindex ezaxi:0xfc4cf980 %l 0x814b080 0x14b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO12_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_STATUS2 (at 0x14b09)"
      tindex ezaxi:0xfc4cf980 %l 0x814b090 0x14b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO12_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_STATUS3 (at 0x14b0a)"
      tindex ezaxi:0xfc4cf980 %l 0x814b0a0 0x14b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO12_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_RT_STS (at 0x14b10)"
      tindex ezaxi:0xfc4cf980 %l 0x814b100 0x14b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_SET_TYPE (at 0x14b11)"
      tindex ezaxi:0xfc4cf980 %l 0x814b110 0x14b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_POLARITY_HIGH (at 0x14b12)"
      tindex ezaxi:0xfc4cf980 %l 0x814b120 0x14b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_POLARITY_LOW (at 0x14b13)"
      tindex ezaxi:0xfc4cf980 %l 0x814b130 0x14b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO12_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_LATCHED_CLR (at 0x14b14)"
      tindex ezaxi:0xfc4cf980 %l 0x814b140 0x14b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO12_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_EN_SET (at 0x14b15)"
      tindex ezaxi:0xfc4cf980 %l 0x814b150 0x14b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_EN_CLR (at 0x14b16)"
      tindex ezaxi:0xfc4cf980 %l 0x814b160 0x14b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO12_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_LATCHED_STS (at 0x14b18)"
      tindex ezaxi:0xfc4cf980 %l 0x814b180 0x14b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO12_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_PENDING_STS (at 0x14b19)"
      tindex ezaxi:0xfc4cf980 %l 0x814b190 0x14b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO12_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_MID_SEL (at 0x14b1a)"
      tindex ezaxi:0xfc4cf980 %l 0x814b1a0 0x14b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO12_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_PRIORITY (at 0x14b1b)"
      tindex ezaxi:0xfc4cf980 %l 0x814b1b0 0x14b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO12_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_VOLTAGE_CTL1 (at 0x14b40)"
      tindex ezaxi:0xfc4cf980 %l 0x814b400 0x14b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_VOLTAGE_CTL2 (at 0x14b41)"
      tindex ezaxi:0xfc4cf980 %l 0x814b410 0x14b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO12_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_MODE_CTL2 (at 0x14b45)"
      tindex ezaxi:0xfc4cf980 %l 0x814b450 0x14b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO12_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_EN_CTL (at 0x14b46)"
      tindex ezaxi:0xfc4cf980 %l 0x814b460 0x14b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO12_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_PD_CTL (at 0x14b48)"
      tindex ezaxi:0xfc4cf980 %l 0x814b480 0x14b480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO12_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_CURRENT_LIM_CTL (at 0x14b4a)"
      tindex ezaxi:0xfc4cf980 %l 0x814b4a0 0x14b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO12_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_SOFT_START_CTL (at 0x14b4c)"
      tindex ezaxi:0xfc4cf980 %l 0x814b4c0 0x14b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO12_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_CONFIG_CTL (at 0x14b52)"
      tindex ezaxi:0xfc4cf980 %l 0x814b520 0x14b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_LL_VOLTAGE_CTL1 (at 0x14b68)"
      tindex ezaxi:0xfc4cf980 %l 0x814b680 0x14b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_LL_VOLTAGE_CTL2 (at 0x14b69)"
      tindex ezaxi:0xfc4cf980 %l 0x814b690 0x14b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_UL_VOLTAGE_CTL1 (at 0x14b6a)"
      tindex ezaxi:0xfc4cf980 %l 0x814b6a0 0x14b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_UL_VOLTAGE_CTL2 (at 0x14b6b)"
      tindex ezaxi:0xfc4cf980 %l 0x814b6b0 0x14b6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO12_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_SEC_ACCESS (at 0x14bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x814bd00 0x14bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO12_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_PERPH_RESET_CTL1 (at 0x14bd8)"
      tindex ezaxi:0xfc4cf980 %l 0x814bd80 0x14bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_PERPH_RESET_CTL2 (at 0x14bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x814bd90 0x14bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_PERPH_RESET_CTL3 (at 0x14bda)"
      tindex ezaxi:0xfc4cf980 %l 0x814bda0 0x14bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_PERPH_RESET_CTL4 (at 0x14bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x814bdb0 0x14bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO12_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_TEST1 (at 0x14be0)"
      tindex ezaxi:0xfc4cf980 %l 0x814be00 0x14be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO12_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_INT_TEST_VAL (at 0x14be1)"
      tindex ezaxi:0xfc4cf980 %l 0x814be10 0x14be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO12_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_TEST1 (at 0x14be2)"
      tindex ezaxi:0xfc4cf980 %l 0x814be20 0x14be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO12_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_TEST2 (at 0x14be3)"
      tindex ezaxi:0xfc4cf980 %l 0x814be30 0x14be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO12_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_TRIM_NUM (at 0x14bf0)"
      tindex ezaxi:0xfc4cf980 %l 0x814bf00 0x14bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO12_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO12_TRIM_CTRL (at 0x14bf1)"
      tindex ezaxi:0xfc4cf980 %l 0x814bf10 0x14bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO13"
  tree "LDO13"
    tree "LDO13_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_REVISION1 (at 0x14c00)"
      tindex ezaxi:0xfc4cf980 %l 0x814c000 0x14c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO13_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_REVISION2 (at 0x14c01)"
      tindex ezaxi:0xfc4cf980 %l 0x814c010 0x14c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO13_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_REVISION3 (at 0x14c02)"
      tindex ezaxi:0xfc4cf980 %l 0x814c020 0x14c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO13_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_REVISION4 (at 0x14c03)"
      tindex ezaxi:0xfc4cf980 %l 0x814c030 0x14c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO13_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_PERPH_TYPE (at 0x14c04)"
      tindex ezaxi:0xfc4cf980 %l 0x814c040 0x14c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO13_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_PERPH_SUBTYPE (at 0x14c05)"
      tindex ezaxi:0xfc4cf980 %l 0x814c050 0x14c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO13_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_STATUS1 (at 0x14c08)"
      tindex ezaxi:0xfc4cf980 %l 0x814c080 0x14c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO13_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_STATUS2 (at 0x14c09)"
      tindex ezaxi:0xfc4cf980 %l 0x814c090 0x14c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO13_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_STATUS3 (at 0x14c0a)"
      tindex ezaxi:0xfc4cf980 %l 0x814c0a0 0x14c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO13_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_RT_STS (at 0x14c10)"
      tindex ezaxi:0xfc4cf980 %l 0x814c100 0x14c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_SET_TYPE (at 0x14c11)"
      tindex ezaxi:0xfc4cf980 %l 0x814c110 0x14c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_POLARITY_HIGH (at 0x14c12)"
      tindex ezaxi:0xfc4cf980 %l 0x814c120 0x14c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_POLARITY_LOW (at 0x14c13)"
      tindex ezaxi:0xfc4cf980 %l 0x814c130 0x14c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO13_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_LATCHED_CLR (at 0x14c14)"
      tindex ezaxi:0xfc4cf980 %l 0x814c140 0x14c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO13_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_EN_SET (at 0x14c15)"
      tindex ezaxi:0xfc4cf980 %l 0x814c150 0x14c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_EN_CLR (at 0x14c16)"
      tindex ezaxi:0xfc4cf980 %l 0x814c160 0x14c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO13_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_LATCHED_STS (at 0x14c18)"
      tindex ezaxi:0xfc4cf980 %l 0x814c180 0x14c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO13_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_PENDING_STS (at 0x14c19)"
      tindex ezaxi:0xfc4cf980 %l 0x814c190 0x14c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO13_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_MID_SEL (at 0x14c1a)"
      tindex ezaxi:0xfc4cf980 %l 0x814c1a0 0x14c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO13_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_PRIORITY (at 0x14c1b)"
      tindex ezaxi:0xfc4cf980 %l 0x814c1b0 0x14c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO13_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_VOLTAGE_CTL1 (at 0x14c40)"
      tindex ezaxi:0xfc4cf980 %l 0x814c400 0x14c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_VOLTAGE_CTL2 (at 0x14c41)"
      tindex ezaxi:0xfc4cf980 %l 0x814c410 0x14c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO13_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_MODE_CTL2 (at 0x14c45)"
      tindex ezaxi:0xfc4cf980 %l 0x814c450 0x14c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO13_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_EN_CTL (at 0x14c46)"
      tindex ezaxi:0xfc4cf980 %l 0x814c460 0x14c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO13_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_PD_CTL (at 0x14c48)"
      tindex ezaxi:0xfc4cf980 %l 0x814c480 0x14c480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO13_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_CURRENT_LIM_CTL (at 0x14c4a)"
      tindex ezaxi:0xfc4cf980 %l 0x814c4a0 0x14c4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO13_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_SOFT_START_CTL (at 0x14c4c)"
      tindex ezaxi:0xfc4cf980 %l 0x814c4c0 0x14c4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO13_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_CONFIG_CTL (at 0x14c52)"
      tindex ezaxi:0xfc4cf980 %l 0x814c520 0x14c520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO13_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_LL_VOLTAGE_CTL1 (at 0x14c68)"
      tindex ezaxi:0xfc4cf980 %l 0x814c680 0x14c680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_LL_VOLTAGE_CTL2 (at 0x14c69)"
      tindex ezaxi:0xfc4cf980 %l 0x814c690 0x14c690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO13_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_UL_VOLTAGE_CTL1 (at 0x14c6a)"
      tindex ezaxi:0xfc4cf980 %l 0x814c6a0 0x14c6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_UL_VOLTAGE_CTL2 (at 0x14c6b)"
      tindex ezaxi:0xfc4cf980 %l 0x814c6b0 0x14c6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO13_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_SEC_ACCESS (at 0x14cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x814cd00 0x14cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO13_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_PERPH_RESET_CTL1 (at 0x14cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x814cd80 0x14cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_PERPH_RESET_CTL2 (at 0x14cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x814cd90 0x14cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_PERPH_RESET_CTL3 (at 0x14cda)"
      tindex ezaxi:0xfc4cf980 %l 0x814cda0 0x14cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_PERPH_RESET_CTL4 (at 0x14cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x814cdb0 0x14cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO13_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_TEST1 (at 0x14ce0)"
      tindex ezaxi:0xfc4cf980 %l 0x814ce00 0x14ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO13_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_INT_TEST_VAL (at 0x14ce1)"
      tindex ezaxi:0xfc4cf980 %l 0x814ce10 0x14ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO13_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_TEST1 (at 0x14ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x814ce20 0x14ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO13_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_TEST2 (at 0x14ce3)"
      tindex ezaxi:0xfc4cf980 %l 0x814ce30 0x14ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO13_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_TRIM_NUM (at 0x14cf0)"
      tindex ezaxi:0xfc4cf980 %l 0x814cf00 0x14cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO13_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO13_TRIM_CTRL (at 0x14cf1)"
      tindex ezaxi:0xfc4cf980 %l 0x814cf10 0x14cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO14"
  tree "LDO14"
    tree "LDO14_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_REVISION1 (at 0x14d00)"
      tindex ezaxi:0xfc4cf980 %l 0x814d000 0x14d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO14_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_REVISION2 (at 0x14d01)"
      tindex ezaxi:0xfc4cf980 %l 0x814d010 0x14d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO14_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_REVISION3 (at 0x14d02)"
      tindex ezaxi:0xfc4cf980 %l 0x814d020 0x14d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO14_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_REVISION4 (at 0x14d03)"
      tindex ezaxi:0xfc4cf980 %l 0x814d030 0x14d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO14_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_PERPH_TYPE (at 0x14d04)"
      tindex ezaxi:0xfc4cf980 %l 0x814d040 0x14d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO14_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_PERPH_SUBTYPE (at 0x14d05)"
      tindex ezaxi:0xfc4cf980 %l 0x814d050 0x14d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO14_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_STATUS1 (at 0x14d08)"
      tindex ezaxi:0xfc4cf980 %l 0x814d080 0x14d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO14_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_STATUS2 (at 0x14d09)"
      tindex ezaxi:0xfc4cf980 %l 0x814d090 0x14d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO14_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_STATUS3 (at 0x14d0a)"
      tindex ezaxi:0xfc4cf980 %l 0x814d0a0 0x14d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO14_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_RT_STS (at 0x14d10)"
      tindex ezaxi:0xfc4cf980 %l 0x814d100 0x14d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_SET_TYPE (at 0x14d11)"
      tindex ezaxi:0xfc4cf980 %l 0x814d110 0x14d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_POLARITY_HIGH (at 0x14d12)"
      tindex ezaxi:0xfc4cf980 %l 0x814d120 0x14d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO14_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_POLARITY_LOW (at 0x14d13)"
      tindex ezaxi:0xfc4cf980 %l 0x814d130 0x14d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO14_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_LATCHED_CLR (at 0x14d14)"
      tindex ezaxi:0xfc4cf980 %l 0x814d140 0x14d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO14_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_EN_SET (at 0x14d15)"
      tindex ezaxi:0xfc4cf980 %l 0x814d150 0x14d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_EN_CLR (at 0x14d16)"
      tindex ezaxi:0xfc4cf980 %l 0x814d160 0x14d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO14_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_LATCHED_STS (at 0x14d18)"
      tindex ezaxi:0xfc4cf980 %l 0x814d180 0x14d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO14_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_PENDING_STS (at 0x14d19)"
      tindex ezaxi:0xfc4cf980 %l 0x814d190 0x14d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO14_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_MID_SEL (at 0x14d1a)"
      tindex ezaxi:0xfc4cf980 %l 0x814d1a0 0x14d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO14_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_PRIORITY (at 0x14d1b)"
      tindex ezaxi:0xfc4cf980 %l 0x814d1b0 0x14d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO14_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_VOLTAGE_CTL1 (at 0x14d40)"
      tindex ezaxi:0xfc4cf980 %l 0x814d400 0x14d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_VOLTAGE_CTL2 (at 0x14d41)"
      tindex ezaxi:0xfc4cf980 %l 0x814d410 0x14d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO14_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_MODE_CTL2 (at 0x14d45)"
      tindex ezaxi:0xfc4cf980 %l 0x814d450 0x14d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO14_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_EN_CTL (at 0x14d46)"
      tindex ezaxi:0xfc4cf980 %l 0x814d460 0x14d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO14_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_PD_CTL (at 0x14d48)"
      tindex ezaxi:0xfc4cf980 %l 0x814d480 0x14d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO14_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_CURRENT_LIM_CTL (at 0x14d4a)"
      tindex ezaxi:0xfc4cf980 %l 0x814d4a0 0x14d4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO14_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_SOFT_START_CTL (at 0x14d4c)"
      tindex ezaxi:0xfc4cf980 %l 0x814d4c0 0x14d4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO14_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_CONFIG_CTL (at 0x14d52)"
      tindex ezaxi:0xfc4cf980 %l 0x814d520 0x14d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_LL_VOLTAGE_CTL1 (at 0x14d68)"
      tindex ezaxi:0xfc4cf980 %l 0x814d680 0x14d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_LL_VOLTAGE_CTL2 (at 0x14d69)"
      tindex ezaxi:0xfc4cf980 %l 0x814d690 0x14d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_UL_VOLTAGE_CTL1 (at 0x14d6a)"
      tindex ezaxi:0xfc4cf980 %l 0x814d6a0 0x14d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_UL_VOLTAGE_CTL2 (at 0x14d6b)"
      tindex ezaxi:0xfc4cf980 %l 0x814d6b0 0x14d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO14_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_SEC_ACCESS (at 0x14dd0)"
      tindex ezaxi:0xfc4cf980 %l 0x814dd00 0x14dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO14_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_PERPH_RESET_CTL1 (at 0x14dd8)"
      tindex ezaxi:0xfc4cf980 %l 0x814dd80 0x14dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_PERPH_RESET_CTL2 (at 0x14dd9)"
      tindex ezaxi:0xfc4cf980 %l 0x814dd90 0x14dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_PERPH_RESET_CTL3 (at 0x14dda)"
      tindex ezaxi:0xfc4cf980 %l 0x814dda0 0x14dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO14_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_PERPH_RESET_CTL4 (at 0x14ddb)"
      tindex ezaxi:0xfc4cf980 %l 0x814ddb0 0x14ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO14_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_TEST1 (at 0x14de0)"
      tindex ezaxi:0xfc4cf980 %l 0x814de00 0x14de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO14_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_INT_TEST_VAL (at 0x14de1)"
      tindex ezaxi:0xfc4cf980 %l 0x814de10 0x14de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO14_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_TEST1 (at 0x14de2)"
      tindex ezaxi:0xfc4cf980 %l 0x814de20 0x14de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO14_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_TEST2 (at 0x14de3)"
      tindex ezaxi:0xfc4cf980 %l 0x814de30 0x14de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO14_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_TRIM_NUM (at 0x14df0)"
      tindex ezaxi:0xfc4cf980 %l 0x814df00 0x14df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO14_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO14_TRIM_CTRL (at 0x14df1)"
      tindex ezaxi:0xfc4cf980 %l 0x814df10 0x14df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO15"
  tree "LDO15"
    tree "LDO15_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_REVISION1 (at 0x14e00)"
      tindex ezaxi:0xfc4cf980 %l 0x814e000 0x14e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO15_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_REVISION2 (at 0x14e01)"
      tindex ezaxi:0xfc4cf980 %l 0x814e010 0x14e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO15_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_REVISION3 (at 0x14e02)"
      tindex ezaxi:0xfc4cf980 %l 0x814e020 0x14e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO15_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_REVISION4 (at 0x14e03)"
      tindex ezaxi:0xfc4cf980 %l 0x814e030 0x14e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO15_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_PERPH_TYPE (at 0x14e04)"
      tindex ezaxi:0xfc4cf980 %l 0x814e040 0x14e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO15_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_PERPH_SUBTYPE (at 0x14e05)"
      tindex ezaxi:0xfc4cf980 %l 0x814e050 0x14e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO15_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_STATUS1 (at 0x14e08)"
      tindex ezaxi:0xfc4cf980 %l 0x814e080 0x14e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO15_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_STATUS2 (at 0x14e09)"
      tindex ezaxi:0xfc4cf980 %l 0x814e090 0x14e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO15_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_STATUS3 (at 0x14e0a)"
      tindex ezaxi:0xfc4cf980 %l 0x814e0a0 0x14e0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO15_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_RT_STS (at 0x14e10)"
      tindex ezaxi:0xfc4cf980 %l 0x814e100 0x14e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_SET_TYPE (at 0x14e11)"
      tindex ezaxi:0xfc4cf980 %l 0x814e110 0x14e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_POLARITY_HIGH (at 0x14e12)"
      tindex ezaxi:0xfc4cf980 %l 0x814e120 0x14e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO15_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_POLARITY_LOW (at 0x14e13)"
      tindex ezaxi:0xfc4cf980 %l 0x814e130 0x14e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO15_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_LATCHED_CLR (at 0x14e14)"
      tindex ezaxi:0xfc4cf980 %l 0x814e140 0x14e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO15_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_EN_SET (at 0x14e15)"
      tindex ezaxi:0xfc4cf980 %l 0x814e150 0x14e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_EN_CLR (at 0x14e16)"
      tindex ezaxi:0xfc4cf980 %l 0x814e160 0x14e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO15_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_LATCHED_STS (at 0x14e18)"
      tindex ezaxi:0xfc4cf980 %l 0x814e180 0x14e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO15_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_PENDING_STS (at 0x14e19)"
      tindex ezaxi:0xfc4cf980 %l 0x814e190 0x14e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO15_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_MID_SEL (at 0x14e1a)"
      tindex ezaxi:0xfc4cf980 %l 0x814e1a0 0x14e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO15_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_PRIORITY (at 0x14e1b)"
      tindex ezaxi:0xfc4cf980 %l 0x814e1b0 0x14e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO15_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_VOLTAGE_CTL1 (at 0x14e40)"
      tindex ezaxi:0xfc4cf980 %l 0x814e400 0x14e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_VOLTAGE_CTL2 (at 0x14e41)"
      tindex ezaxi:0xfc4cf980 %l 0x814e410 0x14e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO15_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_MODE_CTL2 (at 0x14e45)"
      tindex ezaxi:0xfc4cf980 %l 0x814e450 0x14e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO15_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_EN_CTL (at 0x14e46)"
      tindex ezaxi:0xfc4cf980 %l 0x814e460 0x14e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO15_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_PD_CTL (at 0x14e48)"
      tindex ezaxi:0xfc4cf980 %l 0x814e480 0x14e480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO15_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_CURRENT_LIM_CTL (at 0x14e4a)"
      tindex ezaxi:0xfc4cf980 %l 0x814e4a0 0x14e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO15_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_SOFT_START_CTL (at 0x14e4c)"
      tindex ezaxi:0xfc4cf980 %l 0x814e4c0 0x14e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO15_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_CONFIG_CTL (at 0x14e52)"
      tindex ezaxi:0xfc4cf980 %l 0x814e520 0x14e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_LL_VOLTAGE_CTL1 (at 0x14e68)"
      tindex ezaxi:0xfc4cf980 %l 0x814e680 0x14e680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_LL_VOLTAGE_CTL2 (at 0x14e69)"
      tindex ezaxi:0xfc4cf980 %l 0x814e690 0x14e690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_UL_VOLTAGE_CTL1 (at 0x14e6a)"
      tindex ezaxi:0xfc4cf980 %l 0x814e6a0 0x14e6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_UL_VOLTAGE_CTL2 (at 0x14e6b)"
      tindex ezaxi:0xfc4cf980 %l 0x814e6b0 0x14e6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO15_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_SEC_ACCESS (at 0x14ed0)"
      tindex ezaxi:0xfc4cf980 %l 0x814ed00 0x14ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO15_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_PERPH_RESET_CTL1 (at 0x14ed8)"
      tindex ezaxi:0xfc4cf980 %l 0x814ed80 0x14ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_PERPH_RESET_CTL2 (at 0x14ed9)"
      tindex ezaxi:0xfc4cf980 %l 0x814ed90 0x14ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_PERPH_RESET_CTL3 (at 0x14eda)"
      tindex ezaxi:0xfc4cf980 %l 0x814eda0 0x14eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO15_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_PERPH_RESET_CTL4 (at 0x14edb)"
      tindex ezaxi:0xfc4cf980 %l 0x814edb0 0x14edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO15_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_TEST1 (at 0x14ee0)"
      tindex ezaxi:0xfc4cf980 %l 0x814ee00 0x14ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO15_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_INT_TEST_VAL (at 0x14ee1)"
      tindex ezaxi:0xfc4cf980 %l 0x814ee10 0x14ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO15_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_TEST1 (at 0x14ee2)"
      tindex ezaxi:0xfc4cf980 %l 0x814ee20 0x14ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO15_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_TEST2 (at 0x14ee3)"
      tindex ezaxi:0xfc4cf980 %l 0x814ee30 0x14ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO15_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_TRIM_NUM (at 0x14ef0)"
      tindex ezaxi:0xfc4cf980 %l 0x814ef00 0x14ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO15_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO15_TRIM_CTRL (at 0x14ef1)"
      tindex ezaxi:0xfc4cf980 %l 0x814ef10 0x14ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO16"
  tree "LDO16"
    tree "LDO16_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_REVISION1 (at 0x14f00)"
      tindex ezaxi:0xfc4cf980 %l 0x814f000 0x14f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO16_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_REVISION2 (at 0x14f01)"
      tindex ezaxi:0xfc4cf980 %l 0x814f010 0x14f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO16_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_REVISION3 (at 0x14f02)"
      tindex ezaxi:0xfc4cf980 %l 0x814f020 0x14f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO16_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_REVISION4 (at 0x14f03)"
      tindex ezaxi:0xfc4cf980 %l 0x814f030 0x14f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO16_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_PERPH_TYPE (at 0x14f04)"
      tindex ezaxi:0xfc4cf980 %l 0x814f040 0x14f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO16_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_PERPH_SUBTYPE (at 0x14f05)"
      tindex ezaxi:0xfc4cf980 %l 0x814f050 0x14f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO16_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_STATUS1 (at 0x14f08)"
      tindex ezaxi:0xfc4cf980 %l 0x814f080 0x14f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO16_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_STATUS2 (at 0x14f09)"
      tindex ezaxi:0xfc4cf980 %l 0x814f090 0x14f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO16_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_STATUS3 (at 0x14f0a)"
      tindex ezaxi:0xfc4cf980 %l 0x814f0a0 0x14f0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO16_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_RT_STS (at 0x14f10)"
      tindex ezaxi:0xfc4cf980 %l 0x814f100 0x14f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_SET_TYPE (at 0x14f11)"
      tindex ezaxi:0xfc4cf980 %l 0x814f110 0x14f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_POLARITY_HIGH (at 0x14f12)"
      tindex ezaxi:0xfc4cf980 %l 0x814f120 0x14f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO16_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_POLARITY_LOW (at 0x14f13)"
      tindex ezaxi:0xfc4cf980 %l 0x814f130 0x14f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO16_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_LATCHED_CLR (at 0x14f14)"
      tindex ezaxi:0xfc4cf980 %l 0x814f140 0x14f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO16_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_EN_SET (at 0x14f15)"
      tindex ezaxi:0xfc4cf980 %l 0x814f150 0x14f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_EN_CLR (at 0x14f16)"
      tindex ezaxi:0xfc4cf980 %l 0x814f160 0x14f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO16_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_LATCHED_STS (at 0x14f18)"
      tindex ezaxi:0xfc4cf980 %l 0x814f180 0x14f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO16_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_PENDING_STS (at 0x14f19)"
      tindex ezaxi:0xfc4cf980 %l 0x814f190 0x14f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO16_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_MID_SEL (at 0x14f1a)"
      tindex ezaxi:0xfc4cf980 %l 0x814f1a0 0x14f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO16_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_PRIORITY (at 0x14f1b)"
      tindex ezaxi:0xfc4cf980 %l 0x814f1b0 0x14f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO16_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_VOLTAGE_CTL1 (at 0x14f40)"
      tindex ezaxi:0xfc4cf980 %l 0x814f400 0x14f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_VOLTAGE_CTL2 (at 0x14f41)"
      tindex ezaxi:0xfc4cf980 %l 0x814f410 0x14f410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO16_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_MODE_CTL2 (at 0x14f45)"
      tindex ezaxi:0xfc4cf980 %l 0x814f450 0x14f450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO16_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_EN_CTL (at 0x14f46)"
      tindex ezaxi:0xfc4cf980 %l 0x814f460 0x14f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO16_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_PD_CTL (at 0x14f48)"
      tindex ezaxi:0xfc4cf980 %l 0x814f480 0x14f480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO16_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_CURRENT_LIM_CTL (at 0x14f4a)"
      tindex ezaxi:0xfc4cf980 %l 0x814f4a0 0x14f4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO16_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_SOFT_START_CTL (at 0x14f4c)"
      tindex ezaxi:0xfc4cf980 %l 0x814f4c0 0x14f4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO16_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_CONFIG_CTL (at 0x14f52)"
      tindex ezaxi:0xfc4cf980 %l 0x814f520 0x14f520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_LL_VOLTAGE_CTL1 (at 0x14f68)"
      tindex ezaxi:0xfc4cf980 %l 0x814f680 0x14f680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_LL_VOLTAGE_CTL2 (at 0x14f69)"
      tindex ezaxi:0xfc4cf980 %l 0x814f690 0x14f690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_UL_VOLTAGE_CTL1 (at 0x14f6a)"
      tindex ezaxi:0xfc4cf980 %l 0x814f6a0 0x14f6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_UL_VOLTAGE_CTL2 (at 0x14f6b)"
      tindex ezaxi:0xfc4cf980 %l 0x814f6b0 0x14f6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO16_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_SEC_ACCESS (at 0x14fd0)"
      tindex ezaxi:0xfc4cf980 %l 0x814fd00 0x14fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO16_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_PERPH_RESET_CTL1 (at 0x14fd8)"
      tindex ezaxi:0xfc4cf980 %l 0x814fd80 0x14fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_PERPH_RESET_CTL2 (at 0x14fd9)"
      tindex ezaxi:0xfc4cf980 %l 0x814fd90 0x14fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_PERPH_RESET_CTL3 (at 0x14fda)"
      tindex ezaxi:0xfc4cf980 %l 0x814fda0 0x14fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO16_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_PERPH_RESET_CTL4 (at 0x14fdb)"
      tindex ezaxi:0xfc4cf980 %l 0x814fdb0 0x14fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO16_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_TEST1 (at 0x14fe0)"
      tindex ezaxi:0xfc4cf980 %l 0x814fe00 0x14fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO16_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_INT_TEST_VAL (at 0x14fe1)"
      tindex ezaxi:0xfc4cf980 %l 0x814fe10 0x14fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO16_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_TEST1 (at 0x14fe2)"
      tindex ezaxi:0xfc4cf980 %l 0x814fe20 0x14fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO16_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_TEST2 (at 0x14fe3)"
      tindex ezaxi:0xfc4cf980 %l 0x814fe30 0x14fe30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO16_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_TRIM_NUM (at 0x14ff0)"
      tindex ezaxi:0xfc4cf980 %l 0x814ff00 0x14ff00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO16_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO16_TRIM_CTRL (at 0x14ff1)"
      tindex ezaxi:0xfc4cf980 %l 0x814ff10 0x14ff10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO17"
  tree "LDO17"
    tree "LDO17_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_REVISION1 (at 0x15000)"
      tindex ezaxi:0xfc4cf980 %l 0x8150000 0x150000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO17_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_REVISION2 (at 0x15001)"
      tindex ezaxi:0xfc4cf980 %l 0x8150010 0x150010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO17_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_REVISION3 (at 0x15002)"
      tindex ezaxi:0xfc4cf980 %l 0x8150020 0x150020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO17_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_REVISION4 (at 0x15003)"
      tindex ezaxi:0xfc4cf980 %l 0x8150030 0x150030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO17_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_PERPH_TYPE (at 0x15004)"
      tindex ezaxi:0xfc4cf980 %l 0x8150040 0x150040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO17_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_PERPH_SUBTYPE (at 0x15005)"
      tindex ezaxi:0xfc4cf980 %l 0x8150050 0x150050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO17_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_STATUS1 (at 0x15008)"
      tindex ezaxi:0xfc4cf980 %l 0x8150080 0x150080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO17_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_STATUS2 (at 0x15009)"
      tindex ezaxi:0xfc4cf980 %l 0x8150090 0x150090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO17_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_STATUS3 (at 0x1500a)"
      tindex ezaxi:0xfc4cf980 %l 0x81500a0 0x1500a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO17_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_RT_STS (at 0x15010)"
      tindex ezaxi:0xfc4cf980 %l 0x8150100 0x150100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO17_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_SET_TYPE (at 0x15011)"
      tindex ezaxi:0xfc4cf980 %l 0x8150110 0x150110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO17_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_POLARITY_HIGH (at 0x15012)"
      tindex ezaxi:0xfc4cf980 %l 0x8150120 0x150120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO17_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_POLARITY_LOW (at 0x15013)"
      tindex ezaxi:0xfc4cf980 %l 0x8150130 0x150130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO17_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_LATCHED_CLR (at 0x15014)"
      tindex ezaxi:0xfc4cf980 %l 0x8150140 0x150140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO17_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_EN_SET (at 0x15015)"
      tindex ezaxi:0xfc4cf980 %l 0x8150150 0x150150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO17_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_EN_CLR (at 0x15016)"
      tindex ezaxi:0xfc4cf980 %l 0x8150160 0x150160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO17_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_LATCHED_STS (at 0x15018)"
      tindex ezaxi:0xfc4cf980 %l 0x8150180 0x150180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO17_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_PENDING_STS (at 0x15019)"
      tindex ezaxi:0xfc4cf980 %l 0x8150190 0x150190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO17_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_MID_SEL (at 0x1501a)"
      tindex ezaxi:0xfc4cf980 %l 0x81501a0 0x1501a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO17_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_PRIORITY (at 0x1501b)"
      tindex ezaxi:0xfc4cf980 %l 0x81501b0 0x1501b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO17_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_VOLTAGE_CTL1 (at 0x15040)"
      tindex ezaxi:0xfc4cf980 %l 0x8150400 0x150400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO17_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_VOLTAGE_CTL2 (at 0x15041)"
      tindex ezaxi:0xfc4cf980 %l 0x8150410 0x150410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO17_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_MODE_CTL2 (at 0x15045)"
      tindex ezaxi:0xfc4cf980 %l 0x8150450 0x150450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO17_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_EN_CTL (at 0x15046)"
      tindex ezaxi:0xfc4cf980 %l 0x8150460 0x150460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO17_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_PD_CTL (at 0x15048)"
      tindex ezaxi:0xfc4cf980 %l 0x8150480 0x150480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO17_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_CURRENT_LIM_CTL (at 0x1504a)"
      tindex ezaxi:0xfc4cf980 %l 0x81504a0 0x1504a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO17_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_SOFT_START_CTL (at 0x1504c)"
      tindex ezaxi:0xfc4cf980 %l 0x81504c0 0x1504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO17_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_CONFIG_CTL (at 0x15052)"
      tindex ezaxi:0xfc4cf980 %l 0x8150520 0x150520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO17_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_LL_VOLTAGE_CTL1 (at 0x15068)"
      tindex ezaxi:0xfc4cf980 %l 0x8150680 0x150680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO17_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_LL_VOLTAGE_CTL2 (at 0x15069)"
      tindex ezaxi:0xfc4cf980 %l 0x8150690 0x150690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO17_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_UL_VOLTAGE_CTL1 (at 0x1506a)"
      tindex ezaxi:0xfc4cf980 %l 0x81506a0 0x1506a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO17_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_UL_VOLTAGE_CTL2 (at 0x1506b)"
      tindex ezaxi:0xfc4cf980 %l 0x81506b0 0x1506b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO17_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_SEC_ACCESS (at 0x150d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8150d00 0x150d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO17_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_PERPH_RESET_CTL1 (at 0x150d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8150d80 0x150d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO17_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_PERPH_RESET_CTL2 (at 0x150d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8150d90 0x150d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO17_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_PERPH_RESET_CTL3 (at 0x150da)"
      tindex ezaxi:0xfc4cf980 %l 0x8150da0 0x150da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO17_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_PERPH_RESET_CTL4 (at 0x150db)"
      tindex ezaxi:0xfc4cf980 %l 0x8150db0 0x150db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO17_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_TEST1 (at 0x150e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8150e00 0x150e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO17_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_INT_TEST_VAL (at 0x150e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8150e10 0x150e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO17_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_TEST1 (at 0x150e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8150e20 0x150e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO17_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_TEST2 (at 0x150e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8150e30 0x150e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO17_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_TRIM_NUM (at 0x150f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8150f00 0x150f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO17_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO17_TRIM_CTRL (at 0x150f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8150f10 0x150f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO18"
  tree "LDO18"
    tree "LDO18_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_REVISION1 (at 0x15100)"
      tindex ezaxi:0xfc4cf980 %l 0x8151000 0x151000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO18_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_REVISION2 (at 0x15101)"
      tindex ezaxi:0xfc4cf980 %l 0x8151010 0x151010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO18_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_REVISION3 (at 0x15102)"
      tindex ezaxi:0xfc4cf980 %l 0x8151020 0x151020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO18_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_REVISION4 (at 0x15103)"
      tindex ezaxi:0xfc4cf980 %l 0x8151030 0x151030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO18_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_PERPH_TYPE (at 0x15104)"
      tindex ezaxi:0xfc4cf980 %l 0x8151040 0x151040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO18_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_PERPH_SUBTYPE (at 0x15105)"
      tindex ezaxi:0xfc4cf980 %l 0x8151050 0x151050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO18_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_STATUS1 (at 0x15108)"
      tindex ezaxi:0xfc4cf980 %l 0x8151080 0x151080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO18_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_STATUS2 (at 0x15109)"
      tindex ezaxi:0xfc4cf980 %l 0x8151090 0x151090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO18_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_STATUS3 (at 0x1510a)"
      tindex ezaxi:0xfc4cf980 %l 0x81510a0 0x1510a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO18_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_RT_STS (at 0x15110)"
      tindex ezaxi:0xfc4cf980 %l 0x8151100 0x151100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO18_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_SET_TYPE (at 0x15111)"
      tindex ezaxi:0xfc4cf980 %l 0x8151110 0x151110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO18_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_POLARITY_HIGH (at 0x15112)"
      tindex ezaxi:0xfc4cf980 %l 0x8151120 0x151120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO18_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_POLARITY_LOW (at 0x15113)"
      tindex ezaxi:0xfc4cf980 %l 0x8151130 0x151130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO18_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_LATCHED_CLR (at 0x15114)"
      tindex ezaxi:0xfc4cf980 %l 0x8151140 0x151140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO18_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_EN_SET (at 0x15115)"
      tindex ezaxi:0xfc4cf980 %l 0x8151150 0x151150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO18_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_EN_CLR (at 0x15116)"
      tindex ezaxi:0xfc4cf980 %l 0x8151160 0x151160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO18_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_LATCHED_STS (at 0x15118)"
      tindex ezaxi:0xfc4cf980 %l 0x8151180 0x151180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO18_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_PENDING_STS (at 0x15119)"
      tindex ezaxi:0xfc4cf980 %l 0x8151190 0x151190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO18_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_MID_SEL (at 0x1511a)"
      tindex ezaxi:0xfc4cf980 %l 0x81511a0 0x1511a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO18_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_PRIORITY (at 0x1511b)"
      tindex ezaxi:0xfc4cf980 %l 0x81511b0 0x1511b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO18_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_VOLTAGE_CTL1 (at 0x15140)"
      tindex ezaxi:0xfc4cf980 %l 0x8151400 0x151400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO18_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_VOLTAGE_CTL2 (at 0x15141)"
      tindex ezaxi:0xfc4cf980 %l 0x8151410 0x151410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO18_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_MODE_CTL2 (at 0x15145)"
      tindex ezaxi:0xfc4cf980 %l 0x8151450 0x151450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO18_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_EN_CTL (at 0x15146)"
      tindex ezaxi:0xfc4cf980 %l 0x8151460 0x151460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO18_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_PD_CTL (at 0x15148)"
      tindex ezaxi:0xfc4cf980 %l 0x8151480 0x151480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO18_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_CURRENT_LIM_CTL (at 0x1514a)"
      tindex ezaxi:0xfc4cf980 %l 0x81514a0 0x1514a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO18_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_SOFT_START_CTL (at 0x1514c)"
      tindex ezaxi:0xfc4cf980 %l 0x81514c0 0x1514c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO18_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_CONFIG_CTL (at 0x15152)"
      tindex ezaxi:0xfc4cf980 %l 0x8151520 0x151520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO18_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_LL_VOLTAGE_CTL1 (at 0x15168)"
      tindex ezaxi:0xfc4cf980 %l 0x8151680 0x151680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO18_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_LL_VOLTAGE_CTL2 (at 0x15169)"
      tindex ezaxi:0xfc4cf980 %l 0x8151690 0x151690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO18_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_UL_VOLTAGE_CTL1 (at 0x1516a)"
      tindex ezaxi:0xfc4cf980 %l 0x81516a0 0x1516a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO18_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_UL_VOLTAGE_CTL2 (at 0x1516b)"
      tindex ezaxi:0xfc4cf980 %l 0x81516b0 0x1516b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO18_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_SEC_ACCESS (at 0x151d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8151d00 0x151d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO18_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_PERPH_RESET_CTL1 (at 0x151d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8151d80 0x151d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO18_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_PERPH_RESET_CTL2 (at 0x151d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8151d90 0x151d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO18_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_PERPH_RESET_CTL3 (at 0x151da)"
      tindex ezaxi:0xfc4cf980 %l 0x8151da0 0x151da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO18_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_PERPH_RESET_CTL4 (at 0x151db)"
      tindex ezaxi:0xfc4cf980 %l 0x8151db0 0x151db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO18_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_TEST1 (at 0x151e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8151e00 0x151e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO18_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_INT_TEST_VAL (at 0x151e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8151e10 0x151e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO18_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_TEST1 (at 0x151e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8151e20 0x151e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO18_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_TEST2 (at 0x151e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8151e30 0x151e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO18_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_TRIM_NUM (at 0x151f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8151f00 0x151f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO18_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO18_TRIM_CTRL (at 0x151f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8151f10 0x151f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO19"
  tree "LDO19"
    tree "LDO19_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_REVISION1 (at 0x15200)"
      tindex ezaxi:0xfc4cf980 %l 0x8152000 0x152000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO19_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_REVISION2 (at 0x15201)"
      tindex ezaxi:0xfc4cf980 %l 0x8152010 0x152010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO19_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_REVISION3 (at 0x15202)"
      tindex ezaxi:0xfc4cf980 %l 0x8152020 0x152020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO19_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_REVISION4 (at 0x15203)"
      tindex ezaxi:0xfc4cf980 %l 0x8152030 0x152030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO19_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_PERPH_TYPE (at 0x15204)"
      tindex ezaxi:0xfc4cf980 %l 0x8152040 0x152040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO19_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_PERPH_SUBTYPE (at 0x15205)"
      tindex ezaxi:0xfc4cf980 %l 0x8152050 0x152050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO19_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_STATUS1 (at 0x15208)"
      tindex ezaxi:0xfc4cf980 %l 0x8152080 0x152080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO19_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_STATUS2 (at 0x15209)"
      tindex ezaxi:0xfc4cf980 %l 0x8152090 0x152090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO19_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_STATUS3 (at 0x1520a)"
      tindex ezaxi:0xfc4cf980 %l 0x81520a0 0x1520a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO19_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_RT_STS (at 0x15210)"
      tindex ezaxi:0xfc4cf980 %l 0x8152100 0x152100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO19_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_SET_TYPE (at 0x15211)"
      tindex ezaxi:0xfc4cf980 %l 0x8152110 0x152110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO19_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_POLARITY_HIGH (at 0x15212)"
      tindex ezaxi:0xfc4cf980 %l 0x8152120 0x152120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO19_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_POLARITY_LOW (at 0x15213)"
      tindex ezaxi:0xfc4cf980 %l 0x8152130 0x152130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO19_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_LATCHED_CLR (at 0x15214)"
      tindex ezaxi:0xfc4cf980 %l 0x8152140 0x152140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO19_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_EN_SET (at 0x15215)"
      tindex ezaxi:0xfc4cf980 %l 0x8152150 0x152150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO19_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_EN_CLR (at 0x15216)"
      tindex ezaxi:0xfc4cf980 %l 0x8152160 0x152160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO19_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_LATCHED_STS (at 0x15218)"
      tindex ezaxi:0xfc4cf980 %l 0x8152180 0x152180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO19_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_PENDING_STS (at 0x15219)"
      tindex ezaxi:0xfc4cf980 %l 0x8152190 0x152190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO19_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_MID_SEL (at 0x1521a)"
      tindex ezaxi:0xfc4cf980 %l 0x81521a0 0x1521a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO19_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_PRIORITY (at 0x1521b)"
      tindex ezaxi:0xfc4cf980 %l 0x81521b0 0x1521b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO19_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_VOLTAGE_CTL1 (at 0x15240)"
      tindex ezaxi:0xfc4cf980 %l 0x8152400 0x152400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO19_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_VOLTAGE_CTL2 (at 0x15241)"
      tindex ezaxi:0xfc4cf980 %l 0x8152410 0x152410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO19_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_MODE_CTL2 (at 0x15245)"
      tindex ezaxi:0xfc4cf980 %l 0x8152450 0x152450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO19_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_EN_CTL (at 0x15246)"
      tindex ezaxi:0xfc4cf980 %l 0x8152460 0x152460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO19_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_PD_CTL (at 0x15248)"
      tindex ezaxi:0xfc4cf980 %l 0x8152480 0x152480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO19_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_CURRENT_LIM_CTL (at 0x1524a)"
      tindex ezaxi:0xfc4cf980 %l 0x81524a0 0x1524a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO19_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_SOFT_START_CTL (at 0x1524c)"
      tindex ezaxi:0xfc4cf980 %l 0x81524c0 0x1524c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO19_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_CONFIG_CTL (at 0x15252)"
      tindex ezaxi:0xfc4cf980 %l 0x8152520 0x152520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO19_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_LL_VOLTAGE_CTL1 (at 0x15268)"
      tindex ezaxi:0xfc4cf980 %l 0x8152680 0x152680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO19_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_LL_VOLTAGE_CTL2 (at 0x15269)"
      tindex ezaxi:0xfc4cf980 %l 0x8152690 0x152690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO19_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_UL_VOLTAGE_CTL1 (at 0x1526a)"
      tindex ezaxi:0xfc4cf980 %l 0x81526a0 0x1526a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO19_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_UL_VOLTAGE_CTL2 (at 0x1526b)"
      tindex ezaxi:0xfc4cf980 %l 0x81526b0 0x1526b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO19_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_SEC_ACCESS (at 0x152d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8152d00 0x152d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO19_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_PERPH_RESET_CTL1 (at 0x152d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8152d80 0x152d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO19_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_PERPH_RESET_CTL2 (at 0x152d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8152d90 0x152d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO19_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_PERPH_RESET_CTL3 (at 0x152da)"
      tindex ezaxi:0xfc4cf980 %l 0x8152da0 0x152da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO19_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_PERPH_RESET_CTL4 (at 0x152db)"
      tindex ezaxi:0xfc4cf980 %l 0x8152db0 0x152db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO19_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_TEST1 (at 0x152e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8152e00 0x152e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO19_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_INT_TEST_VAL (at 0x152e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8152e10 0x152e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO19_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_TEST1 (at 0x152e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8152e20 0x152e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO19_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_TEST2 (at 0x152e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8152e30 0x152e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO19_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_TRIM_NUM (at 0x152f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8152f00 0x152f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO19_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO19_TRIM_CTRL (at 0x152f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8152f10 0x152f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO2"
  tree "LDO2"
    tree "LDO2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_REVISION1 (at 0x14100)"
      tindex ezaxi:0xfc4cf980 %l 0x8141000 0x141000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_REVISION2 (at 0x14101)"
      tindex ezaxi:0xfc4cf980 %l 0x8141010 0x141010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_REVISION3 (at 0x14102)"
      tindex ezaxi:0xfc4cf980 %l 0x8141020 0x141020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_REVISION4 (at 0x14103)"
      tindex ezaxi:0xfc4cf980 %l 0x8141030 0x141030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_PERPH_TYPE (at 0x14104)"
      tindex ezaxi:0xfc4cf980 %l 0x8141040 0x141040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_PERPH_SUBTYPE (at 0x14105)"
      tindex ezaxi:0xfc4cf980 %l 0x8141050 0x141050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_STATUS1 (at 0x14108)"
      tindex ezaxi:0xfc4cf980 %l 0x8141080 0x141080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO2_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_STATUS2 (at 0x14109)"
      tindex ezaxi:0xfc4cf980 %l 0x8141090 0x141090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO2_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_STATUS3 (at 0x1410a)"
      tindex ezaxi:0xfc4cf980 %l 0x81410a0 0x1410a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_RT_STS (at 0x14110)"
      tindex ezaxi:0xfc4cf980 %l 0x8141100 0x141100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_SET_TYPE (at 0x14111)"
      tindex ezaxi:0xfc4cf980 %l 0x8141110 0x141110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_POLARITY_HIGH (at 0x14112)"
      tindex ezaxi:0xfc4cf980 %l 0x8141120 0x141120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_POLARITY_LOW (at 0x14113)"
      tindex ezaxi:0xfc4cf980 %l 0x8141130 0x141130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_LATCHED_CLR (at 0x14114)"
      tindex ezaxi:0xfc4cf980 %l 0x8141140 0x141140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_EN_SET (at 0x14115)"
      tindex ezaxi:0xfc4cf980 %l 0x8141150 0x141150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_EN_CLR (at 0x14116)"
      tindex ezaxi:0xfc4cf980 %l 0x8141160 0x141160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_LATCHED_STS (at 0x14118)"
      tindex ezaxi:0xfc4cf980 %l 0x8141180 0x141180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_PENDING_STS (at 0x14119)"
      tindex ezaxi:0xfc4cf980 %l 0x8141190 0x141190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_MID_SEL (at 0x1411a)"
      tindex ezaxi:0xfc4cf980 %l 0x81411a0 0x1411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_PRIORITY (at 0x1411b)"
      tindex ezaxi:0xfc4cf980 %l 0x81411b0 0x1411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO2_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_VOLTAGE_CTL1 (at 0x14140)"
      tindex ezaxi:0xfc4cf980 %l 0x8141400 0x141400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_VOLTAGE_CTL2 (at 0x14141)"
      tindex ezaxi:0xfc4cf980 %l 0x8141410 0x141410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO2_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_MODE_CTL2 (at 0x14145)"
      tindex ezaxi:0xfc4cf980 %l 0x8141450 0x141450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_EN_CTL (at 0x14146)"
      tindex ezaxi:0xfc4cf980 %l 0x8141460 0x141460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO2_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_PD_CTL (at 0x14148)"
      tindex ezaxi:0xfc4cf980 %l 0x8141480 0x141480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO2_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_CURRENT_LIM_CTL (at 0x1414a)"
      tindex ezaxi:0xfc4cf980 %l 0x81414a0 0x1414a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO2_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_SOFT_START_CTL (at 0x1414c)"
      tindex ezaxi:0xfc4cf980 %l 0x81414c0 0x1414c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO2_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_CONFIG_CTL (at 0x14152)"
      tindex ezaxi:0xfc4cf980 %l 0x8141520 0x141520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_LL_VOLTAGE_CTL1 (at 0x14168)"
      tindex ezaxi:0xfc4cf980 %l 0x8141680 0x141680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_LL_VOLTAGE_CTL2 (at 0x14169)"
      tindex ezaxi:0xfc4cf980 %l 0x8141690 0x141690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_UL_VOLTAGE_CTL1 (at 0x1416a)"
      tindex ezaxi:0xfc4cf980 %l 0x81416a0 0x1416a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_UL_VOLTAGE_CTL2 (at 0x1416b)"
      tindex ezaxi:0xfc4cf980 %l 0x81416b0 0x1416b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_SEC_ACCESS (at 0x141d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8141d00 0x141d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_PERPH_RESET_CTL1 (at 0x141d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8141d80 0x141d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_PERPH_RESET_CTL2 (at 0x141d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8141d90 0x141d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_PERPH_RESET_CTL3 (at 0x141da)"
      tindex ezaxi:0xfc4cf980 %l 0x8141da0 0x141da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_PERPH_RESET_CTL4 (at 0x141db)"
      tindex ezaxi:0xfc4cf980 %l 0x8141db0 0x141db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO2_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_TEST1 (at 0x141e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8141e00 0x141e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO2_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_INT_TEST_VAL (at 0x141e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8141e10 0x141e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO2_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_TEST1 (at 0x141e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8141e20 0x141e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO2_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_TEST2 (at 0x141e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8141e30 0x141e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO2_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_TRIM_NUM (at 0x141f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8141f00 0x141f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO2_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO2_TRIM_CTRL (at 0x141f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8141f10 0x141f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO20"
  tree "LDO20"
    tree "LDO20_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_REVISION1 (at 0x15300)"
      tindex ezaxi:0xfc4cf980 %l 0x8153000 0x153000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO20_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_REVISION2 (at 0x15301)"
      tindex ezaxi:0xfc4cf980 %l 0x8153010 0x153010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO20_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_REVISION3 (at 0x15302)"
      tindex ezaxi:0xfc4cf980 %l 0x8153020 0x153020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO20_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_REVISION4 (at 0x15303)"
      tindex ezaxi:0xfc4cf980 %l 0x8153030 0x153030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO20_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_PERPH_TYPE (at 0x15304)"
      tindex ezaxi:0xfc4cf980 %l 0x8153040 0x153040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO20_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_PERPH_SUBTYPE (at 0x15305)"
      tindex ezaxi:0xfc4cf980 %l 0x8153050 0x153050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO20_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_STATUS1 (at 0x15308)"
      tindex ezaxi:0xfc4cf980 %l 0x8153080 0x153080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO20_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_STATUS2 (at 0x15309)"
      tindex ezaxi:0xfc4cf980 %l 0x8153090 0x153090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO20_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_STATUS3 (at 0x1530a)"
      tindex ezaxi:0xfc4cf980 %l 0x81530a0 0x1530a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO20_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_RT_STS (at 0x15310)"
      tindex ezaxi:0xfc4cf980 %l 0x8153100 0x153100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO20_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_SET_TYPE (at 0x15311)"
      tindex ezaxi:0xfc4cf980 %l 0x8153110 0x153110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO20_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_POLARITY_HIGH (at 0x15312)"
      tindex ezaxi:0xfc4cf980 %l 0x8153120 0x153120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO20_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_POLARITY_LOW (at 0x15313)"
      tindex ezaxi:0xfc4cf980 %l 0x8153130 0x153130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO20_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_LATCHED_CLR (at 0x15314)"
      tindex ezaxi:0xfc4cf980 %l 0x8153140 0x153140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO20_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_EN_SET (at 0x15315)"
      tindex ezaxi:0xfc4cf980 %l 0x8153150 0x153150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO20_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_EN_CLR (at 0x15316)"
      tindex ezaxi:0xfc4cf980 %l 0x8153160 0x153160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO20_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_LATCHED_STS (at 0x15318)"
      tindex ezaxi:0xfc4cf980 %l 0x8153180 0x153180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO20_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_PENDING_STS (at 0x15319)"
      tindex ezaxi:0xfc4cf980 %l 0x8153190 0x153190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO20_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_MID_SEL (at 0x1531a)"
      tindex ezaxi:0xfc4cf980 %l 0x81531a0 0x1531a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO20_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_PRIORITY (at 0x1531b)"
      tindex ezaxi:0xfc4cf980 %l 0x81531b0 0x1531b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO20_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_VOLTAGE_CTL1 (at 0x15340)"
      tindex ezaxi:0xfc4cf980 %l 0x8153400 0x153400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO20_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_VOLTAGE_CTL2 (at 0x15341)"
      tindex ezaxi:0xfc4cf980 %l 0x8153410 0x153410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO20_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_MODE_CTL2 (at 0x15345)"
      tindex ezaxi:0xfc4cf980 %l 0x8153450 0x153450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO20_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_EN_CTL (at 0x15346)"
      tindex ezaxi:0xfc4cf980 %l 0x8153460 0x153460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO20_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_PD_CTL (at 0x15348)"
      tindex ezaxi:0xfc4cf980 %l 0x8153480 0x153480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO20_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_CURRENT_LIM_CTL (at 0x1534a)"
      tindex ezaxi:0xfc4cf980 %l 0x81534a0 0x1534a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO20_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_SOFT_START_CTL (at 0x1534c)"
      tindex ezaxi:0xfc4cf980 %l 0x81534c0 0x1534c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO20_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_CONFIG_CTL (at 0x15352)"
      tindex ezaxi:0xfc4cf980 %l 0x8153520 0x153520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO20_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_LL_VOLTAGE_CTL1 (at 0x15368)"
      tindex ezaxi:0xfc4cf980 %l 0x8153680 0x153680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO20_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_LL_VOLTAGE_CTL2 (at 0x15369)"
      tindex ezaxi:0xfc4cf980 %l 0x8153690 0x153690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO20_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_UL_VOLTAGE_CTL1 (at 0x1536a)"
      tindex ezaxi:0xfc4cf980 %l 0x81536a0 0x1536a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO20_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_UL_VOLTAGE_CTL2 (at 0x1536b)"
      tindex ezaxi:0xfc4cf980 %l 0x81536b0 0x1536b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO20_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_SEC_ACCESS (at 0x153d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8153d00 0x153d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO20_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_PERPH_RESET_CTL1 (at 0x153d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8153d80 0x153d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO20_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_PERPH_RESET_CTL2 (at 0x153d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8153d90 0x153d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO20_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_PERPH_RESET_CTL3 (at 0x153da)"
      tindex ezaxi:0xfc4cf980 %l 0x8153da0 0x153da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO20_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_PERPH_RESET_CTL4 (at 0x153db)"
      tindex ezaxi:0xfc4cf980 %l 0x8153db0 0x153db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO20_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_TEST1 (at 0x153e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8153e00 0x153e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO20_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_INT_TEST_VAL (at 0x153e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8153e10 0x153e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO20_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_TEST1 (at 0x153e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8153e20 0x153e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO20_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_TEST2 (at 0x153e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8153e30 0x153e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO20_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_TRIM_NUM (at 0x153f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8153f00 0x153f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO20_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO20_TRIM_CTRL (at 0x153f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8153f10 0x153f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO21"
  tree "LDO21"
    tree "LDO21_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_REVISION1 (at 0x15400)"
      tindex ezaxi:0xfc4cf980 %l 0x8154000 0x154000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO21_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_REVISION2 (at 0x15401)"
      tindex ezaxi:0xfc4cf980 %l 0x8154010 0x154010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO21_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_REVISION3 (at 0x15402)"
      tindex ezaxi:0xfc4cf980 %l 0x8154020 0x154020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO21_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_REVISION4 (at 0x15403)"
      tindex ezaxi:0xfc4cf980 %l 0x8154030 0x154030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO21_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_PERPH_TYPE (at 0x15404)"
      tindex ezaxi:0xfc4cf980 %l 0x8154040 0x154040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO21_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_PERPH_SUBTYPE (at 0x15405)"
      tindex ezaxi:0xfc4cf980 %l 0x8154050 0x154050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO21_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_STATUS1 (at 0x15408)"
      tindex ezaxi:0xfc4cf980 %l 0x8154080 0x154080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO21_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_STATUS2 (at 0x15409)"
      tindex ezaxi:0xfc4cf980 %l 0x8154090 0x154090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO21_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_STATUS3 (at 0x1540a)"
      tindex ezaxi:0xfc4cf980 %l 0x81540a0 0x1540a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO21_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_RT_STS (at 0x15410)"
      tindex ezaxi:0xfc4cf980 %l 0x8154100 0x154100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO21_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_SET_TYPE (at 0x15411)"
      tindex ezaxi:0xfc4cf980 %l 0x8154110 0x154110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO21_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_POLARITY_HIGH (at 0x15412)"
      tindex ezaxi:0xfc4cf980 %l 0x8154120 0x154120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO21_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_POLARITY_LOW (at 0x15413)"
      tindex ezaxi:0xfc4cf980 %l 0x8154130 0x154130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO21_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_LATCHED_CLR (at 0x15414)"
      tindex ezaxi:0xfc4cf980 %l 0x8154140 0x154140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO21_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_EN_SET (at 0x15415)"
      tindex ezaxi:0xfc4cf980 %l 0x8154150 0x154150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO21_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_EN_CLR (at 0x15416)"
      tindex ezaxi:0xfc4cf980 %l 0x8154160 0x154160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO21_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_LATCHED_STS (at 0x15418)"
      tindex ezaxi:0xfc4cf980 %l 0x8154180 0x154180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO21_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_PENDING_STS (at 0x15419)"
      tindex ezaxi:0xfc4cf980 %l 0x8154190 0x154190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO21_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_MID_SEL (at 0x1541a)"
      tindex ezaxi:0xfc4cf980 %l 0x81541a0 0x1541a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO21_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_PRIORITY (at 0x1541b)"
      tindex ezaxi:0xfc4cf980 %l 0x81541b0 0x1541b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO21_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_VOLTAGE_CTL1 (at 0x15440)"
      tindex ezaxi:0xfc4cf980 %l 0x8154400 0x154400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO21_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_VOLTAGE_CTL2 (at 0x15441)"
      tindex ezaxi:0xfc4cf980 %l 0x8154410 0x154410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO21_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_MODE_CTL2 (at 0x15445)"
      tindex ezaxi:0xfc4cf980 %l 0x8154450 0x154450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO21_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_EN_CTL (at 0x15446)"
      tindex ezaxi:0xfc4cf980 %l 0x8154460 0x154460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO21_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_PD_CTL (at 0x15448)"
      tindex ezaxi:0xfc4cf980 %l 0x8154480 0x154480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO21_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_CURRENT_LIM_CTL (at 0x1544a)"
      tindex ezaxi:0xfc4cf980 %l 0x81544a0 0x1544a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO21_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_SOFT_START_CTL (at 0x1544c)"
      tindex ezaxi:0xfc4cf980 %l 0x81544c0 0x1544c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO21_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_CONFIG_CTL (at 0x15452)"
      tindex ezaxi:0xfc4cf980 %l 0x8154520 0x154520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO21_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_LL_VOLTAGE_CTL1 (at 0x15468)"
      tindex ezaxi:0xfc4cf980 %l 0x8154680 0x154680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO21_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_LL_VOLTAGE_CTL2 (at 0x15469)"
      tindex ezaxi:0xfc4cf980 %l 0x8154690 0x154690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO21_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_UL_VOLTAGE_CTL1 (at 0x1546a)"
      tindex ezaxi:0xfc4cf980 %l 0x81546a0 0x1546a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO21_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_UL_VOLTAGE_CTL2 (at 0x1546b)"
      tindex ezaxi:0xfc4cf980 %l 0x81546b0 0x1546b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO21_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_SEC_ACCESS (at 0x154d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8154d00 0x154d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO21_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_PERPH_RESET_CTL1 (at 0x154d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8154d80 0x154d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO21_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_PERPH_RESET_CTL2 (at 0x154d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8154d90 0x154d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO21_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_PERPH_RESET_CTL3 (at 0x154da)"
      tindex ezaxi:0xfc4cf980 %l 0x8154da0 0x154da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO21_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_PERPH_RESET_CTL4 (at 0x154db)"
      tindex ezaxi:0xfc4cf980 %l 0x8154db0 0x154db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO21_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_TEST1 (at 0x154e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8154e00 0x154e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO21_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_INT_TEST_VAL (at 0x154e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8154e10 0x154e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO21_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_TEST1 (at 0x154e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8154e20 0x154e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO21_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_TEST2 (at 0x154e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8154e30 0x154e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO21_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_TRIM_NUM (at 0x154f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8154f00 0x154f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO21_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO21_TRIM_CTRL (at 0x154f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8154f10 0x154f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO22"
  tree "LDO22"
    tree "LDO22_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_REVISION1 (at 0x15500)"
      tindex ezaxi:0xfc4cf980 %l 0x8155000 0x155000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO22_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_REVISION2 (at 0x15501)"
      tindex ezaxi:0xfc4cf980 %l 0x8155010 0x155010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO22_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_REVISION3 (at 0x15502)"
      tindex ezaxi:0xfc4cf980 %l 0x8155020 0x155020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO22_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_REVISION4 (at 0x15503)"
      tindex ezaxi:0xfc4cf980 %l 0x8155030 0x155030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO22_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_PERPH_TYPE (at 0x15504)"
      tindex ezaxi:0xfc4cf980 %l 0x8155040 0x155040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO22_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_PERPH_SUBTYPE (at 0x15505)"
      tindex ezaxi:0xfc4cf980 %l 0x8155050 0x155050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO22_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_STATUS1 (at 0x15508)"
      tindex ezaxi:0xfc4cf980 %l 0x8155080 0x155080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO22_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_STATUS2 (at 0x15509)"
      tindex ezaxi:0xfc4cf980 %l 0x8155090 0x155090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO22_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_STATUS3 (at 0x1550a)"
      tindex ezaxi:0xfc4cf980 %l 0x81550a0 0x1550a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO22_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_RT_STS (at 0x15510)"
      tindex ezaxi:0xfc4cf980 %l 0x8155100 0x155100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO22_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_SET_TYPE (at 0x15511)"
      tindex ezaxi:0xfc4cf980 %l 0x8155110 0x155110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO22_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_POLARITY_HIGH (at 0x15512)"
      tindex ezaxi:0xfc4cf980 %l 0x8155120 0x155120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO22_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_POLARITY_LOW (at 0x15513)"
      tindex ezaxi:0xfc4cf980 %l 0x8155130 0x155130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO22_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_LATCHED_CLR (at 0x15514)"
      tindex ezaxi:0xfc4cf980 %l 0x8155140 0x155140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO22_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_EN_SET (at 0x15515)"
      tindex ezaxi:0xfc4cf980 %l 0x8155150 0x155150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO22_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_EN_CLR (at 0x15516)"
      tindex ezaxi:0xfc4cf980 %l 0x8155160 0x155160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO22_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_LATCHED_STS (at 0x15518)"
      tindex ezaxi:0xfc4cf980 %l 0x8155180 0x155180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO22_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_PENDING_STS (at 0x15519)"
      tindex ezaxi:0xfc4cf980 %l 0x8155190 0x155190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO22_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_MID_SEL (at 0x1551a)"
      tindex ezaxi:0xfc4cf980 %l 0x81551a0 0x1551a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO22_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_PRIORITY (at 0x1551b)"
      tindex ezaxi:0xfc4cf980 %l 0x81551b0 0x1551b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO22_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_VOLTAGE_CTL1 (at 0x15540)"
      tindex ezaxi:0xfc4cf980 %l 0x8155400 0x155400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO22_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_VOLTAGE_CTL2 (at 0x15541)"
      tindex ezaxi:0xfc4cf980 %l 0x8155410 0x155410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO22_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_MODE_CTL2 (at 0x15545)"
      tindex ezaxi:0xfc4cf980 %l 0x8155450 0x155450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO22_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_EN_CTL (at 0x15546)"
      tindex ezaxi:0xfc4cf980 %l 0x8155460 0x155460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO22_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_PD_CTL (at 0x15548)"
      tindex ezaxi:0xfc4cf980 %l 0x8155480 0x155480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO22_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_CURRENT_LIM_CTL (at 0x1554a)"
      tindex ezaxi:0xfc4cf980 %l 0x81554a0 0x1554a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO22_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_SOFT_START_CTL (at 0x1554c)"
      tindex ezaxi:0xfc4cf980 %l 0x81554c0 0x1554c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO22_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_CONFIG_CTL (at 0x15552)"
      tindex ezaxi:0xfc4cf980 %l 0x8155520 0x155520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO22_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_LL_VOLTAGE_CTL1 (at 0x15568)"
      tindex ezaxi:0xfc4cf980 %l 0x8155680 0x155680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO22_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_LL_VOLTAGE_CTL2 (at 0x15569)"
      tindex ezaxi:0xfc4cf980 %l 0x8155690 0x155690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO22_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_UL_VOLTAGE_CTL1 (at 0x1556a)"
      tindex ezaxi:0xfc4cf980 %l 0x81556a0 0x1556a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO22_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_UL_VOLTAGE_CTL2 (at 0x1556b)"
      tindex ezaxi:0xfc4cf980 %l 0x81556b0 0x1556b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO22_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_SEC_ACCESS (at 0x155d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8155d00 0x155d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO22_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_PERPH_RESET_CTL1 (at 0x155d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8155d80 0x155d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO22_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_PERPH_RESET_CTL2 (at 0x155d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8155d90 0x155d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO22_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_PERPH_RESET_CTL3 (at 0x155da)"
      tindex ezaxi:0xfc4cf980 %l 0x8155da0 0x155da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO22_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_PERPH_RESET_CTL4 (at 0x155db)"
      tindex ezaxi:0xfc4cf980 %l 0x8155db0 0x155db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO22_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_TEST1 (at 0x155e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8155e00 0x155e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO22_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_INT_TEST_VAL (at 0x155e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8155e10 0x155e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO22_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_TEST1 (at 0x155e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8155e20 0x155e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO22_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_TEST2 (at 0x155e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8155e30 0x155e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO22_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_TRIM_NUM (at 0x155f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8155f00 0x155f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO22_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO22_TRIM_CTRL (at 0x155f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8155f10 0x155f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO23"
  tree "LDO23"
    tree "LDO23_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_REVISION1 (at 0x15600)"
      tindex ezaxi:0xfc4cf980 %l 0x8156000 0x156000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO23_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_REVISION2 (at 0x15601)"
      tindex ezaxi:0xfc4cf980 %l 0x8156010 0x156010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO23_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_REVISION3 (at 0x15602)"
      tindex ezaxi:0xfc4cf980 %l 0x8156020 0x156020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO23_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_REVISION4 (at 0x15603)"
      tindex ezaxi:0xfc4cf980 %l 0x8156030 0x156030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO23_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_PERPH_TYPE (at 0x15604)"
      tindex ezaxi:0xfc4cf980 %l 0x8156040 0x156040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO23_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_PERPH_SUBTYPE (at 0x15605)"
      tindex ezaxi:0xfc4cf980 %l 0x8156050 0x156050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO23_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_STATUS1 (at 0x15608)"
      tindex ezaxi:0xfc4cf980 %l 0x8156080 0x156080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO23_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_STATUS2 (at 0x15609)"
      tindex ezaxi:0xfc4cf980 %l 0x8156090 0x156090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO23_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_STATUS3 (at 0x1560a)"
      tindex ezaxi:0xfc4cf980 %l 0x81560a0 0x1560a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO23_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_RT_STS (at 0x15610)"
      tindex ezaxi:0xfc4cf980 %l 0x8156100 0x156100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO23_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_SET_TYPE (at 0x15611)"
      tindex ezaxi:0xfc4cf980 %l 0x8156110 0x156110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO23_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_POLARITY_HIGH (at 0x15612)"
      tindex ezaxi:0xfc4cf980 %l 0x8156120 0x156120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO23_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_POLARITY_LOW (at 0x15613)"
      tindex ezaxi:0xfc4cf980 %l 0x8156130 0x156130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO23_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_LATCHED_CLR (at 0x15614)"
      tindex ezaxi:0xfc4cf980 %l 0x8156140 0x156140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO23_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_EN_SET (at 0x15615)"
      tindex ezaxi:0xfc4cf980 %l 0x8156150 0x156150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO23_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_EN_CLR (at 0x15616)"
      tindex ezaxi:0xfc4cf980 %l 0x8156160 0x156160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO23_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_LATCHED_STS (at 0x15618)"
      tindex ezaxi:0xfc4cf980 %l 0x8156180 0x156180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO23_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_PENDING_STS (at 0x15619)"
      tindex ezaxi:0xfc4cf980 %l 0x8156190 0x156190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO23_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_MID_SEL (at 0x1561a)"
      tindex ezaxi:0xfc4cf980 %l 0x81561a0 0x1561a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO23_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_PRIORITY (at 0x1561b)"
      tindex ezaxi:0xfc4cf980 %l 0x81561b0 0x1561b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO23_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_VOLTAGE_CTL1 (at 0x15640)"
      tindex ezaxi:0xfc4cf980 %l 0x8156400 0x156400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO23_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_VOLTAGE_CTL2 (at 0x15641)"
      tindex ezaxi:0xfc4cf980 %l 0x8156410 0x156410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO23_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_MODE_CTL2 (at 0x15645)"
      tindex ezaxi:0xfc4cf980 %l 0x8156450 0x156450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO23_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_EN_CTL (at 0x15646)"
      tindex ezaxi:0xfc4cf980 %l 0x8156460 0x156460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO23_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_PD_CTL (at 0x15648)"
      tindex ezaxi:0xfc4cf980 %l 0x8156480 0x156480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO23_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_CURRENT_LIM_CTL (at 0x1564a)"
      tindex ezaxi:0xfc4cf980 %l 0x81564a0 0x1564a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO23_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_SOFT_START_CTL (at 0x1564c)"
      tindex ezaxi:0xfc4cf980 %l 0x81564c0 0x1564c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO23_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_CONFIG_CTL (at 0x15652)"
      tindex ezaxi:0xfc4cf980 %l 0x8156520 0x156520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO23_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_LL_VOLTAGE_CTL1 (at 0x15668)"
      tindex ezaxi:0xfc4cf980 %l 0x8156680 0x156680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO23_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_LL_VOLTAGE_CTL2 (at 0x15669)"
      tindex ezaxi:0xfc4cf980 %l 0x8156690 0x156690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO23_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_UL_VOLTAGE_CTL1 (at 0x1566a)"
      tindex ezaxi:0xfc4cf980 %l 0x81566a0 0x1566a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO23_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_UL_VOLTAGE_CTL2 (at 0x1566b)"
      tindex ezaxi:0xfc4cf980 %l 0x81566b0 0x1566b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO23_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_SEC_ACCESS (at 0x156d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8156d00 0x156d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO23_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_PERPH_RESET_CTL1 (at 0x156d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8156d80 0x156d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO23_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_PERPH_RESET_CTL2 (at 0x156d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8156d90 0x156d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO23_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_PERPH_RESET_CTL3 (at 0x156da)"
      tindex ezaxi:0xfc4cf980 %l 0x8156da0 0x156da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO23_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_PERPH_RESET_CTL4 (at 0x156db)"
      tindex ezaxi:0xfc4cf980 %l 0x8156db0 0x156db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO23_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_TEST1 (at 0x156e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8156e00 0x156e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO23_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_INT_TEST_VAL (at 0x156e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8156e10 0x156e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO23_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_TEST1 (at 0x156e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8156e20 0x156e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO23_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_TEST2 (at 0x156e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8156e30 0x156e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO23_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_TRIM_NUM (at 0x156f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8156f00 0x156f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO23_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO23_TRIM_CTRL (at 0x156f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8156f10 0x156f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO24"
  tree "LDO24"
    tree "LDO24_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_REVISION1 (at 0x15700)"
      tindex ezaxi:0xfc4cf980 %l 0x8157000 0x157000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO24_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_REVISION2 (at 0x15701)"
      tindex ezaxi:0xfc4cf980 %l 0x8157010 0x157010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO24_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_REVISION3 (at 0x15702)"
      tindex ezaxi:0xfc4cf980 %l 0x8157020 0x157020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO24_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_REVISION4 (at 0x15703)"
      tindex ezaxi:0xfc4cf980 %l 0x8157030 0x157030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO24_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_PERPH_TYPE (at 0x15704)"
      tindex ezaxi:0xfc4cf980 %l 0x8157040 0x157040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO24_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_PERPH_SUBTYPE (at 0x15705)"
      tindex ezaxi:0xfc4cf980 %l 0x8157050 0x157050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO24_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_STATUS1 (at 0x15708)"
      tindex ezaxi:0xfc4cf980 %l 0x8157080 0x157080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO24_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_STATUS2 (at 0x15709)"
      tindex ezaxi:0xfc4cf980 %l 0x8157090 0x157090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO24_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_STATUS3 (at 0x1570a)"
      tindex ezaxi:0xfc4cf980 %l 0x81570a0 0x1570a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO24_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_RT_STS (at 0x15710)"
      tindex ezaxi:0xfc4cf980 %l 0x8157100 0x157100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO24_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_SET_TYPE (at 0x15711)"
      tindex ezaxi:0xfc4cf980 %l 0x8157110 0x157110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO24_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_POLARITY_HIGH (at 0x15712)"
      tindex ezaxi:0xfc4cf980 %l 0x8157120 0x157120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO24_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_POLARITY_LOW (at 0x15713)"
      tindex ezaxi:0xfc4cf980 %l 0x8157130 0x157130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO24_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_LATCHED_CLR (at 0x15714)"
      tindex ezaxi:0xfc4cf980 %l 0x8157140 0x157140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO24_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_EN_SET (at 0x15715)"
      tindex ezaxi:0xfc4cf980 %l 0x8157150 0x157150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO24_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_EN_CLR (at 0x15716)"
      tindex ezaxi:0xfc4cf980 %l 0x8157160 0x157160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO24_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_LATCHED_STS (at 0x15718)"
      tindex ezaxi:0xfc4cf980 %l 0x8157180 0x157180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO24_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_PENDING_STS (at 0x15719)"
      tindex ezaxi:0xfc4cf980 %l 0x8157190 0x157190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO24_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_MID_SEL (at 0x1571a)"
      tindex ezaxi:0xfc4cf980 %l 0x81571a0 0x1571a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO24_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_PRIORITY (at 0x1571b)"
      tindex ezaxi:0xfc4cf980 %l 0x81571b0 0x1571b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO24_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_VOLTAGE_CTL1 (at 0x15740)"
      tindex ezaxi:0xfc4cf980 %l 0x8157400 0x157400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO24_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_VOLTAGE_CTL2 (at 0x15741)"
      tindex ezaxi:0xfc4cf980 %l 0x8157410 0x157410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO24_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_MODE_CTL2 (at 0x15745)"
      tindex ezaxi:0xfc4cf980 %l 0x8157450 0x157450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO24_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_EN_CTL (at 0x15746)"
      tindex ezaxi:0xfc4cf980 %l 0x8157460 0x157460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO24_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_PD_CTL (at 0x15748)"
      tindex ezaxi:0xfc4cf980 %l 0x8157480 0x157480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO24_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_CURRENT_LIM_CTL (at 0x1574a)"
      tindex ezaxi:0xfc4cf980 %l 0x81574a0 0x1574a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO24_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_SOFT_START_CTL (at 0x1574c)"
      tindex ezaxi:0xfc4cf980 %l 0x81574c0 0x1574c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO24_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_CONFIG_CTL (at 0x15752)"
      tindex ezaxi:0xfc4cf980 %l 0x8157520 0x157520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO24_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_LL_VOLTAGE_CTL1 (at 0x15768)"
      tindex ezaxi:0xfc4cf980 %l 0x8157680 0x157680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO24_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_LL_VOLTAGE_CTL2 (at 0x15769)"
      tindex ezaxi:0xfc4cf980 %l 0x8157690 0x157690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO24_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_UL_VOLTAGE_CTL1 (at 0x1576a)"
      tindex ezaxi:0xfc4cf980 %l 0x81576a0 0x1576a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO24_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_UL_VOLTAGE_CTL2 (at 0x1576b)"
      tindex ezaxi:0xfc4cf980 %l 0x81576b0 0x1576b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO24_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_SEC_ACCESS (at 0x157d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8157d00 0x157d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO24_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_PERPH_RESET_CTL1 (at 0x157d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8157d80 0x157d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO24_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_PERPH_RESET_CTL2 (at 0x157d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8157d90 0x157d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO24_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_PERPH_RESET_CTL3 (at 0x157da)"
      tindex ezaxi:0xfc4cf980 %l 0x8157da0 0x157da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO24_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_PERPH_RESET_CTL4 (at 0x157db)"
      tindex ezaxi:0xfc4cf980 %l 0x8157db0 0x157db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO24_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_TEST1 (at 0x157e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8157e00 0x157e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO24_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_INT_TEST_VAL (at 0x157e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8157e10 0x157e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO24_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_TEST1 (at 0x157e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8157e20 0x157e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO24_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_TEST2 (at 0x157e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8157e30 0x157e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO24_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_TRIM_NUM (at 0x157f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8157f00 0x157f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO24_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO24_TRIM_CTRL (at 0x157f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8157f10 0x157f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO25"
  tree "LDO25"
    tree "LDO25_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_REVISION1 (at 0x15800)"
      tindex ezaxi:0xfc4cf980 %l 0x8158000 0x158000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO25_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_REVISION2 (at 0x15801)"
      tindex ezaxi:0xfc4cf980 %l 0x8158010 0x158010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO25_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_REVISION3 (at 0x15802)"
      tindex ezaxi:0xfc4cf980 %l 0x8158020 0x158020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO25_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_REVISION4 (at 0x15803)"
      tindex ezaxi:0xfc4cf980 %l 0x8158030 0x158030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO25_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_PERPH_TYPE (at 0x15804)"
      tindex ezaxi:0xfc4cf980 %l 0x8158040 0x158040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO25_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_PERPH_SUBTYPE (at 0x15805)"
      tindex ezaxi:0xfc4cf980 %l 0x8158050 0x158050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO25_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_STATUS1 (at 0x15808)"
      tindex ezaxi:0xfc4cf980 %l 0x8158080 0x158080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO25_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_STATUS2 (at 0x15809)"
      tindex ezaxi:0xfc4cf980 %l 0x8158090 0x158090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO25_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_STATUS3 (at 0x1580a)"
      tindex ezaxi:0xfc4cf980 %l 0x81580a0 0x1580a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO25_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_RT_STS (at 0x15810)"
      tindex ezaxi:0xfc4cf980 %l 0x8158100 0x158100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO25_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_SET_TYPE (at 0x15811)"
      tindex ezaxi:0xfc4cf980 %l 0x8158110 0x158110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO25_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_POLARITY_HIGH (at 0x15812)"
      tindex ezaxi:0xfc4cf980 %l 0x8158120 0x158120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO25_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_POLARITY_LOW (at 0x15813)"
      tindex ezaxi:0xfc4cf980 %l 0x8158130 0x158130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO25_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_LATCHED_CLR (at 0x15814)"
      tindex ezaxi:0xfc4cf980 %l 0x8158140 0x158140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO25_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_EN_SET (at 0x15815)"
      tindex ezaxi:0xfc4cf980 %l 0x8158150 0x158150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO25_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_EN_CLR (at 0x15816)"
      tindex ezaxi:0xfc4cf980 %l 0x8158160 0x158160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO25_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_LATCHED_STS (at 0x15818)"
      tindex ezaxi:0xfc4cf980 %l 0x8158180 0x158180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO25_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_PENDING_STS (at 0x15819)"
      tindex ezaxi:0xfc4cf980 %l 0x8158190 0x158190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO25_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_MID_SEL (at 0x1581a)"
      tindex ezaxi:0xfc4cf980 %l 0x81581a0 0x1581a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO25_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_PRIORITY (at 0x1581b)"
      tindex ezaxi:0xfc4cf980 %l 0x81581b0 0x1581b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO25_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_VOLTAGE_CTL1 (at 0x15840)"
      tindex ezaxi:0xfc4cf980 %l 0x8158400 0x158400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO25_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_VOLTAGE_CTL2 (at 0x15841)"
      tindex ezaxi:0xfc4cf980 %l 0x8158410 0x158410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO25_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_MODE_CTL2 (at 0x15845)"
      tindex ezaxi:0xfc4cf980 %l 0x8158450 0x158450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO25_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_EN_CTL (at 0x15846)"
      tindex ezaxi:0xfc4cf980 %l 0x8158460 0x158460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO25_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_PD_CTL (at 0x15848)"
      tindex ezaxi:0xfc4cf980 %l 0x8158480 0x158480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO25_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_CURRENT_LIM_CTL (at 0x1584a)"
      tindex ezaxi:0xfc4cf980 %l 0x81584a0 0x1584a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO25_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_SOFT_START_CTL (at 0x1584c)"
      tindex ezaxi:0xfc4cf980 %l 0x81584c0 0x1584c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO25_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_CONFIG_CTL (at 0x15852)"
      tindex ezaxi:0xfc4cf980 %l 0x8158520 0x158520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO25_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_LL_VOLTAGE_CTL1 (at 0x15868)"
      tindex ezaxi:0xfc4cf980 %l 0x8158680 0x158680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO25_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_LL_VOLTAGE_CTL2 (at 0x15869)"
      tindex ezaxi:0xfc4cf980 %l 0x8158690 0x158690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO25_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_UL_VOLTAGE_CTL1 (at 0x1586a)"
      tindex ezaxi:0xfc4cf980 %l 0x81586a0 0x1586a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO25_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_UL_VOLTAGE_CTL2 (at 0x1586b)"
      tindex ezaxi:0xfc4cf980 %l 0x81586b0 0x1586b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO25_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_SEC_ACCESS (at 0x158d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8158d00 0x158d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO25_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_PERPH_RESET_CTL1 (at 0x158d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8158d80 0x158d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO25_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_PERPH_RESET_CTL2 (at 0x158d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8158d90 0x158d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO25_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_PERPH_RESET_CTL3 (at 0x158da)"
      tindex ezaxi:0xfc4cf980 %l 0x8158da0 0x158da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO25_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_PERPH_RESET_CTL4 (at 0x158db)"
      tindex ezaxi:0xfc4cf980 %l 0x8158db0 0x158db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO25_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_TEST1 (at 0x158e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8158e00 0x158e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO25_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_INT_TEST_VAL (at 0x158e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8158e10 0x158e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO25_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_TEST1 (at 0x158e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8158e20 0x158e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO25_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_TEST2 (at 0x158e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8158e30 0x158e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO25_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_TRIM_NUM (at 0x158f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8158f00 0x158f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO25_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO25_TRIM_CTRL (at 0x158f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8158f10 0x158f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO26"
  tree "LDO26"
    tree "LDO26_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_REVISION1 (at 0x15900)"
      tindex ezaxi:0xfc4cf980 %l 0x8159000 0x159000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO26_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_REVISION2 (at 0x15901)"
      tindex ezaxi:0xfc4cf980 %l 0x8159010 0x159010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO26_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_REVISION3 (at 0x15902)"
      tindex ezaxi:0xfc4cf980 %l 0x8159020 0x159020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO26_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_REVISION4 (at 0x15903)"
      tindex ezaxi:0xfc4cf980 %l 0x8159030 0x159030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO26_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_PERPH_TYPE (at 0x15904)"
      tindex ezaxi:0xfc4cf980 %l 0x8159040 0x159040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO26_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_PERPH_SUBTYPE (at 0x15905)"
      tindex ezaxi:0xfc4cf980 %l 0x8159050 0x159050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO26_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_STATUS1 (at 0x15908)"
      tindex ezaxi:0xfc4cf980 %l 0x8159080 0x159080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO26_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_STATUS2 (at 0x15909)"
      tindex ezaxi:0xfc4cf980 %l 0x8159090 0x159090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO26_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_STATUS3 (at 0x1590a)"
      tindex ezaxi:0xfc4cf980 %l 0x81590a0 0x1590a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO26_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_RT_STS (at 0x15910)"
      tindex ezaxi:0xfc4cf980 %l 0x8159100 0x159100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO26_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_SET_TYPE (at 0x15911)"
      tindex ezaxi:0xfc4cf980 %l 0x8159110 0x159110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO26_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_POLARITY_HIGH (at 0x15912)"
      tindex ezaxi:0xfc4cf980 %l 0x8159120 0x159120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO26_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_POLARITY_LOW (at 0x15913)"
      tindex ezaxi:0xfc4cf980 %l 0x8159130 0x159130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO26_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_LATCHED_CLR (at 0x15914)"
      tindex ezaxi:0xfc4cf980 %l 0x8159140 0x159140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO26_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_EN_SET (at 0x15915)"
      tindex ezaxi:0xfc4cf980 %l 0x8159150 0x159150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO26_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_EN_CLR (at 0x15916)"
      tindex ezaxi:0xfc4cf980 %l 0x8159160 0x159160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO26_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_LATCHED_STS (at 0x15918)"
      tindex ezaxi:0xfc4cf980 %l 0x8159180 0x159180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO26_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_PENDING_STS (at 0x15919)"
      tindex ezaxi:0xfc4cf980 %l 0x8159190 0x159190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO26_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_MID_SEL (at 0x1591a)"
      tindex ezaxi:0xfc4cf980 %l 0x81591a0 0x1591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO26_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_PRIORITY (at 0x1591b)"
      tindex ezaxi:0xfc4cf980 %l 0x81591b0 0x1591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO26_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_VOLTAGE_CTL1 (at 0x15940)"
      tindex ezaxi:0xfc4cf980 %l 0x8159400 0x159400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO26_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_VOLTAGE_CTL2 (at 0x15941)"
      tindex ezaxi:0xfc4cf980 %l 0x8159410 0x159410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO26_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_MODE_CTL2 (at 0x15945)"
      tindex ezaxi:0xfc4cf980 %l 0x8159450 0x159450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO26_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_EN_CTL (at 0x15946)"
      tindex ezaxi:0xfc4cf980 %l 0x8159460 0x159460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO26_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_PD_CTL (at 0x15948)"
      tindex ezaxi:0xfc4cf980 %l 0x8159480 0x159480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO26_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_CURRENT_LIM_CTL (at 0x1594a)"
      tindex ezaxi:0xfc4cf980 %l 0x81594a0 0x1594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO26_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_SOFT_START_CTL (at 0x1594c)"
      tindex ezaxi:0xfc4cf980 %l 0x81594c0 0x1594c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO26_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_CONFIG_CTL (at 0x15952)"
      tindex ezaxi:0xfc4cf980 %l 0x8159520 0x159520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO26_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_VS_CTL (at 0x15961)"
      tindex ezaxi:0xfc4cf980 %l 0x8159610 0x159610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO26_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_LL_VOLTAGE_CTL1 (at 0x15968)"
      tindex ezaxi:0xfc4cf980 %l 0x8159680 0x159680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO26_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_LL_VOLTAGE_CTL2 (at 0x15969)"
      tindex ezaxi:0xfc4cf980 %l 0x8159690 0x159690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO26_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_UL_VOLTAGE_CTL1 (at 0x1596a)"
      tindex ezaxi:0xfc4cf980 %l 0x81596a0 0x1596a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO26_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_UL_VOLTAGE_CTL2 (at 0x1596b)"
      tindex ezaxi:0xfc4cf980 %l 0x81596b0 0x1596b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO26_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_SEC_ACCESS (at 0x159d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8159d00 0x159d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO26_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_PERPH_RESET_CTL1 (at 0x159d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8159d80 0x159d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO26_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_PERPH_RESET_CTL2 (at 0x159d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8159d90 0x159d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO26_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_PERPH_RESET_CTL3 (at 0x159da)"
      tindex ezaxi:0xfc4cf980 %l 0x8159da0 0x159da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO26_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_PERPH_RESET_CTL4 (at 0x159db)"
      tindex ezaxi:0xfc4cf980 %l 0x8159db0 0x159db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO26_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_TEST1 (at 0x159e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8159e00 0x159e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO26_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_INT_TEST_VAL (at 0x159e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8159e10 0x159e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO26_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_TEST1 (at 0x159e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8159e20 0x159e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO26_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_TEST2 (at 0x159e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8159e30 0x159e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO26_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_TRIM_NUM (at 0x159f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8159f00 0x159f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO26_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO26_TRIM_CTRL (at 0x159f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8159f10 0x159f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO27"
  tree "LDO27"
    tree "LDO27_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_REVISION1 (at 0x15a00)"
      tindex ezaxi:0xfc4cf980 %l 0x815a000 0x15a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO27_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_REVISION2 (at 0x15a01)"
      tindex ezaxi:0xfc4cf980 %l 0x815a010 0x15a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO27_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_REVISION3 (at 0x15a02)"
      tindex ezaxi:0xfc4cf980 %l 0x815a020 0x15a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO27_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_REVISION4 (at 0x15a03)"
      tindex ezaxi:0xfc4cf980 %l 0x815a030 0x15a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO27_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_PERPH_TYPE (at 0x15a04)"
      tindex ezaxi:0xfc4cf980 %l 0x815a040 0x15a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO27_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_PERPH_SUBTYPE (at 0x15a05)"
      tindex ezaxi:0xfc4cf980 %l 0x815a050 0x15a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO27_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_STATUS1 (at 0x15a08)"
      tindex ezaxi:0xfc4cf980 %l 0x815a080 0x15a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO27_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_STATUS2 (at 0x15a09)"
      tindex ezaxi:0xfc4cf980 %l 0x815a090 0x15a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO27_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_STATUS3 (at 0x15a0a)"
      tindex ezaxi:0xfc4cf980 %l 0x815a0a0 0x15a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO27_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_RT_STS (at 0x15a10)"
      tindex ezaxi:0xfc4cf980 %l 0x815a100 0x15a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO27_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_SET_TYPE (at 0x15a11)"
      tindex ezaxi:0xfc4cf980 %l 0x815a110 0x15a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO27_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_POLARITY_HIGH (at 0x15a12)"
      tindex ezaxi:0xfc4cf980 %l 0x815a120 0x15a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO27_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_POLARITY_LOW (at 0x15a13)"
      tindex ezaxi:0xfc4cf980 %l 0x815a130 0x15a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO27_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_LATCHED_CLR (at 0x15a14)"
      tindex ezaxi:0xfc4cf980 %l 0x815a140 0x15a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO27_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_EN_SET (at 0x15a15)"
      tindex ezaxi:0xfc4cf980 %l 0x815a150 0x15a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO27_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_EN_CLR (at 0x15a16)"
      tindex ezaxi:0xfc4cf980 %l 0x815a160 0x15a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO27_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_LATCHED_STS (at 0x15a18)"
      tindex ezaxi:0xfc4cf980 %l 0x815a180 0x15a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO27_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_PENDING_STS (at 0x15a19)"
      tindex ezaxi:0xfc4cf980 %l 0x815a190 0x15a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO27_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_MID_SEL (at 0x15a1a)"
      tindex ezaxi:0xfc4cf980 %l 0x815a1a0 0x15a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO27_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_PRIORITY (at 0x15a1b)"
      tindex ezaxi:0xfc4cf980 %l 0x815a1b0 0x15a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO27_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_VOLTAGE_CTL1 (at 0x15a40)"
      tindex ezaxi:0xfc4cf980 %l 0x815a400 0x15a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO27_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_VOLTAGE_CTL2 (at 0x15a41)"
      tindex ezaxi:0xfc4cf980 %l 0x815a410 0x15a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO27_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_MODE_CTL2 (at 0x15a45)"
      tindex ezaxi:0xfc4cf980 %l 0x815a450 0x15a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO27_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_EN_CTL (at 0x15a46)"
      tindex ezaxi:0xfc4cf980 %l 0x815a460 0x15a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO27_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_PD_CTL (at 0x15a48)"
      tindex ezaxi:0xfc4cf980 %l 0x815a480 0x15a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO27_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_CURRENT_LIM_CTL (at 0x15a4a)"
      tindex ezaxi:0xfc4cf980 %l 0x815a4a0 0x15a4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO27_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_SOFT_START_CTL (at 0x15a4c)"
      tindex ezaxi:0xfc4cf980 %l 0x815a4c0 0x15a4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO27_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_CONFIG_CTL (at 0x15a52)"
      tindex ezaxi:0xfc4cf980 %l 0x815a520 0x15a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO27_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_LL_VOLTAGE_CTL1 (at 0x15a68)"
      tindex ezaxi:0xfc4cf980 %l 0x815a680 0x15a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO27_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_LL_VOLTAGE_CTL2 (at 0x15a69)"
      tindex ezaxi:0xfc4cf980 %l 0x815a690 0x15a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO27_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_UL_VOLTAGE_CTL1 (at 0x15a6a)"
      tindex ezaxi:0xfc4cf980 %l 0x815a6a0 0x15a6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO27_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_UL_VOLTAGE_CTL2 (at 0x15a6b)"
      tindex ezaxi:0xfc4cf980 %l 0x815a6b0 0x15a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO27_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_SEC_ACCESS (at 0x15ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x815ad00 0x15ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO27_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_PERPH_RESET_CTL1 (at 0x15ad8)"
      tindex ezaxi:0xfc4cf980 %l 0x815ad80 0x15ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO27_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_PERPH_RESET_CTL2 (at 0x15ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x815ad90 0x15ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO27_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_PERPH_RESET_CTL3 (at 0x15ada)"
      tindex ezaxi:0xfc4cf980 %l 0x815ada0 0x15ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO27_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_PERPH_RESET_CTL4 (at 0x15adb)"
      tindex ezaxi:0xfc4cf980 %l 0x815adb0 0x15adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO27_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_TEST1 (at 0x15ae0)"
      tindex ezaxi:0xfc4cf980 %l 0x815ae00 0x15ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO27_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_INT_TEST_VAL (at 0x15ae1)"
      tindex ezaxi:0xfc4cf980 %l 0x815ae10 0x15ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO27_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_TEST1 (at 0x15ae2)"
      tindex ezaxi:0xfc4cf980 %l 0x815ae20 0x15ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO27_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_TEST2 (at 0x15ae3)"
      tindex ezaxi:0xfc4cf980 %l 0x815ae30 0x15ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO27_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_TRIM_NUM (at 0x15af0)"
      tindex ezaxi:0xfc4cf980 %l 0x815af00 0x15af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO27_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO27_TRIM_CTRL (at 0x15af1)"
      tindex ezaxi:0xfc4cf980 %l 0x815af10 0x15af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO28"
  tree "LDO28"
    tree "LDO28_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_REVISION1 (at 0x15b00)"
      tindex ezaxi:0xfc4cf980 %l 0x815b000 0x15b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO28_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_REVISION2 (at 0x15b01)"
      tindex ezaxi:0xfc4cf980 %l 0x815b010 0x15b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO28_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_REVISION3 (at 0x15b02)"
      tindex ezaxi:0xfc4cf980 %l 0x815b020 0x15b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO28_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_REVISION4 (at 0x15b03)"
      tindex ezaxi:0xfc4cf980 %l 0x815b030 0x15b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO28_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_PERPH_TYPE (at 0x15b04)"
      tindex ezaxi:0xfc4cf980 %l 0x815b040 0x15b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO28_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_PERPH_SUBTYPE (at 0x15b05)"
      tindex ezaxi:0xfc4cf980 %l 0x815b050 0x15b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO28_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_STATUS1 (at 0x15b08)"
      tindex ezaxi:0xfc4cf980 %l 0x815b080 0x15b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO28_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_STATUS2 (at 0x15b09)"
      tindex ezaxi:0xfc4cf980 %l 0x815b090 0x15b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO28_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_STATUS3 (at 0x15b0a)"
      tindex ezaxi:0xfc4cf980 %l 0x815b0a0 0x15b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO28_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_RT_STS (at 0x15b10)"
      tindex ezaxi:0xfc4cf980 %l 0x815b100 0x15b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO28_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_SET_TYPE (at 0x15b11)"
      tindex ezaxi:0xfc4cf980 %l 0x815b110 0x15b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO28_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_POLARITY_HIGH (at 0x15b12)"
      tindex ezaxi:0xfc4cf980 %l 0x815b120 0x15b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO28_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_POLARITY_LOW (at 0x15b13)"
      tindex ezaxi:0xfc4cf980 %l 0x815b130 0x15b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO28_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_LATCHED_CLR (at 0x15b14)"
      tindex ezaxi:0xfc4cf980 %l 0x815b140 0x15b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO28_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_EN_SET (at 0x15b15)"
      tindex ezaxi:0xfc4cf980 %l 0x815b150 0x15b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO28_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_EN_CLR (at 0x15b16)"
      tindex ezaxi:0xfc4cf980 %l 0x815b160 0x15b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO28_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_LATCHED_STS (at 0x15b18)"
      tindex ezaxi:0xfc4cf980 %l 0x815b180 0x15b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO28_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_PENDING_STS (at 0x15b19)"
      tindex ezaxi:0xfc4cf980 %l 0x815b190 0x15b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO28_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_MID_SEL (at 0x15b1a)"
      tindex ezaxi:0xfc4cf980 %l 0x815b1a0 0x15b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO28_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_PRIORITY (at 0x15b1b)"
      tindex ezaxi:0xfc4cf980 %l 0x815b1b0 0x15b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO28_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_VOLTAGE_CTL1 (at 0x15b40)"
      tindex ezaxi:0xfc4cf980 %l 0x815b400 0x15b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO28_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_VOLTAGE_CTL2 (at 0x15b41)"
      tindex ezaxi:0xfc4cf980 %l 0x815b410 0x15b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO28_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_MODE_CTL2 (at 0x15b45)"
      tindex ezaxi:0xfc4cf980 %l 0x815b450 0x15b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO28_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_EN_CTL (at 0x15b46)"
      tindex ezaxi:0xfc4cf980 %l 0x815b460 0x15b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO28_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_PD_CTL (at 0x15b48)"
      tindex ezaxi:0xfc4cf980 %l 0x815b480 0x15b480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO28_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_CURRENT_LIM_CTL (at 0x15b4a)"
      tindex ezaxi:0xfc4cf980 %l 0x815b4a0 0x15b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO28_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_SOFT_START_CTL (at 0x15b4c)"
      tindex ezaxi:0xfc4cf980 %l 0x815b4c0 0x15b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO28_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_CONFIG_CTL (at 0x15b52)"
      tindex ezaxi:0xfc4cf980 %l 0x815b520 0x15b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO28_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_LL_VOLTAGE_CTL1 (at 0x15b68)"
      tindex ezaxi:0xfc4cf980 %l 0x815b680 0x15b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO28_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_LL_VOLTAGE_CTL2 (at 0x15b69)"
      tindex ezaxi:0xfc4cf980 %l 0x815b690 0x15b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO28_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_UL_VOLTAGE_CTL1 (at 0x15b6a)"
      tindex ezaxi:0xfc4cf980 %l 0x815b6a0 0x15b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO28_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_UL_VOLTAGE_CTL2 (at 0x15b6b)"
      tindex ezaxi:0xfc4cf980 %l 0x815b6b0 0x15b6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO28_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_SEC_ACCESS (at 0x15bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x815bd00 0x15bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO28_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_PERPH_RESET_CTL1 (at 0x15bd8)"
      tindex ezaxi:0xfc4cf980 %l 0x815bd80 0x15bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO28_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_PERPH_RESET_CTL2 (at 0x15bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x815bd90 0x15bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO28_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_PERPH_RESET_CTL3 (at 0x15bda)"
      tindex ezaxi:0xfc4cf980 %l 0x815bda0 0x15bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO28_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_PERPH_RESET_CTL4 (at 0x15bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x815bdb0 0x15bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO28_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_TEST1 (at 0x15be0)"
      tindex ezaxi:0xfc4cf980 %l 0x815be00 0x15be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO28_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_INT_TEST_VAL (at 0x15be1)"
      tindex ezaxi:0xfc4cf980 %l 0x815be10 0x15be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO28_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_TEST1 (at 0x15be2)"
      tindex ezaxi:0xfc4cf980 %l 0x815be20 0x15be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO28_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_TEST2 (at 0x15be3)"
      tindex ezaxi:0xfc4cf980 %l 0x815be30 0x15be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO28_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_TRIM_NUM (at 0x15bf0)"
      tindex ezaxi:0xfc4cf980 %l 0x815bf00 0x15bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO28_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO28_TRIM_CTRL (at 0x15bf1)"
      tindex ezaxi:0xfc4cf980 %l 0x815bf10 0x15bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO29"
  tree "LDO29"
    tree "LDO29_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_REVISION1 (at 0x15c00)"
      tindex ezaxi:0xfc4cf980 %l 0x815c000 0x15c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO29_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_REVISION2 (at 0x15c01)"
      tindex ezaxi:0xfc4cf980 %l 0x815c010 0x15c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO29_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_REVISION3 (at 0x15c02)"
      tindex ezaxi:0xfc4cf980 %l 0x815c020 0x15c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO29_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_REVISION4 (at 0x15c03)"
      tindex ezaxi:0xfc4cf980 %l 0x815c030 0x15c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO29_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_PERPH_TYPE (at 0x15c04)"
      tindex ezaxi:0xfc4cf980 %l 0x815c040 0x15c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO29_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_PERPH_SUBTYPE (at 0x15c05)"
      tindex ezaxi:0xfc4cf980 %l 0x815c050 0x15c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO29_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_STATUS1 (at 0x15c08)"
      tindex ezaxi:0xfc4cf980 %l 0x815c080 0x15c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO29_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_STATUS2 (at 0x15c09)"
      tindex ezaxi:0xfc4cf980 %l 0x815c090 0x15c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO29_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_STATUS3 (at 0x15c0a)"
      tindex ezaxi:0xfc4cf980 %l 0x815c0a0 0x15c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO29_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_RT_STS (at 0x15c10)"
      tindex ezaxi:0xfc4cf980 %l 0x815c100 0x15c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO29_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_SET_TYPE (at 0x15c11)"
      tindex ezaxi:0xfc4cf980 %l 0x815c110 0x15c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO29_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_POLARITY_HIGH (at 0x15c12)"
      tindex ezaxi:0xfc4cf980 %l 0x815c120 0x15c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO29_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_POLARITY_LOW (at 0x15c13)"
      tindex ezaxi:0xfc4cf980 %l 0x815c130 0x15c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO29_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_LATCHED_CLR (at 0x15c14)"
      tindex ezaxi:0xfc4cf980 %l 0x815c140 0x15c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO29_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_EN_SET (at 0x15c15)"
      tindex ezaxi:0xfc4cf980 %l 0x815c150 0x15c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO29_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_EN_CLR (at 0x15c16)"
      tindex ezaxi:0xfc4cf980 %l 0x815c160 0x15c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO29_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_LATCHED_STS (at 0x15c18)"
      tindex ezaxi:0xfc4cf980 %l 0x815c180 0x15c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO29_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_PENDING_STS (at 0x15c19)"
      tindex ezaxi:0xfc4cf980 %l 0x815c190 0x15c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO29_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_MID_SEL (at 0x15c1a)"
      tindex ezaxi:0xfc4cf980 %l 0x815c1a0 0x15c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO29_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_PRIORITY (at 0x15c1b)"
      tindex ezaxi:0xfc4cf980 %l 0x815c1b0 0x15c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO29_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_VOLTAGE_CTL1 (at 0x15c40)"
      tindex ezaxi:0xfc4cf980 %l 0x815c400 0x15c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO29_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_VOLTAGE_CTL2 (at 0x15c41)"
      tindex ezaxi:0xfc4cf980 %l 0x815c410 0x15c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO29_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_MODE_CTL2 (at 0x15c45)"
      tindex ezaxi:0xfc4cf980 %l 0x815c450 0x15c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO29_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_EN_CTL (at 0x15c46)"
      tindex ezaxi:0xfc4cf980 %l 0x815c460 0x15c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO29_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_PD_CTL (at 0x15c48)"
      tindex ezaxi:0xfc4cf980 %l 0x815c480 0x15c480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO29_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_CURRENT_LIM_CTL (at 0x15c4a)"
      tindex ezaxi:0xfc4cf980 %l 0x815c4a0 0x15c4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO29_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_SOFT_START_CTL (at 0x15c4c)"
      tindex ezaxi:0xfc4cf980 %l 0x815c4c0 0x15c4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO29_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_CONFIG_CTL (at 0x15c52)"
      tindex ezaxi:0xfc4cf980 %l 0x815c520 0x15c520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO29_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_LL_VOLTAGE_CTL1 (at 0x15c68)"
      tindex ezaxi:0xfc4cf980 %l 0x815c680 0x15c680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO29_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_LL_VOLTAGE_CTL2 (at 0x15c69)"
      tindex ezaxi:0xfc4cf980 %l 0x815c690 0x15c690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO29_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_UL_VOLTAGE_CTL1 (at 0x15c6a)"
      tindex ezaxi:0xfc4cf980 %l 0x815c6a0 0x15c6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO29_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_UL_VOLTAGE_CTL2 (at 0x15c6b)"
      tindex ezaxi:0xfc4cf980 %l 0x815c6b0 0x15c6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO29_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_SEC_ACCESS (at 0x15cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x815cd00 0x15cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO29_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_PERPH_RESET_CTL1 (at 0x15cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x815cd80 0x15cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO29_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_PERPH_RESET_CTL2 (at 0x15cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x815cd90 0x15cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO29_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_PERPH_RESET_CTL3 (at 0x15cda)"
      tindex ezaxi:0xfc4cf980 %l 0x815cda0 0x15cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO29_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_PERPH_RESET_CTL4 (at 0x15cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x815cdb0 0x15cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO29_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_TEST1 (at 0x15ce0)"
      tindex ezaxi:0xfc4cf980 %l 0x815ce00 0x15ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO29_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_INT_TEST_VAL (at 0x15ce1)"
      tindex ezaxi:0xfc4cf980 %l 0x815ce10 0x15ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO29_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_TEST1 (at 0x15ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x815ce20 0x15ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO29_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_TEST2 (at 0x15ce3)"
      tindex ezaxi:0xfc4cf980 %l 0x815ce30 0x15ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO29_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_TRIM_NUM (at 0x15cf0)"
      tindex ezaxi:0xfc4cf980 %l 0x815cf00 0x15cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO29_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO29_TRIM_CTRL (at 0x15cf1)"
      tindex ezaxi:0xfc4cf980 %l 0x815cf10 0x15cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO3"
  tree "LDO3"
    tree "LDO3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_REVISION1 (at 0x14200)"
      tindex ezaxi:0xfc4cf980 %l 0x8142000 0x142000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_REVISION2 (at 0x14201)"
      tindex ezaxi:0xfc4cf980 %l 0x8142010 0x142010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO3_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_REVISION3 (at 0x14202)"
      tindex ezaxi:0xfc4cf980 %l 0x8142020 0x142020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO3_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_REVISION4 (at 0x14203)"
      tindex ezaxi:0xfc4cf980 %l 0x8142030 0x142030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_PERPH_TYPE (at 0x14204)"
      tindex ezaxi:0xfc4cf980 %l 0x8142040 0x142040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_PERPH_SUBTYPE (at 0x14205)"
      tindex ezaxi:0xfc4cf980 %l 0x8142050 0x142050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_STATUS1 (at 0x14208)"
      tindex ezaxi:0xfc4cf980 %l 0x8142080 0x142080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO3_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_STATUS2 (at 0x14209)"
      tindex ezaxi:0xfc4cf980 %l 0x8142090 0x142090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO3_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_STATUS3 (at 0x1420a)"
      tindex ezaxi:0xfc4cf980 %l 0x81420a0 0x1420a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_RT_STS (at 0x14210)"
      tindex ezaxi:0xfc4cf980 %l 0x8142100 0x142100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_SET_TYPE (at 0x14211)"
      tindex ezaxi:0xfc4cf980 %l 0x8142110 0x142110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_POLARITY_HIGH (at 0x14212)"
      tindex ezaxi:0xfc4cf980 %l 0x8142120 0x142120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_POLARITY_LOW (at 0x14213)"
      tindex ezaxi:0xfc4cf980 %l 0x8142130 0x142130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_LATCHED_CLR (at 0x14214)"
      tindex ezaxi:0xfc4cf980 %l 0x8142140 0x142140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_EN_SET (at 0x14215)"
      tindex ezaxi:0xfc4cf980 %l 0x8142150 0x142150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_EN_CLR (at 0x14216)"
      tindex ezaxi:0xfc4cf980 %l 0x8142160 0x142160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_LATCHED_STS (at 0x14218)"
      tindex ezaxi:0xfc4cf980 %l 0x8142180 0x142180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_PENDING_STS (at 0x14219)"
      tindex ezaxi:0xfc4cf980 %l 0x8142190 0x142190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_MID_SEL (at 0x1421a)"
      tindex ezaxi:0xfc4cf980 %l 0x81421a0 0x1421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_PRIORITY (at 0x1421b)"
      tindex ezaxi:0xfc4cf980 %l 0x81421b0 0x1421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO3_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_VOLTAGE_CTL1 (at 0x14240)"
      tindex ezaxi:0xfc4cf980 %l 0x8142400 0x142400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_VOLTAGE_CTL2 (at 0x14241)"
      tindex ezaxi:0xfc4cf980 %l 0x8142410 0x142410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO3_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_MODE_CTL2 (at 0x14245)"
      tindex ezaxi:0xfc4cf980 %l 0x8142450 0x142450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_EN_CTL (at 0x14246)"
      tindex ezaxi:0xfc4cf980 %l 0x8142460 0x142460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_PD_CTL (at 0x14248)"
      tindex ezaxi:0xfc4cf980 %l 0x8142480 0x142480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO3_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_CURRENT_LIM_CTL (at 0x1424a)"
      tindex ezaxi:0xfc4cf980 %l 0x81424a0 0x1424a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO3_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_SOFT_START_CTL (at 0x1424c)"
      tindex ezaxi:0xfc4cf980 %l 0x81424c0 0x1424c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO3_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_CONFIG_CTL (at 0x14252)"
      tindex ezaxi:0xfc4cf980 %l 0x8142520 0x142520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO3_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_VS_CTL (at 0x14261)"
      tindex ezaxi:0xfc4cf980 %l 0x8142610 0x142610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_LL_VOLTAGE_CTL1 (at 0x14268)"
      tindex ezaxi:0xfc4cf980 %l 0x8142680 0x142680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_LL_VOLTAGE_CTL2 (at 0x14269)"
      tindex ezaxi:0xfc4cf980 %l 0x8142690 0x142690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_UL_VOLTAGE_CTL1 (at 0x1426a)"
      tindex ezaxi:0xfc4cf980 %l 0x81426a0 0x1426a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_UL_VOLTAGE_CTL2 (at 0x1426b)"
      tindex ezaxi:0xfc4cf980 %l 0x81426b0 0x1426b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_SEC_ACCESS (at 0x142d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8142d00 0x142d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_PERPH_RESET_CTL1 (at 0x142d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8142d80 0x142d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_PERPH_RESET_CTL2 (at 0x142d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8142d90 0x142d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_PERPH_RESET_CTL3 (at 0x142da)"
      tindex ezaxi:0xfc4cf980 %l 0x8142da0 0x142da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_PERPH_RESET_CTL4 (at 0x142db)"
      tindex ezaxi:0xfc4cf980 %l 0x8142db0 0x142db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO3_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_TEST1 (at 0x142e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8142e00 0x142e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO3_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_INT_TEST_VAL (at 0x142e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8142e10 0x142e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO3_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_TEST1 (at 0x142e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8142e20 0x142e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO3_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_TEST2 (at 0x142e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8142e30 0x142e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO3_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_TRIM_NUM (at 0x142f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8142f00 0x142f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO3_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO3_TRIM_CTRL (at 0x142f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8142f10 0x142f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO30"
  tree "LDO30"
    tree "LDO30_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_REVISION1 (at 0x15d00)"
      tindex ezaxi:0xfc4cf980 %l 0x815d000 0x15d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO30_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_REVISION2 (at 0x15d01)"
      tindex ezaxi:0xfc4cf980 %l 0x815d010 0x15d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO30_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_REVISION3 (at 0x15d02)"
      tindex ezaxi:0xfc4cf980 %l 0x815d020 0x15d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO30_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_REVISION4 (at 0x15d03)"
      tindex ezaxi:0xfc4cf980 %l 0x815d030 0x15d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO30_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_PERPH_TYPE (at 0x15d04)"
      tindex ezaxi:0xfc4cf980 %l 0x815d040 0x15d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO30_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_PERPH_SUBTYPE (at 0x15d05)"
      tindex ezaxi:0xfc4cf980 %l 0x815d050 0x15d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO30_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_STATUS1 (at 0x15d08)"
      tindex ezaxi:0xfc4cf980 %l 0x815d080 0x15d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO30_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_STATUS2 (at 0x15d09)"
      tindex ezaxi:0xfc4cf980 %l 0x815d090 0x15d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO30_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_STATUS3 (at 0x15d0a)"
      tindex ezaxi:0xfc4cf980 %l 0x815d0a0 0x15d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO30_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_RT_STS (at 0x15d10)"
      tindex ezaxi:0xfc4cf980 %l 0x815d100 0x15d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO30_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_SET_TYPE (at 0x15d11)"
      tindex ezaxi:0xfc4cf980 %l 0x815d110 0x15d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO30_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_POLARITY_HIGH (at 0x15d12)"
      tindex ezaxi:0xfc4cf980 %l 0x815d120 0x15d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO30_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_POLARITY_LOW (at 0x15d13)"
      tindex ezaxi:0xfc4cf980 %l 0x815d130 0x15d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO30_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_LATCHED_CLR (at 0x15d14)"
      tindex ezaxi:0xfc4cf980 %l 0x815d140 0x15d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO30_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_EN_SET (at 0x15d15)"
      tindex ezaxi:0xfc4cf980 %l 0x815d150 0x15d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO30_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_EN_CLR (at 0x15d16)"
      tindex ezaxi:0xfc4cf980 %l 0x815d160 0x15d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO30_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_LATCHED_STS (at 0x15d18)"
      tindex ezaxi:0xfc4cf980 %l 0x815d180 0x15d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO30_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_PENDING_STS (at 0x15d19)"
      tindex ezaxi:0xfc4cf980 %l 0x815d190 0x15d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO30_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_MID_SEL (at 0x15d1a)"
      tindex ezaxi:0xfc4cf980 %l 0x815d1a0 0x15d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO30_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_PRIORITY (at 0x15d1b)"
      tindex ezaxi:0xfc4cf980 %l 0x815d1b0 0x15d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO30_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_VOLTAGE_CTL1 (at 0x15d40)"
      tindex ezaxi:0xfc4cf980 %l 0x815d400 0x15d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO30_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_VOLTAGE_CTL2 (at 0x15d41)"
      tindex ezaxi:0xfc4cf980 %l 0x815d410 0x15d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO30_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_MODE_CTL2 (at 0x15d45)"
      tindex ezaxi:0xfc4cf980 %l 0x815d450 0x15d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO30_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_EN_CTL (at 0x15d46)"
      tindex ezaxi:0xfc4cf980 %l 0x815d460 0x15d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO30_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_PD_CTL (at 0x15d48)"
      tindex ezaxi:0xfc4cf980 %l 0x815d480 0x15d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO30_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_CURRENT_LIM_CTL (at 0x15d4a)"
      tindex ezaxi:0xfc4cf980 %l 0x815d4a0 0x15d4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO30_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_SOFT_START_CTL (at 0x15d4c)"
      tindex ezaxi:0xfc4cf980 %l 0x815d4c0 0x15d4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO30_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_CONFIG_CTL (at 0x15d52)"
      tindex ezaxi:0xfc4cf980 %l 0x815d520 0x15d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO30_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_LL_VOLTAGE_CTL1 (at 0x15d68)"
      tindex ezaxi:0xfc4cf980 %l 0x815d680 0x15d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO30_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_LL_VOLTAGE_CTL2 (at 0x15d69)"
      tindex ezaxi:0xfc4cf980 %l 0x815d690 0x15d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO30_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_UL_VOLTAGE_CTL1 (at 0x15d6a)"
      tindex ezaxi:0xfc4cf980 %l 0x815d6a0 0x15d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO30_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_UL_VOLTAGE_CTL2 (at 0x15d6b)"
      tindex ezaxi:0xfc4cf980 %l 0x815d6b0 0x15d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO30_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_SEC_ACCESS (at 0x15dd0)"
      tindex ezaxi:0xfc4cf980 %l 0x815dd00 0x15dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO30_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_PERPH_RESET_CTL1 (at 0x15dd8)"
      tindex ezaxi:0xfc4cf980 %l 0x815dd80 0x15dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO30_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_PERPH_RESET_CTL2 (at 0x15dd9)"
      tindex ezaxi:0xfc4cf980 %l 0x815dd90 0x15dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO30_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_PERPH_RESET_CTL3 (at 0x15dda)"
      tindex ezaxi:0xfc4cf980 %l 0x815dda0 0x15dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO30_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_PERPH_RESET_CTL4 (at 0x15ddb)"
      tindex ezaxi:0xfc4cf980 %l 0x815ddb0 0x15ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO30_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_TEST1 (at 0x15de0)"
      tindex ezaxi:0xfc4cf980 %l 0x815de00 0x15de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO30_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_INT_TEST_VAL (at 0x15de1)"
      tindex ezaxi:0xfc4cf980 %l 0x815de10 0x15de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO30_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_TEST1 (at 0x15de2)"
      tindex ezaxi:0xfc4cf980 %l 0x815de20 0x15de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO30_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_TEST2 (at 0x15de3)"
      tindex ezaxi:0xfc4cf980 %l 0x815de30 0x15de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO30_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_TRIM_NUM (at 0x15df0)"
      tindex ezaxi:0xfc4cf980 %l 0x815df00 0x15df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO30_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO30_TRIM_CTRL (at 0x15df1)"
      tindex ezaxi:0xfc4cf980 %l 0x815df10 0x15df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO31"
  tree "LDO31"
    tree "LDO31_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_REVISION1 (at 0x15e00)"
      tindex ezaxi:0xfc4cf980 %l 0x815e000 0x15e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO31_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_REVISION2 (at 0x15e01)"
      tindex ezaxi:0xfc4cf980 %l 0x815e010 0x15e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO31_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_REVISION3 (at 0x15e02)"
      tindex ezaxi:0xfc4cf980 %l 0x815e020 0x15e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO31_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_REVISION4 (at 0x15e03)"
      tindex ezaxi:0xfc4cf980 %l 0x815e030 0x15e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO31_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_PERPH_TYPE (at 0x15e04)"
      tindex ezaxi:0xfc4cf980 %l 0x815e040 0x15e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO31_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_PERPH_SUBTYPE (at 0x15e05)"
      tindex ezaxi:0xfc4cf980 %l 0x815e050 0x15e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO31_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_STATUS1 (at 0x15e08)"
      tindex ezaxi:0xfc4cf980 %l 0x815e080 0x15e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO31_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_STATUS2 (at 0x15e09)"
      tindex ezaxi:0xfc4cf980 %l 0x815e090 0x15e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO31_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_STATUS3 (at 0x15e0a)"
      tindex ezaxi:0xfc4cf980 %l 0x815e0a0 0x15e0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO31_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_RT_STS (at 0x15e10)"
      tindex ezaxi:0xfc4cf980 %l 0x815e100 0x15e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO31_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_SET_TYPE (at 0x15e11)"
      tindex ezaxi:0xfc4cf980 %l 0x815e110 0x15e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO31_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_POLARITY_HIGH (at 0x15e12)"
      tindex ezaxi:0xfc4cf980 %l 0x815e120 0x15e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO31_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_POLARITY_LOW (at 0x15e13)"
      tindex ezaxi:0xfc4cf980 %l 0x815e130 0x15e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO31_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_LATCHED_CLR (at 0x15e14)"
      tindex ezaxi:0xfc4cf980 %l 0x815e140 0x15e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO31_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_EN_SET (at 0x15e15)"
      tindex ezaxi:0xfc4cf980 %l 0x815e150 0x15e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO31_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_EN_CLR (at 0x15e16)"
      tindex ezaxi:0xfc4cf980 %l 0x815e160 0x15e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO31_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_LATCHED_STS (at 0x15e18)"
      tindex ezaxi:0xfc4cf980 %l 0x815e180 0x15e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO31_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_PENDING_STS (at 0x15e19)"
      tindex ezaxi:0xfc4cf980 %l 0x815e190 0x15e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO31_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_MID_SEL (at 0x15e1a)"
      tindex ezaxi:0xfc4cf980 %l 0x815e1a0 0x15e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO31_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_PRIORITY (at 0x15e1b)"
      tindex ezaxi:0xfc4cf980 %l 0x815e1b0 0x15e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO31_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_VOLTAGE_CTL1 (at 0x15e40)"
      tindex ezaxi:0xfc4cf980 %l 0x815e400 0x15e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO31_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_VOLTAGE_CTL2 (at 0x15e41)"
      tindex ezaxi:0xfc4cf980 %l 0x815e410 0x15e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO31_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_MODE_CTL2 (at 0x15e45)"
      tindex ezaxi:0xfc4cf980 %l 0x815e450 0x15e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO31_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_EN_CTL (at 0x15e46)"
      tindex ezaxi:0xfc4cf980 %l 0x815e460 0x15e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO31_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_PD_CTL (at 0x15e48)"
      tindex ezaxi:0xfc4cf980 %l 0x815e480 0x15e480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO31_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_CURRENT_LIM_CTL (at 0x15e4a)"
      tindex ezaxi:0xfc4cf980 %l 0x815e4a0 0x15e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO31_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_SOFT_START_CTL (at 0x15e4c)"
      tindex ezaxi:0xfc4cf980 %l 0x815e4c0 0x15e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO31_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_CONFIG_CTL (at 0x15e52)"
      tindex ezaxi:0xfc4cf980 %l 0x815e520 0x15e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO31_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_VS_CTL (at 0x15e61)"
      tindex ezaxi:0xfc4cf980 %l 0x815e610 0x15e610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO31_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_LL_VOLTAGE_CTL1 (at 0x15e68)"
      tindex ezaxi:0xfc4cf980 %l 0x815e680 0x15e680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO31_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_LL_VOLTAGE_CTL2 (at 0x15e69)"
      tindex ezaxi:0xfc4cf980 %l 0x815e690 0x15e690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO31_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_UL_VOLTAGE_CTL1 (at 0x15e6a)"
      tindex ezaxi:0xfc4cf980 %l 0x815e6a0 0x15e6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO31_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_UL_VOLTAGE_CTL2 (at 0x15e6b)"
      tindex ezaxi:0xfc4cf980 %l 0x815e6b0 0x15e6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO31_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_SEC_ACCESS (at 0x15ed0)"
      tindex ezaxi:0xfc4cf980 %l 0x815ed00 0x15ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO31_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_PERPH_RESET_CTL1 (at 0x15ed8)"
      tindex ezaxi:0xfc4cf980 %l 0x815ed80 0x15ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO31_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_PERPH_RESET_CTL2 (at 0x15ed9)"
      tindex ezaxi:0xfc4cf980 %l 0x815ed90 0x15ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO31_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_PERPH_RESET_CTL3 (at 0x15eda)"
      tindex ezaxi:0xfc4cf980 %l 0x815eda0 0x15eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO31_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_PERPH_RESET_CTL4 (at 0x15edb)"
      tindex ezaxi:0xfc4cf980 %l 0x815edb0 0x15edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO31_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_TEST1 (at 0x15ee0)"
      tindex ezaxi:0xfc4cf980 %l 0x815ee00 0x15ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO31_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_INT_TEST_VAL (at 0x15ee1)"
      tindex ezaxi:0xfc4cf980 %l 0x815ee10 0x15ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO31_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_TEST1 (at 0x15ee2)"
      tindex ezaxi:0xfc4cf980 %l 0x815ee20 0x15ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO31_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_TEST2 (at 0x15ee3)"
      tindex ezaxi:0xfc4cf980 %l 0x815ee30 0x15ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO31_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_TRIM_NUM (at 0x15ef0)"
      tindex ezaxi:0xfc4cf980 %l 0x815ef00 0x15ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO31_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO31_TRIM_CTRL (at 0x15ef1)"
      tindex ezaxi:0xfc4cf980 %l 0x815ef10 0x15ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO32"
  tree "LDO32"
    tree "LDO32_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_REVISION1 (at 0x15f00)"
      tindex ezaxi:0xfc4cf980 %l 0x815f000 0x15f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO32_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_REVISION2 (at 0x15f01)"
      tindex ezaxi:0xfc4cf980 %l 0x815f010 0x15f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO32_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_REVISION3 (at 0x15f02)"
      tindex ezaxi:0xfc4cf980 %l 0x815f020 0x15f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO32_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_REVISION4 (at 0x15f03)"
      tindex ezaxi:0xfc4cf980 %l 0x815f030 0x15f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO32_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_PERPH_TYPE (at 0x15f04)"
      tindex ezaxi:0xfc4cf980 %l 0x815f040 0x15f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO32_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_PERPH_SUBTYPE (at 0x15f05)"
      tindex ezaxi:0xfc4cf980 %l 0x815f050 0x15f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO32_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_STATUS1 (at 0x15f08)"
      tindex ezaxi:0xfc4cf980 %l 0x815f080 0x15f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO32_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_STATUS2 (at 0x15f09)"
      tindex ezaxi:0xfc4cf980 %l 0x815f090 0x15f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO32_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_STATUS3 (at 0x15f0a)"
      tindex ezaxi:0xfc4cf980 %l 0x815f0a0 0x15f0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO32_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_RT_STS (at 0x15f10)"
      tindex ezaxi:0xfc4cf980 %l 0x815f100 0x15f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO32_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_SET_TYPE (at 0x15f11)"
      tindex ezaxi:0xfc4cf980 %l 0x815f110 0x15f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO32_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_POLARITY_HIGH (at 0x15f12)"
      tindex ezaxi:0xfc4cf980 %l 0x815f120 0x15f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO32_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_POLARITY_LOW (at 0x15f13)"
      tindex ezaxi:0xfc4cf980 %l 0x815f130 0x15f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO32_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_LATCHED_CLR (at 0x15f14)"
      tindex ezaxi:0xfc4cf980 %l 0x815f140 0x15f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO32_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_EN_SET (at 0x15f15)"
      tindex ezaxi:0xfc4cf980 %l 0x815f150 0x15f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO32_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_EN_CLR (at 0x15f16)"
      tindex ezaxi:0xfc4cf980 %l 0x815f160 0x15f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO32_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_LATCHED_STS (at 0x15f18)"
      tindex ezaxi:0xfc4cf980 %l 0x815f180 0x15f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO32_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_PENDING_STS (at 0x15f19)"
      tindex ezaxi:0xfc4cf980 %l 0x815f190 0x15f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO32_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_MID_SEL (at 0x15f1a)"
      tindex ezaxi:0xfc4cf980 %l 0x815f1a0 0x15f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO32_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_PRIORITY (at 0x15f1b)"
      tindex ezaxi:0xfc4cf980 %l 0x815f1b0 0x15f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO32_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_VOLTAGE_CTL1 (at 0x15f40)"
      tindex ezaxi:0xfc4cf980 %l 0x815f400 0x15f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO32_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_VOLTAGE_CTL2 (at 0x15f41)"
      tindex ezaxi:0xfc4cf980 %l 0x815f410 0x15f410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO32_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_MODE_CTL2 (at 0x15f45)"
      tindex ezaxi:0xfc4cf980 %l 0x815f450 0x15f450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO32_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_EN_CTL (at 0x15f46)"
      tindex ezaxi:0xfc4cf980 %l 0x815f460 0x15f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO32_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_PD_CTL (at 0x15f48)"
      tindex ezaxi:0xfc4cf980 %l 0x815f480 0x15f480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO32_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_CURRENT_LIM_CTL (at 0x15f4a)"
      tindex ezaxi:0xfc4cf980 %l 0x815f4a0 0x15f4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO32_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_SOFT_START_CTL (at 0x15f4c)"
      tindex ezaxi:0xfc4cf980 %l 0x815f4c0 0x15f4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO32_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_CONFIG_CTL (at 0x15f52)"
      tindex ezaxi:0xfc4cf980 %l 0x815f520 0x15f520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO32_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_LL_VOLTAGE_CTL1 (at 0x15f68)"
      tindex ezaxi:0xfc4cf980 %l 0x815f680 0x15f680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO32_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_LL_VOLTAGE_CTL2 (at 0x15f69)"
      tindex ezaxi:0xfc4cf980 %l 0x815f690 0x15f690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO32_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_UL_VOLTAGE_CTL1 (at 0x15f6a)"
      tindex ezaxi:0xfc4cf980 %l 0x815f6a0 0x15f6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO32_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_UL_VOLTAGE_CTL2 (at 0x15f6b)"
      tindex ezaxi:0xfc4cf980 %l 0x815f6b0 0x15f6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO32_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_SEC_ACCESS (at 0x15fd0)"
      tindex ezaxi:0xfc4cf980 %l 0x815fd00 0x15fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO32_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_PERPH_RESET_CTL1 (at 0x15fd8)"
      tindex ezaxi:0xfc4cf980 %l 0x815fd80 0x15fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO32_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_PERPH_RESET_CTL2 (at 0x15fd9)"
      tindex ezaxi:0xfc4cf980 %l 0x815fd90 0x15fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO32_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_PERPH_RESET_CTL3 (at 0x15fda)"
      tindex ezaxi:0xfc4cf980 %l 0x815fda0 0x15fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO32_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_PERPH_RESET_CTL4 (at 0x15fdb)"
      tindex ezaxi:0xfc4cf980 %l 0x815fdb0 0x15fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO32_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_TEST1 (at 0x15fe0)"
      tindex ezaxi:0xfc4cf980 %l 0x815fe00 0x15fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO32_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_INT_TEST_VAL (at 0x15fe1)"
      tindex ezaxi:0xfc4cf980 %l 0x815fe10 0x15fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO32_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_TEST1 (at 0x15fe2)"
      tindex ezaxi:0xfc4cf980 %l 0x815fe20 0x15fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO32_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_TEST2 (at 0x15fe3)"
      tindex ezaxi:0xfc4cf980 %l 0x815fe30 0x15fe30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO32_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_TRIM_NUM (at 0x15ff0)"
      tindex ezaxi:0xfc4cf980 %l 0x815ff00 0x15ff00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO32_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO32_TRIM_CTRL (at 0x15ff1)"
      tindex ezaxi:0xfc4cf980 %l 0x815ff10 0x15ff10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO4"
  tree "LDO4"
    tree "LDO4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_REVISION1 (at 0x14300)"
      tindex ezaxi:0xfc4cf980 %l 0x8143000 0x143000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_REVISION2 (at 0x14301)"
      tindex ezaxi:0xfc4cf980 %l 0x8143010 0x143010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO4_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_REVISION3 (at 0x14302)"
      tindex ezaxi:0xfc4cf980 %l 0x8143020 0x143020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO4_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_REVISION4 (at 0x14303)"
      tindex ezaxi:0xfc4cf980 %l 0x8143030 0x143030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_PERPH_TYPE (at 0x14304)"
      tindex ezaxi:0xfc4cf980 %l 0x8143040 0x143040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_PERPH_SUBTYPE (at 0x14305)"
      tindex ezaxi:0xfc4cf980 %l 0x8143050 0x143050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO4_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_STATUS1 (at 0x14308)"
      tindex ezaxi:0xfc4cf980 %l 0x8143080 0x143080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO4_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_STATUS2 (at 0x14309)"
      tindex ezaxi:0xfc4cf980 %l 0x8143090 0x143090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO4_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_STATUS3 (at 0x1430a)"
      tindex ezaxi:0xfc4cf980 %l 0x81430a0 0x1430a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_RT_STS (at 0x14310)"
      tindex ezaxi:0xfc4cf980 %l 0x8143100 0x143100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_SET_TYPE (at 0x14311)"
      tindex ezaxi:0xfc4cf980 %l 0x8143110 0x143110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_POLARITY_HIGH (at 0x14312)"
      tindex ezaxi:0xfc4cf980 %l 0x8143120 0x143120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_POLARITY_LOW (at 0x14313)"
      tindex ezaxi:0xfc4cf980 %l 0x8143130 0x143130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_LATCHED_CLR (at 0x14314)"
      tindex ezaxi:0xfc4cf980 %l 0x8143140 0x143140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_EN_SET (at 0x14315)"
      tindex ezaxi:0xfc4cf980 %l 0x8143150 0x143150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_EN_CLR (at 0x14316)"
      tindex ezaxi:0xfc4cf980 %l 0x8143160 0x143160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_LATCHED_STS (at 0x14318)"
      tindex ezaxi:0xfc4cf980 %l 0x8143180 0x143180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_PENDING_STS (at 0x14319)"
      tindex ezaxi:0xfc4cf980 %l 0x8143190 0x143190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_MID_SEL (at 0x1431a)"
      tindex ezaxi:0xfc4cf980 %l 0x81431a0 0x1431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_PRIORITY (at 0x1431b)"
      tindex ezaxi:0xfc4cf980 %l 0x81431b0 0x1431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO4_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_VOLTAGE_CTL1 (at 0x14340)"
      tindex ezaxi:0xfc4cf980 %l 0x8143400 0x143400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_VOLTAGE_CTL2 (at 0x14341)"
      tindex ezaxi:0xfc4cf980 %l 0x8143410 0x143410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO4_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_MODE_CTL2 (at 0x14345)"
      tindex ezaxi:0xfc4cf980 %l 0x8143450 0x143450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_EN_CTL (at 0x14346)"
      tindex ezaxi:0xfc4cf980 %l 0x8143460 0x143460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_PD_CTL (at 0x14348)"
      tindex ezaxi:0xfc4cf980 %l 0x8143480 0x143480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO4_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_CURRENT_LIM_CTL (at 0x1434a)"
      tindex ezaxi:0xfc4cf980 %l 0x81434a0 0x1434a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO4_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_SOFT_START_CTL (at 0x1434c)"
      tindex ezaxi:0xfc4cf980 %l 0x81434c0 0x1434c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO4_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_CONFIG_CTL (at 0x14352)"
      tindex ezaxi:0xfc4cf980 %l 0x8143520 0x143520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_LL_VOLTAGE_CTL1 (at 0x14368)"
      tindex ezaxi:0xfc4cf980 %l 0x8143680 0x143680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_LL_VOLTAGE_CTL2 (at 0x14369)"
      tindex ezaxi:0xfc4cf980 %l 0x8143690 0x143690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_UL_VOLTAGE_CTL1 (at 0x1436a)"
      tindex ezaxi:0xfc4cf980 %l 0x81436a0 0x1436a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_UL_VOLTAGE_CTL2 (at 0x1436b)"
      tindex ezaxi:0xfc4cf980 %l 0x81436b0 0x1436b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_SEC_ACCESS (at 0x143d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8143d00 0x143d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO4_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_PERPH_RESET_CTL1 (at 0x143d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8143d80 0x143d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_PERPH_RESET_CTL2 (at 0x143d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8143d90 0x143d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_PERPH_RESET_CTL3 (at 0x143da)"
      tindex ezaxi:0xfc4cf980 %l 0x8143da0 0x143da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_PERPH_RESET_CTL4 (at 0x143db)"
      tindex ezaxi:0xfc4cf980 %l 0x8143db0 0x143db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO4_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_TEST1 (at 0x143e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8143e00 0x143e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO4_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_INT_TEST_VAL (at 0x143e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8143e10 0x143e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO4_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_TEST1 (at 0x143e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8143e20 0x143e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO4_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_TEST2 (at 0x143e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8143e30 0x143e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO4_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_TRIM_NUM (at 0x143f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8143f00 0x143f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO4_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO4_TRIM_CTRL (at 0x143f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8143f10 0x143f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO5"
  tree "LDO5"
    tree "LDO5_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_REVISION1 (at 0x14400)"
      tindex ezaxi:0xfc4cf980 %l 0x8144000 0x144000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO5_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_REVISION2 (at 0x14401)"
      tindex ezaxi:0xfc4cf980 %l 0x8144010 0x144010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO5_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_REVISION3 (at 0x14402)"
      tindex ezaxi:0xfc4cf980 %l 0x8144020 0x144020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO5_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_REVISION4 (at 0x14403)"
      tindex ezaxi:0xfc4cf980 %l 0x8144030 0x144030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO5_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_PERPH_TYPE (at 0x14404)"
      tindex ezaxi:0xfc4cf980 %l 0x8144040 0x144040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO5_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_PERPH_SUBTYPE (at 0x14405)"
      tindex ezaxi:0xfc4cf980 %l 0x8144050 0x144050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO5_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_STATUS1 (at 0x14408)"
      tindex ezaxi:0xfc4cf980 %l 0x8144080 0x144080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO5_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_VOLTAGE_CTL1 (at 0x14440)"
      tindex ezaxi:0xfc4cf980 %l 0x8144400 0x144400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO5_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_VOLTAGE_CTL2 (at 0x14441)"
      tindex ezaxi:0xfc4cf980 %l 0x8144410 0x144410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_MODE_CTL2 (at 0x14445)"
      tindex ezaxi:0xfc4cf980 %l 0x8144450 0x144450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO5_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_EN_CTL (at 0x14446)"
      tindex ezaxi:0xfc4cf980 %l 0x8144460 0x144460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO5_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_SEC_ACCESS (at 0x144d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8144d00 0x144d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO5_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_PERPH_RESET_CTL1 (at 0x144d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8144d80 0x144d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_PERPH_RESET_CTL2 (at 0x144d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8144d90 0x144d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_PERPH_RESET_CTL3 (at 0x144da)"
      tindex ezaxi:0xfc4cf980 %l 0x8144da0 0x144da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_PERPH_RESET_CTL4 (at 0x144db)"
      tindex ezaxi:0xfc4cf980 %l 0x8144db0 0x144db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO5_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO5_TEST1 (at 0x144e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8144e20 0x144e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LDO6"
  tree "LDO6"
    tree "LDO6_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_REVISION1 (at 0x14500)"
      tindex ezaxi:0xfc4cf980 %l 0x8145000 0x145000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO6_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_REVISION2 (at 0x14501)"
      tindex ezaxi:0xfc4cf980 %l 0x8145010 0x145010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO6_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_REVISION3 (at 0x14502)"
      tindex ezaxi:0xfc4cf980 %l 0x8145020 0x145020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO6_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_REVISION4 (at 0x14503)"
      tindex ezaxi:0xfc4cf980 %l 0x8145030 0x145030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO6_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_PERPH_TYPE (at 0x14504)"
      tindex ezaxi:0xfc4cf980 %l 0x8145040 0x145040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO6_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_PERPH_SUBTYPE (at 0x14505)"
      tindex ezaxi:0xfc4cf980 %l 0x8145050 0x145050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO6_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_STATUS1 (at 0x14508)"
      tindex ezaxi:0xfc4cf980 %l 0x8145080 0x145080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO6_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_STATUS2 (at 0x14509)"
      tindex ezaxi:0xfc4cf980 %l 0x8145090 0x145090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO6_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_STATUS3 (at 0x1450a)"
      tindex ezaxi:0xfc4cf980 %l 0x81450a0 0x1450a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO6_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_RT_STS (at 0x14510)"
      tindex ezaxi:0xfc4cf980 %l 0x8145100 0x145100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_SET_TYPE (at 0x14511)"
      tindex ezaxi:0xfc4cf980 %l 0x8145110 0x145110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_POLARITY_HIGH (at 0x14512)"
      tindex ezaxi:0xfc4cf980 %l 0x8145120 0x145120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_POLARITY_LOW (at 0x14513)"
      tindex ezaxi:0xfc4cf980 %l 0x8145130 0x145130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO6_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_LATCHED_CLR (at 0x14514)"
      tindex ezaxi:0xfc4cf980 %l 0x8145140 0x145140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO6_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_EN_SET (at 0x14515)"
      tindex ezaxi:0xfc4cf980 %l 0x8145150 0x145150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_EN_CLR (at 0x14516)"
      tindex ezaxi:0xfc4cf980 %l 0x8145160 0x145160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_LATCHED_STS (at 0x14518)"
      tindex ezaxi:0xfc4cf980 %l 0x8145180 0x145180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO6_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_PENDING_STS (at 0x14519)"
      tindex ezaxi:0xfc4cf980 %l 0x8145190 0x145190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_MID_SEL (at 0x1451a)"
      tindex ezaxi:0xfc4cf980 %l 0x81451a0 0x1451a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO6_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_PRIORITY (at 0x1451b)"
      tindex ezaxi:0xfc4cf980 %l 0x81451b0 0x1451b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO6_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_VOLTAGE_CTL1 (at 0x14540)"
      tindex ezaxi:0xfc4cf980 %l 0x8145400 0x145400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_VOLTAGE_CTL2 (at 0x14541)"
      tindex ezaxi:0xfc4cf980 %l 0x8145410 0x145410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO6_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_MODE_CTL2 (at 0x14545)"
      tindex ezaxi:0xfc4cf980 %l 0x8145450 0x145450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_EN_CTL (at 0x14546)"
      tindex ezaxi:0xfc4cf980 %l 0x8145460 0x145460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_PD_CTL (at 0x14548)"
      tindex ezaxi:0xfc4cf980 %l 0x8145480 0x145480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO6_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_CURRENT_LIM_CTL (at 0x1454a)"
      tindex ezaxi:0xfc4cf980 %l 0x81454a0 0x1454a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO6_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_SOFT_START_CTL (at 0x1454c)"
      tindex ezaxi:0xfc4cf980 %l 0x81454c0 0x1454c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO6_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_CONFIG_CTL (at 0x14552)"
      tindex ezaxi:0xfc4cf980 %l 0x8145520 0x145520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_LL_VOLTAGE_CTL1 (at 0x14568)"
      tindex ezaxi:0xfc4cf980 %l 0x8145680 0x145680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_LL_VOLTAGE_CTL2 (at 0x14569)"
      tindex ezaxi:0xfc4cf980 %l 0x8145690 0x145690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_UL_VOLTAGE_CTL1 (at 0x1456a)"
      tindex ezaxi:0xfc4cf980 %l 0x81456a0 0x1456a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_UL_VOLTAGE_CTL2 (at 0x1456b)"
      tindex ezaxi:0xfc4cf980 %l 0x81456b0 0x1456b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO6_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_SEC_ACCESS (at 0x145d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8145d00 0x145d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO6_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_PERPH_RESET_CTL1 (at 0x145d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8145d80 0x145d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_PERPH_RESET_CTL2 (at 0x145d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8145d90 0x145d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_PERPH_RESET_CTL3 (at 0x145da)"
      tindex ezaxi:0xfc4cf980 %l 0x8145da0 0x145da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_PERPH_RESET_CTL4 (at 0x145db)"
      tindex ezaxi:0xfc4cf980 %l 0x8145db0 0x145db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO6_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_TEST1 (at 0x145e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8145e00 0x145e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO6_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_INT_TEST_VAL (at 0x145e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8145e10 0x145e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO6_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_TEST1 (at 0x145e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8145e20 0x145e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO6_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_TEST2 (at 0x145e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8145e30 0x145e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO6_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_TRIM_NUM (at 0x145f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8145f00 0x145f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO6_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO6_TRIM_CTRL (at 0x145f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8145f10 0x145f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO7"
  tree "LDO7"
    tree "LDO7_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_REVISION1 (at 0x14600)"
      tindex ezaxi:0xfc4cf980 %l 0x8146000 0x146000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO7_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_REVISION2 (at 0x14601)"
      tindex ezaxi:0xfc4cf980 %l 0x8146010 0x146010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO7_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_REVISION3 (at 0x14602)"
      tindex ezaxi:0xfc4cf980 %l 0x8146020 0x146020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO7_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_REVISION4 (at 0x14603)"
      tindex ezaxi:0xfc4cf980 %l 0x8146030 0x146030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO7_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_PERPH_TYPE (at 0x14604)"
      tindex ezaxi:0xfc4cf980 %l 0x8146040 0x146040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO7_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_PERPH_SUBTYPE (at 0x14605)"
      tindex ezaxi:0xfc4cf980 %l 0x8146050 0x146050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO7_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_STATUS1 (at 0x14608)"
      tindex ezaxi:0xfc4cf980 %l 0x8146080 0x146080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
    tree.end
    tree "LDO7_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_VOLTAGE_CTL1 (at 0x14640)"
      tindex ezaxi:0xfc4cf980 %l 0x8146400 0x146400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_0),1 (RANGE_1)"
    tree.end
    tree "LDO7_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_VOLTAGE_CTL2 (at 0x14641)"
      tindex ezaxi:0xfc4cf980 %l 0x8146410 0x146410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_MODE_CTL2 (at 0x14645)"
      tindex ezaxi:0xfc4cf980 %l 0x8146450 0x146450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "LDO7_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_EN_CTL (at 0x14646)"
      tindex ezaxi:0xfc4cf980 %l 0x8146460 0x146460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "LDO7_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_SEC_ACCESS (at 0x146d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8146d00 0x146d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO7_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_PERPH_RESET_CTL1 (at 0x146d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8146d80 0x146d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_PERPH_RESET_CTL2 (at 0x146d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8146d90 0x146d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_PERPH_RESET_CTL3 (at 0x146da)"
      tindex ezaxi:0xfc4cf980 %l 0x8146da0 0x146da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_PERPH_RESET_CTL4 (at 0x146db)"
      tindex ezaxi:0xfc4cf980 %l 0x8146db0 0x146db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
