      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO7_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO7_TEST1 (at 0x146e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8146e20 0x146e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0 (ATEST1_HIGHZ),1 (ATEST1_VREG_OUT)"
    tree.end
  tree.end
tree.end
tree "LDO8"
  tree "LDO8"
    tree "LDO8_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_REVISION1 (at 0x14700)"
      tindex ezaxi:0xfc4cf980 %l 0x8147000 0x147000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO8_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_REVISION2 (at 0x14701)"
      tindex ezaxi:0xfc4cf980 %l 0x8147010 0x147010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO8_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_REVISION3 (at 0x14702)"
      tindex ezaxi:0xfc4cf980 %l 0x8147020 0x147020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO8_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_REVISION4 (at 0x14703)"
      tindex ezaxi:0xfc4cf980 %l 0x8147030 0x147030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO8_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_PERPH_TYPE (at 0x14704)"
      tindex ezaxi:0xfc4cf980 %l 0x8147040 0x147040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO8_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_PERPH_SUBTYPE (at 0x14705)"
      tindex ezaxi:0xfc4cf980 %l 0x8147050 0x147050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO8_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_STATUS1 (at 0x14708)"
      tindex ezaxi:0xfc4cf980 %l 0x8147080 0x147080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO8_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_STATUS2 (at 0x14709)"
      tindex ezaxi:0xfc4cf980 %l 0x8147090 0x147090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO8_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_STATUS3 (at 0x1470a)"
      tindex ezaxi:0xfc4cf980 %l 0x81470a0 0x1470a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO8_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_RT_STS (at 0x14710)"
      tindex ezaxi:0xfc4cf980 %l 0x8147100 0x147100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_SET_TYPE (at 0x14711)"
      tindex ezaxi:0xfc4cf980 %l 0x8147110 0x147110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_POLARITY_HIGH (at 0x14712)"
      tindex ezaxi:0xfc4cf980 %l 0x8147120 0x147120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_POLARITY_LOW (at 0x14713)"
      tindex ezaxi:0xfc4cf980 %l 0x8147130 0x147130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO8_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_LATCHED_CLR (at 0x14714)"
      tindex ezaxi:0xfc4cf980 %l 0x8147140 0x147140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO8_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_EN_SET (at 0x14715)"
      tindex ezaxi:0xfc4cf980 %l 0x8147150 0x147150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_EN_CLR (at 0x14716)"
      tindex ezaxi:0xfc4cf980 %l 0x8147160 0x147160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_LATCHED_STS (at 0x14718)"
      tindex ezaxi:0xfc4cf980 %l 0x8147180 0x147180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO8_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_PENDING_STS (at 0x14719)"
      tindex ezaxi:0xfc4cf980 %l 0x8147190 0x147190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_MID_SEL (at 0x1471a)"
      tindex ezaxi:0xfc4cf980 %l 0x81471a0 0x1471a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO8_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_PRIORITY (at 0x1471b)"
      tindex ezaxi:0xfc4cf980 %l 0x81471b0 0x1471b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO8_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_VOLTAGE_CTL1 (at 0x14740)"
      tindex ezaxi:0xfc4cf980 %l 0x8147400 0x147400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_VOLTAGE_CTL2 (at 0x14741)"
      tindex ezaxi:0xfc4cf980 %l 0x8147410 0x147410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO8_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_MODE_CTL2 (at 0x14745)"
      tindex ezaxi:0xfc4cf980 %l 0x8147450 0x147450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_EN_CTL (at 0x14746)"
      tindex ezaxi:0xfc4cf980 %l 0x8147460 0x147460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_PD_CTL (at 0x14748)"
      tindex ezaxi:0xfc4cf980 %l 0x8147480 0x147480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO8_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_CURRENT_LIM_CTL (at 0x1474a)"
      tindex ezaxi:0xfc4cf980 %l 0x81474a0 0x1474a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO8_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_SOFT_START_CTL (at 0x1474c)"
      tindex ezaxi:0xfc4cf980 %l 0x81474c0 0x1474c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO8_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_CONFIG_CTL (at 0x14752)"
      tindex ezaxi:0xfc4cf980 %l 0x8147520 0x147520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_LL_VOLTAGE_CTL1 (at 0x14768)"
      tindex ezaxi:0xfc4cf980 %l 0x8147680 0x147680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_LL_VOLTAGE_CTL2 (at 0x14769)"
      tindex ezaxi:0xfc4cf980 %l 0x8147690 0x147690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_UL_VOLTAGE_CTL1 (at 0x1476a)"
      tindex ezaxi:0xfc4cf980 %l 0x81476a0 0x1476a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_UL_VOLTAGE_CTL2 (at 0x1476b)"
      tindex ezaxi:0xfc4cf980 %l 0x81476b0 0x1476b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO8_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_SEC_ACCESS (at 0x147d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8147d00 0x147d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO8_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_PERPH_RESET_CTL1 (at 0x147d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8147d80 0x147d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_PERPH_RESET_CTL2 (at 0x147d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8147d90 0x147d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_PERPH_RESET_CTL3 (at 0x147da)"
      tindex ezaxi:0xfc4cf980 %l 0x8147da0 0x147da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_PERPH_RESET_CTL4 (at 0x147db)"
      tindex ezaxi:0xfc4cf980 %l 0x8147db0 0x147db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO8_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_TEST1 (at 0x147e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8147e00 0x147e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO8_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_INT_TEST_VAL (at 0x147e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8147e10 0x147e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO8_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_TEST1 (at 0x147e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8147e20 0x147e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO8_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_TEST2 (at 0x147e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8147e30 0x147e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO8_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_TRIM_NUM (at 0x147f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8147f00 0x147f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO8_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO8_TRIM_CTRL (at 0x147f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8147f10 0x147f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO9"
  tree "LDO9"
    tree "LDO9_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_REVISION1 (at 0x14800)"
      tindex ezaxi:0xfc4cf980 %l 0x8148000 0x148000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO9_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_REVISION2 (at 0x14801)"
      tindex ezaxi:0xfc4cf980 %l 0x8148010 0x148010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO9_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_REVISION3 (at 0x14802)"
      tindex ezaxi:0xfc4cf980 %l 0x8148020 0x148020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO9_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_REVISION4 (at 0x14803)"
      tindex ezaxi:0xfc4cf980 %l 0x8148030 0x148030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO9_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_PERPH_TYPE (at 0x14804)"
      tindex ezaxi:0xfc4cf980 %l 0x8148040 0x148040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO9_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_PERPH_SUBTYPE (at 0x14805)"
      tindex ezaxi:0xfc4cf980 %l 0x8148050 0x148050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO9_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_STATUS1 (at 0x14808)"
      tindex ezaxi:0xfc4cf980 %l 0x8148080 0x148080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO9_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_STATUS2 (at 0x14809)"
      tindex ezaxi:0xfc4cf980 %l 0x8148090 0x148090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO9_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_STATUS3 (at 0x1480a)"
      tindex ezaxi:0xfc4cf980 %l 0x81480a0 0x1480a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO9_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_RT_STS (at 0x14810)"
      tindex ezaxi:0xfc4cf980 %l 0x8148100 0x148100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_SET_TYPE (at 0x14811)"
      tindex ezaxi:0xfc4cf980 %l 0x8148110 0x148110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_POLARITY_HIGH (at 0x14812)"
      tindex ezaxi:0xfc4cf980 %l 0x8148120 0x148120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_POLARITY_LOW (at 0x14813)"
      tindex ezaxi:0xfc4cf980 %l 0x8148130 0x148130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO9_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_LATCHED_CLR (at 0x14814)"
      tindex ezaxi:0xfc4cf980 %l 0x8148140 0x148140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO9_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_EN_SET (at 0x14815)"
      tindex ezaxi:0xfc4cf980 %l 0x8148150 0x148150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_EN_CLR (at 0x14816)"
      tindex ezaxi:0xfc4cf980 %l 0x8148160 0x148160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_LATCHED_STS (at 0x14818)"
      tindex ezaxi:0xfc4cf980 %l 0x8148180 0x148180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO9_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_PENDING_STS (at 0x14819)"
      tindex ezaxi:0xfc4cf980 %l 0x8148190 0x148190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_MID_SEL (at 0x1481a)"
      tindex ezaxi:0xfc4cf980 %l 0x81481a0 0x1481a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO9_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_PRIORITY (at 0x1481b)"
      tindex ezaxi:0xfc4cf980 %l 0x81481b0 0x1481b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO9_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_VOLTAGE_CTL1 (at 0x14840)"
      tindex ezaxi:0xfc4cf980 %l 0x8148400 0x148400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_VOLTAGE_CTL2 (at 0x14841)"
      tindex ezaxi:0xfc4cf980 %l 0x8148410 0x148410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO9_MODE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_MODE_CTL2 (at 0x14845)"
      tindex ezaxi:0xfc4cf980 %l 0x8148450 0x148450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_EN_CTL (at 0x14846)"
      tindex ezaxi:0xfc4cf980 %l 0x8148460 0x148460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_PD_CTL (at 0x14848)"
      tindex ezaxi:0xfc4cf980 %l 0x8148480 0x148480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO9_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_CURRENT_LIM_CTL (at 0x1484a)"
      tindex ezaxi:0xfc4cf980 %l 0x81484a0 0x1484a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO9_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_SOFT_START_CTL (at 0x1484c)"
      tindex ezaxi:0xfc4cf980 %l 0x81484c0 0x1484c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO9_CONFIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_CONFIG_CTL (at 0x14852)"
      tindex ezaxi:0xfc4cf980 %l 0x8148520 0x148520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_LL_VOLTAGE_CTL1 (at 0x14868)"
      tindex ezaxi:0xfc4cf980 %l 0x8148680 0x148680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_LL_VOLTAGE_CTL2 (at 0x14869)"
      tindex ezaxi:0xfc4cf980 %l 0x8148690 0x148690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_UL_VOLTAGE_CTL1 (at 0x1486a)"
      tindex ezaxi:0xfc4cf980 %l 0x81486a0 0x1486a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_UL_VOLTAGE_CTL2 (at 0x1486b)"
      tindex ezaxi:0xfc4cf980 %l 0x81486b0 0x1486b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO9_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_SEC_ACCESS (at 0x148d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8148d00 0x148d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO9_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_PERPH_RESET_CTL1 (at 0x148d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8148d80 0x148d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_PERPH_RESET_CTL2 (at 0x148d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8148d90 0x148d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_PERPH_RESET_CTL3 (at 0x148da)"
      tindex ezaxi:0xfc4cf980 %l 0x8148da0 0x148da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_PERPH_RESET_CTL4 (at 0x148db)"
      tindex ezaxi:0xfc4cf980 %l 0x8148db0 0x148db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO9_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_TEST1 (at 0x148e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8148e00 0x148e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO9_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_INT_TEST_VAL (at 0x148e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8148e10 0x148e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO9_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_TEST1 (at 0x148e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8148e20 0x148e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO9_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_TEST2 (at 0x148e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8148e30 0x148e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO9_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_TRIM_NUM (at 0x148f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8148f00 0x148f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO9_TRIM_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LDO9_TRIM_CTRL (at 0x148f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8148f10 0x148f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LN_BB_CLK"
  tree "LN_BB_CLK"
    tree "LN_BB_CLK_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_REVISION1 (at 0x5800)"
      tindex ezaxi:0xfc4cf980 %l 0x8058000 0x58000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_REVISION2 (at 0x5801)"
      tindex ezaxi:0xfc4cf980 %l 0x8058010 0x58010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_REVISION3 (at 0x5802)"
      tindex ezaxi:0xfc4cf980 %l 0x8058020 0x58020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_REVISION4 (at 0x5803)"
      tindex ezaxi:0xfc4cf980 %l 0x8058030 0x58030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_PERPH_TYPE (at 0x5804)"
      tindex ezaxi:0xfc4cf980 %l 0x8058040 0x58040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LN_BB_CLK_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_PERPH_SUBTYPE (at 0x5805)"
      tindex ezaxi:0xfc4cf980 %l 0x8058050 0x58050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LN_BB_CLK_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_STATUS1 (at 0x5808)"
      tindex ezaxi:0xfc4cf980 %l 0x8058080 0x58080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
    tree.end
    tree "LN_BB_CLK_EDGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_EDGE_CTL1 (at 0x5843)"
      tindex ezaxi:0xfc4cf980 %l 0x8058430 0x58430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "LN_BB_CLK_DRV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_DRV_CTL1 (at 0x5844)"
      tindex ezaxi:0xfc4cf980 %l 0x8058440 0x58440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "LN_BB_CLK_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_EN_CTL (at 0x5846)"
      tindex ezaxi:0xfc4cf980 %l 0x8058460 0x58460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "LN_BB_CLK_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_PD_CTL (at 0x5848)"
      tindex ezaxi:0xfc4cf980 %l 0x8058480 0x58480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "LN_BB_CLK_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_SEC_ACCESS (at 0x58d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8058d00 0x58d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_PERPH_RESET_CTL1 (at 0x58d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8058d80 0x58d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_PERPH_RESET_CTL2 (at 0x58d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8058d90 0x58d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_PERPH_RESET_CTL3 (at 0x58da)"
      tindex ezaxi:0xfc4cf980 %l 0x8058da0 0x58da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LN_BB_CLK_PERPH_RESET_CTL4 (at 0x58db)"
      tindex ezaxi:0xfc4cf980 %l 0x8058db0 0x58db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN1"
  tree "LPG_CHAN1"
    tree "LPG_CHAN1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_REVISION1 (at 0x1b100)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1000 0x1b1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_REVISION2 (at 0x1b101)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1010 0x1b1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_TYPE (at 0x1b104)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1040 0x1b1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_SUBTYPE (at 0x1b105)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1050 0x1b1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_RT_STS (at 0x1b110)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1100 0x1b1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_SET_TYPE (at 0x1b111)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1110 0x1b1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_POLARITY_HIGH (at 0x1b112)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1120 0x1b1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_POLARITY_LOW (at 0x1b113)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1130 0x1b1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_LATCHED_CLR (at 0x1b114)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1140 0x1b1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_EN_SET (at 0x1b115)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1150 0x1b1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_EN_CLR (at 0x1b116)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1160 0x1b1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_LATCHED_STS (at 0x1b118)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1180 0x1b1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_PENDING_STS (at 0x1b119)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1190 0x1b1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_MID_SEL (at 0x1b11a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b11a0 0x1b11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_PRIORITY (at 0x1b11b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b11b0 0x1b11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN1_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PATTERN_CONFIG (at 0x1b140)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1400 0x1b1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PWM_SIZE_CLK (at 0x1b141)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1410 0x1b1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b142)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1420 0x1b1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LPG_PWM_TYPE_CONFIG (at 0x1b143)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1430 0x1b1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PWM_VALUE_LSB (at 0x1b144)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1440 0x1b1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PWM_VALUE_MSB (at 0x1b145)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1450 0x1b1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN1_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_ENABLE_CONTROL (at 0x1b146)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1460 0x1b1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_RAMP_STEP_DURATION_LSB (at 0x1b150)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1500 0x1b1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_RAMP_STEP_DURATION_MSB (at 0x1b151)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1510 0x1b1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN1_PAUSE_HI_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PAUSE_HI_MULTIPLIER_LSB (at 0x1b152)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1520 0x1b1520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN1_PAUSE_HI_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PAUSE_HI_MULTIPLIER_MSB (at 0x1b153)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1530 0x1b1530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN1_PAUSE_LO_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PAUSE_LO_MULTIPLIER_LSB (at 0x1b154)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1540 0x1b1540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN1_PAUSE_LO_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PAUSE_LO_MULTIPLIER_MSB (at 0x1b155)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1550 0x1b1550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN1_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_HI_INDEX (at 0x1b156)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1560 0x1b1560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_LO_INDEX (at 0x1b157)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1570 0x1b1570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_SEC_ACCESS (at 0x1b1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1d00 0x1b1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_RESET_CTL2 (at 0x1b1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1d90 0x1b1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_RESET_CTL3 (at 0x1b1da)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1da0 0x1b1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_PERPH_RESET_CTL4 (at 0x1b1db)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1db0 0x1b1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_TEST1 (at 0x1b1e0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1e00 0x1b1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_INT_TEST_VAL (at 0x1b1e1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1e10 0x1b1e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST1 (at 0x1b1e2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1e20 0x1b1e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN1_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST2 (at 0x1b1e3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1e30 0x1b1e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN1_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST3 (at 0x1b1e4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1e40 0x1b1e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN1_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN1_TEST4 (at 0x1b1e5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b1e50 0x1b1e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN2"
  tree "LPG_CHAN2"
    tree "LPG_CHAN2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_REVISION1 (at 0x1b200)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2000 0x1b2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_REVISION2 (at 0x1b201)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2010 0x1b2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_TYPE (at 0x1b204)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2040 0x1b2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_SUBTYPE (at 0x1b205)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2050 0x1b2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_RT_STS (at 0x1b210)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2100 0x1b2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_SET_TYPE (at 0x1b211)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2110 0x1b2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_POLARITY_HIGH (at 0x1b212)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2120 0x1b2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_POLARITY_LOW (at 0x1b213)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2130 0x1b2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_LATCHED_CLR (at 0x1b214)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2140 0x1b2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_EN_SET (at 0x1b215)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2150 0x1b2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_EN_CLR (at 0x1b216)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2160 0x1b2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_LATCHED_STS (at 0x1b218)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2180 0x1b2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_PENDING_STS (at 0x1b219)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2190 0x1b2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_MID_SEL (at 0x1b21a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b21a0 0x1b21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_PRIORITY (at 0x1b21b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b21b0 0x1b21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN2_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PATTERN_CONFIG (at 0x1b240)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2400 0x1b2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PWM_SIZE_CLK (at 0x1b241)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2410 0x1b2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b242)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2420 0x1b2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LPG_PWM_TYPE_CONFIG (at 0x1b243)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2430 0x1b2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PWM_VALUE_LSB (at 0x1b244)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2440 0x1b2440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PWM_VALUE_MSB (at 0x1b245)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2450 0x1b2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN2_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_ENABLE_CONTROL (at 0x1b246)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2460 0x1b2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_RAMP_STEP_DURATION_LSB (at 0x1b250)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2500 0x1b2500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_RAMP_STEP_DURATION_MSB (at 0x1b251)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2510 0x1b2510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN2_PAUSE_HI_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PAUSE_HI_MULTIPLIER_LSB (at 0x1b252)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2520 0x1b2520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN2_PAUSE_HI_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PAUSE_HI_MULTIPLIER_MSB (at 0x1b253)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2530 0x1b2530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN2_PAUSE_LO_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PAUSE_LO_MULTIPLIER_LSB (at 0x1b254)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2540 0x1b2540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN2_PAUSE_LO_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PAUSE_LO_MULTIPLIER_MSB (at 0x1b255)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2550 0x1b2550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN2_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_HI_INDEX (at 0x1b256)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2560 0x1b2560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_LO_INDEX (at 0x1b257)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2570 0x1b2570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_SEC_ACCESS (at 0x1b2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2d00 0x1b2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_RESET_CTL2 (at 0x1b2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2d90 0x1b2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_RESET_CTL3 (at 0x1b2da)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2da0 0x1b2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_PERPH_RESET_CTL4 (at 0x1b2db)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2db0 0x1b2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_TEST1 (at 0x1b2e0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2e00 0x1b2e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_INT_TEST_VAL (at 0x1b2e1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2e10 0x1b2e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN2_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST1 (at 0x1b2e2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2e20 0x1b2e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN2_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST2 (at 0x1b2e3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2e30 0x1b2e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN2_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST3 (at 0x1b2e4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2e40 0x1b2e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN2_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN2_TEST4 (at 0x1b2e5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b2e50 0x1b2e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN3"
  tree "LPG_CHAN3"
    tree "LPG_CHAN3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_REVISION1 (at 0x1b300)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3000 0x1b3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_REVISION2 (at 0x1b301)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3010 0x1b3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_TYPE (at 0x1b304)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3040 0x1b3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_SUBTYPE (at 0x1b305)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3050 0x1b3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_RT_STS (at 0x1b310)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3100 0x1b3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_SET_TYPE (at 0x1b311)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3110 0x1b3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_POLARITY_HIGH (at 0x1b312)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3120 0x1b3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_POLARITY_LOW (at 0x1b313)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3130 0x1b3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_LATCHED_CLR (at 0x1b314)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3140 0x1b3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_EN_SET (at 0x1b315)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3150 0x1b3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_EN_CLR (at 0x1b316)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3160 0x1b3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_LATCHED_STS (at 0x1b318)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3180 0x1b3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_PENDING_STS (at 0x1b319)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3190 0x1b3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_MID_SEL (at 0x1b31a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b31a0 0x1b31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_PRIORITY (at 0x1b31b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b31b0 0x1b31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN3_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PATTERN_CONFIG (at 0x1b340)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3400 0x1b3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PWM_SIZE_CLK (at 0x1b341)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3410 0x1b3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b342)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3420 0x1b3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LPG_PWM_TYPE_CONFIG (at 0x1b343)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3430 0x1b3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PWM_VALUE_LSB (at 0x1b344)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3440 0x1b3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PWM_VALUE_MSB (at 0x1b345)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3450 0x1b3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN3_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_ENABLE_CONTROL (at 0x1b346)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3460 0x1b3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_RAMP_STEP_DURATION_LSB (at 0x1b350)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3500 0x1b3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_RAMP_STEP_DURATION_MSB (at 0x1b351)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3510 0x1b3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN3_PAUSE_HI_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PAUSE_HI_MULTIPLIER_LSB (at 0x1b352)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3520 0x1b3520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN3_PAUSE_HI_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PAUSE_HI_MULTIPLIER_MSB (at 0x1b353)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3530 0x1b3530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN3_PAUSE_LO_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PAUSE_LO_MULTIPLIER_LSB (at 0x1b354)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3540 0x1b3540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN3_PAUSE_LO_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PAUSE_LO_MULTIPLIER_MSB (at 0x1b355)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3550 0x1b3550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN3_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_HI_INDEX (at 0x1b356)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3560 0x1b3560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_LO_INDEX (at 0x1b357)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3570 0x1b3570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_SEC_ACCESS (at 0x1b3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3d00 0x1b3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_RESET_CTL2 (at 0x1b3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3d90 0x1b3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_RESET_CTL3 (at 0x1b3da)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3da0 0x1b3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_PERPH_RESET_CTL4 (at 0x1b3db)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3db0 0x1b3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_TEST1 (at 0x1b3e0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3e00 0x1b3e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_INT_TEST_VAL (at 0x1b3e1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3e10 0x1b3e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN3_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST1 (at 0x1b3e2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3e20 0x1b3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN3_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST2 (at 0x1b3e3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3e30 0x1b3e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN3_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST3 (at 0x1b3e4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3e40 0x1b3e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN3_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN3_TEST4 (at 0x1b3e5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b3e50 0x1b3e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN4"
  tree "LPG_CHAN4"
    tree "LPG_CHAN4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_REVISION1 (at 0x1b400)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4000 0x1b4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_REVISION2 (at 0x1b401)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4010 0x1b4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_TYPE (at 0x1b404)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4040 0x1b4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_SUBTYPE (at 0x1b405)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4050 0x1b4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_RT_STS (at 0x1b410)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4100 0x1b4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_SET_TYPE (at 0x1b411)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4110 0x1b4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_POLARITY_HIGH (at 0x1b412)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4120 0x1b4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_POLARITY_LOW (at 0x1b413)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4130 0x1b4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_LATCHED_CLR (at 0x1b414)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4140 0x1b4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_EN_SET (at 0x1b415)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4150 0x1b4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_EN_CLR (at 0x1b416)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4160 0x1b4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_LATCHED_STS (at 0x1b418)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4180 0x1b4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_PENDING_STS (at 0x1b419)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4190 0x1b4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_MID_SEL (at 0x1b41a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b41a0 0x1b41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_PRIORITY (at 0x1b41b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b41b0 0x1b41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN4_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PATTERN_CONFIG (at 0x1b440)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4400 0x1b4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PWM_SIZE_CLK (at 0x1b441)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4410 0x1b4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b442)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4420 0x1b4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LPG_PWM_TYPE_CONFIG (at 0x1b443)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4430 0x1b4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PWM_VALUE_LSB (at 0x1b444)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4440 0x1b4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PWM_VALUE_MSB (at 0x1b445)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4450 0x1b4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN4_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_ENABLE_CONTROL (at 0x1b446)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4460 0x1b4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_RAMP_STEP_DURATION_LSB (at 0x1b450)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4500 0x1b4500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_RAMP_STEP_DURATION_MSB (at 0x1b451)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4510 0x1b4510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN4_PAUSE_HI_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PAUSE_HI_MULTIPLIER_LSB (at 0x1b452)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4520 0x1b4520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN4_PAUSE_HI_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PAUSE_HI_MULTIPLIER_MSB (at 0x1b453)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4530 0x1b4530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN4_PAUSE_LO_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PAUSE_LO_MULTIPLIER_LSB (at 0x1b454)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4540 0x1b4540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN4_PAUSE_LO_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PAUSE_LO_MULTIPLIER_MSB (at 0x1b455)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4550 0x1b4550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN4_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_HI_INDEX (at 0x1b456)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4560 0x1b4560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_LO_INDEX (at 0x1b457)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4570 0x1b4570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_SEC_ACCESS (at 0x1b4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4d00 0x1b4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_RESET_CTL2 (at 0x1b4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4d90 0x1b4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_RESET_CTL3 (at 0x1b4da)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4da0 0x1b4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_PERPH_RESET_CTL4 (at 0x1b4db)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4db0 0x1b4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_TEST1 (at 0x1b4e0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4e00 0x1b4e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_INT_TEST_VAL (at 0x1b4e1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4e10 0x1b4e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN4_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST1 (at 0x1b4e2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4e20 0x1b4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN4_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST2 (at 0x1b4e3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4e30 0x1b4e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN4_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST3 (at 0x1b4e4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4e40 0x1b4e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN4_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN4_TEST4 (at 0x1b4e5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b4e50 0x1b4e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN5"
  tree "LPG_CHAN5"
    tree "LPG_CHAN5_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_REVISION1 (at 0x1b500)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5000 0x1b5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN5_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_REVISION2 (at 0x1b501)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5010 0x1b5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN5_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PERPH_TYPE (at 0x1b504)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5040 0x1b5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN5_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PERPH_SUBTYPE (at 0x1b505)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5050 0x1b5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN5_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_RT_STS (at 0x1b510)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5100 0x1b5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN5_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_SET_TYPE (at 0x1b511)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5110 0x1b5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN5_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_POLARITY_HIGH (at 0x1b512)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5120 0x1b5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_POLARITY_LOW (at 0x1b513)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5130 0x1b5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_LATCHED_CLR (at 0x1b514)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5140 0x1b5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN5_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_EN_SET (at 0x1b515)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5150 0x1b5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_EN_CLR (at 0x1b516)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5160 0x1b5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_LATCHED_STS (at 0x1b518)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5180 0x1b5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN5_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_PENDING_STS (at 0x1b519)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5190 0x1b5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN5_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_MID_SEL (at 0x1b51a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b51a0 0x1b51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN5_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_PRIORITY (at 0x1b51b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b51b0 0x1b51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN5_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_LPG_PATTERN_CONFIG (at 0x1b540)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5400 0x1b5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_LPG_PWM_SIZE_CLK (at 0x1b541)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5410 0x1b5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b542)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5420 0x1b5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_LPG_PWM_TYPE_CONFIG (at 0x1b543)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5430 0x1b5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN5_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PWM_VALUE_LSB (at 0x1b544)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5440 0x1b5440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN5_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PWM_VALUE_MSB (at 0x1b545)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5450 0x1b5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN5_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_ENABLE_CONTROL (at 0x1b546)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5460 0x1b5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN5_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_RAMP_STEP_DURATION_LSB (at 0x1b550)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5500 0x1b5500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN5_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_RAMP_STEP_DURATION_MSB (at 0x1b551)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5510 0x1b5510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN5_PAUSE_HI_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PAUSE_HI_MULTIPLIER_LSB (at 0x1b552)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5520 0x1b5520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN5_PAUSE_HI_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PAUSE_HI_MULTIPLIER_MSB (at 0x1b553)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5530 0x1b5530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN5_PAUSE_LO_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PAUSE_LO_MULTIPLIER_LSB (at 0x1b554)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5540 0x1b5540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN5_PAUSE_LO_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PAUSE_LO_MULTIPLIER_MSB (at 0x1b555)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5550 0x1b5550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN5_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_HI_INDEX (at 0x1b556)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5560 0x1b5560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN5_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_LO_INDEX (at 0x1b557)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5570 0x1b5570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN5_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_SEC_ACCESS (at 0x1b5d0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5d00 0x1b5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PERPH_RESET_CTL2 (at 0x1b5d9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5d90 0x1b5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PERPH_RESET_CTL3 (at 0x1b5da)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5da0 0x1b5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_PERPH_RESET_CTL4 (at 0x1b5db)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5db0 0x1b5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN5_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_TEST1 (at 0x1b5e0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5e00 0x1b5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_INT_TEST_VAL (at 0x1b5e1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5e10 0x1b5e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN5_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_TEST1 (at 0x1b5e2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5e20 0x1b5e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN5_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_TEST2 (at 0x1b5e3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5e30 0x1b5e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN5_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_TEST3 (at 0x1b5e4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5e40 0x1b5e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN5_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN5_TEST4 (at 0x1b5e5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b5e50 0x1b5e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN6"
  tree "LPG_CHAN6"
    tree "LPG_CHAN6_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_REVISION1 (at 0x1b600)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6000 0x1b6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN6_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_REVISION2 (at 0x1b601)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6010 0x1b6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN6_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PERPH_TYPE (at 0x1b604)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6040 0x1b6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN6_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PERPH_SUBTYPE (at 0x1b605)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6050 0x1b6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN6_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_RT_STS (at 0x1b610)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6100 0x1b6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN6_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_SET_TYPE (at 0x1b611)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6110 0x1b6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN6_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_POLARITY_HIGH (at 0x1b612)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6120 0x1b6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_POLARITY_LOW (at 0x1b613)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6130 0x1b6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_LATCHED_CLR (at 0x1b614)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6140 0x1b6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN6_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_EN_SET (at 0x1b615)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6150 0x1b6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_EN_CLR (at 0x1b616)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6160 0x1b6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_LATCHED_STS (at 0x1b618)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6180 0x1b6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN6_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_PENDING_STS (at 0x1b619)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6190 0x1b6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN6_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_MID_SEL (at 0x1b61a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b61a0 0x1b61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN6_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_PRIORITY (at 0x1b61b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b61b0 0x1b61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN6_LPG_PATTERN_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_LPG_PATTERN_CONFIG (at 0x1b640)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6400 0x1b6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_SIZE_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_LPG_PWM_SIZE_CLK (at 0x1b641)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6410 0x1b6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_FREQ_PREDIV_CLK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b642)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6420 0x1b6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_TYPE_CONFIG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_LPG_PWM_TYPE_CONFIG (at 0x1b643)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6430 0x1b6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN6_PWM_VALUE_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PWM_VALUE_LSB (at 0x1b644)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6440 0x1b6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN6_PWM_VALUE_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PWM_VALUE_MSB (at 0x1b645)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6450 0x1b6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN6_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_ENABLE_CONTROL (at 0x1b646)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6460 0x1b6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN6_RAMP_STEP_DURATION_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_RAMP_STEP_DURATION_LSB (at 0x1b650)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6500 0x1b6500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN6_RAMP_STEP_DURATION_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_RAMP_STEP_DURATION_MSB (at 0x1b651)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6510 0x1b6510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN6_PAUSE_HI_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PAUSE_HI_MULTIPLIER_LSB (at 0x1b652)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6520 0x1b6520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN6_PAUSE_HI_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PAUSE_HI_MULTIPLIER_MSB (at 0x1b653)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6530 0x1b6530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN6_PAUSE_LO_MULTIPLIER_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PAUSE_LO_MULTIPLIER_LSB (at 0x1b654)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6540 0x1b6540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN6_PAUSE_LO_MULTIPLIER_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PAUSE_LO_MULTIPLIER_MSB (at 0x1b655)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6550 0x1b6550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN6_HI_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_HI_INDEX (at 0x1b656)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6560 0x1b6560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN6_LO_INDEX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_LO_INDEX (at 0x1b657)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6570 0x1b6570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN6_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_SEC_ACCESS (at 0x1b6d0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6d00 0x1b6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PERPH_RESET_CTL2 (at 0x1b6d9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6d90 0x1b6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PERPH_RESET_CTL3 (at 0x1b6da)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6da0 0x1b6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_PERPH_RESET_CTL4 (at 0x1b6db)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6db0 0x1b6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN6_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_TEST1 (at 0x1b6e0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6e00 0x1b6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_INT_TEST_VAL (at 0x1b6e1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6e10 0x1b6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN6_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_TEST1 (at 0x1b6e2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6e20 0x1b6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN6_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_TEST2 (at 0x1b6e3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6e30 0x1b6e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN6_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_TEST3 (at 0x1b6e4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6e40 0x1b6e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN6_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_CHAN6_TEST4 (at 0x1b6e5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b6e50 0x1b6e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_LUT"
  tree "LPG_LUT"
    tree "LPG_LUT_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_REVISION1 (at 0x1b000)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0000 0x1b0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_LUT_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_REVISION2 (at 0x1b001)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0010 0x1b0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_LUT_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_TYPE (at 0x1b004)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0040 0x1b0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_LUT_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_SUBTYPE (at 0x1b005)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0050 0x1b0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_LUT_LUT0_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT0_LSB (at 0x1b040)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0400 0x1b0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT0_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT0_MSB (at 0x1b041)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0410 0x1b0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT1_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT1_LSB (at 0x1b042)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0420 0x1b0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT1_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT1_MSB (at 0x1b043)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0430 0x1b0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT2_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT2_LSB (at 0x1b044)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0440 0x1b0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT2_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT2_MSB (at 0x1b045)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0450 0x1b0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT3_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT3_LSB (at 0x1b046)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0460 0x1b0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT3_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT3_MSB (at 0x1b047)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0470 0x1b0470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT4_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT4_LSB (at 0x1b048)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0480 0x1b0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT4_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT4_MSB (at 0x1b049)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0490 0x1b0490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT5_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT5_LSB (at 0x1b04a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b04a0 0x1b04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT5_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT5_MSB (at 0x1b04b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b04b0 0x1b04b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT6_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT6_LSB (at 0x1b04c)"
      tindex ezaxi:0xfc4cf980 %l 0x81b04c0 0x1b04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT6_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT6_MSB (at 0x1b04d)"
      tindex ezaxi:0xfc4cf980 %l 0x81b04d0 0x1b04d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT7_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT7_LSB (at 0x1b04e)"
      tindex ezaxi:0xfc4cf980 %l 0x81b04e0 0x1b04e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT7_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT7_MSB (at 0x1b04f)"
      tindex ezaxi:0xfc4cf980 %l 0x81b04f0 0x1b04f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT8_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT8_LSB (at 0x1b050)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0500 0x1b0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT8_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT8_MSB (at 0x1b051)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0510 0x1b0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT9_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT9_LSB (at 0x1b052)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0520 0x1b0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT9_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT9_MSB (at 0x1b053)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0530 0x1b0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT10_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT10_LSB (at 0x1b054)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0540 0x1b0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT10_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT10_MSB (at 0x1b055)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0550 0x1b0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT11_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT11_LSB (at 0x1b056)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0560 0x1b0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT11_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT11_MSB (at 0x1b057)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0570 0x1b0570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT12_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT12_LSB (at 0x1b058)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0580 0x1b0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT12_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT12_MSB (at 0x1b059)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0590 0x1b0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT13_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT13_LSB (at 0x1b05a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b05a0 0x1b05a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT13_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT13_MSB (at 0x1b05b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b05b0 0x1b05b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT14_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT14_LSB (at 0x1b05c)"
      tindex ezaxi:0xfc4cf980 %l 0x81b05c0 0x1b05c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT14_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT14_MSB (at 0x1b05d)"
      tindex ezaxi:0xfc4cf980 %l 0x81b05d0 0x1b05d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT15_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT15_LSB (at 0x1b05e)"
      tindex ezaxi:0xfc4cf980 %l 0x81b05e0 0x1b05e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT15_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT15_MSB (at 0x1b05f)"
      tindex ezaxi:0xfc4cf980 %l 0x81b05f0 0x1b05f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT16_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT16_LSB (at 0x1b060)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0600 0x1b0600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT16_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT16_MSB (at 0x1b061)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0610 0x1b0610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT17_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT17_LSB (at 0x1b062)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0620 0x1b0620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT17_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT17_MSB (at 0x1b063)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0630 0x1b0630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT18_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT18_LSB (at 0x1b064)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0640 0x1b0640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT18_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT18_MSB (at 0x1b065)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0650 0x1b0650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT19_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT19_LSB (at 0x1b066)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0660 0x1b0660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT19_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT19_MSB (at 0x1b067)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0670 0x1b0670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT20_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT20_LSB (at 0x1b068)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0680 0x1b0680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT20_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT20_MSB (at 0x1b069)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0690 0x1b0690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT21_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT21_LSB (at 0x1b06a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b06a0 0x1b06a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT21_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT21_MSB (at 0x1b06b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b06b0 0x1b06b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT22_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT22_LSB (at 0x1b06c)"
      tindex ezaxi:0xfc4cf980 %l 0x81b06c0 0x1b06c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT22_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT22_MSB (at 0x1b06d)"
      tindex ezaxi:0xfc4cf980 %l 0x81b06d0 0x1b06d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT23_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT23_LSB (at 0x1b06e)"
      tindex ezaxi:0xfc4cf980 %l 0x81b06e0 0x1b06e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT23_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT23_MSB (at 0x1b06f)"
      tindex ezaxi:0xfc4cf980 %l 0x81b06f0 0x1b06f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT24_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT24_LSB (at 0x1b070)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0700 0x1b0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT24_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT24_MSB (at 0x1b071)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0710 0x1b0710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT25_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT25_LSB (at 0x1b072)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0720 0x1b0720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT25_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT25_MSB (at 0x1b073)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0730 0x1b0730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT26_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT26_LSB (at 0x1b074)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0740 0x1b0740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT26_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT26_MSB (at 0x1b075)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0750 0x1b0750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT27_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT27_LSB (at 0x1b076)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0760 0x1b0760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT27_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT27_MSB (at 0x1b077)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0770 0x1b0770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT28_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT28_LSB (at 0x1b078)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0780 0x1b0780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT28_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT28_MSB (at 0x1b079)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0790 0x1b0790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT29_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT29_LSB (at 0x1b07a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b07a0 0x1b07a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT29_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT29_MSB (at 0x1b07b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b07b0 0x1b07b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT30_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT30_LSB (at 0x1b07c)"
      tindex ezaxi:0xfc4cf980 %l 0x81b07c0 0x1b07c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT30_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT30_MSB (at 0x1b07d)"
      tindex ezaxi:0xfc4cf980 %l 0x81b07d0 0x1b07d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT31_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT31_LSB (at 0x1b07e)"
      tindex ezaxi:0xfc4cf980 %l 0x81b07e0 0x1b07e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT31_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT31_MSB (at 0x1b07f)"
      tindex ezaxi:0xfc4cf980 %l 0x81b07f0 0x1b07f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT32_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT32_LSB (at 0x1b080)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0800 0x1b0800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT32_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT32_MSB (at 0x1b081)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0810 0x1b0810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT33_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT33_LSB (at 0x1b082)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0820 0x1b0820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT33_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT33_MSB (at 0x1b083)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0830 0x1b0830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT34_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT34_LSB (at 0x1b084)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0840 0x1b0840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT34_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT34_MSB (at 0x1b085)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0850 0x1b0850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT35_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT35_LSB (at 0x1b086)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0860 0x1b0860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT35_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT35_MSB (at 0x1b087)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0870 0x1b0870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT36_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT36_LSB (at 0x1b088)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0880 0x1b0880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT36_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT36_MSB (at 0x1b089)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0890 0x1b0890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT37_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT37_LSB (at 0x1b08a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b08a0 0x1b08a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT37_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT37_MSB (at 0x1b08b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b08b0 0x1b08b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT38_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT38_LSB (at 0x1b08c)"
      tindex ezaxi:0xfc4cf980 %l 0x81b08c0 0x1b08c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT38_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT38_MSB (at 0x1b08d)"
      tindex ezaxi:0xfc4cf980 %l 0x81b08d0 0x1b08d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT39_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT39_LSB (at 0x1b08e)"
      tindex ezaxi:0xfc4cf980 %l 0x81b08e0 0x1b08e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT39_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT39_MSB (at 0x1b08f)"
      tindex ezaxi:0xfc4cf980 %l 0x81b08f0 0x1b08f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT40_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT40_LSB (at 0x1b090)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0900 0x1b0900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT40_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT40_MSB (at 0x1b091)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0910 0x1b0910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT41_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT41_LSB (at 0x1b092)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0920 0x1b0920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT41_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT41_MSB (at 0x1b093)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0930 0x1b0930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT42_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT42_LSB (at 0x1b094)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0940 0x1b0940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT42_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT42_MSB (at 0x1b095)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0950 0x1b0950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT43_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT43_LSB (at 0x1b096)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0960 0x1b0960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT43_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT43_MSB (at 0x1b097)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0970 0x1b0970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT44_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT44_LSB (at 0x1b098)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0980 0x1b0980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT44_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT44_MSB (at 0x1b099)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0990 0x1b0990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT45_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT45_LSB (at 0x1b09a)"
      tindex ezaxi:0xfc4cf980 %l 0x81b09a0 0x1b09a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT45_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT45_MSB (at 0x1b09b)"
      tindex ezaxi:0xfc4cf980 %l 0x81b09b0 0x1b09b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT46_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT46_LSB (at 0x1b09c)"
      tindex ezaxi:0xfc4cf980 %l 0x81b09c0 0x1b09c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT46_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT46_MSB (at 0x1b09d)"
      tindex ezaxi:0xfc4cf980 %l 0x81b09d0 0x1b09d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT47_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT47_LSB (at 0x1b09e)"
      tindex ezaxi:0xfc4cf980 %l 0x81b09e0 0x1b09e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT47_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT47_MSB (at 0x1b09f)"
      tindex ezaxi:0xfc4cf980 %l 0x81b09f0 0x1b09f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT48_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT48_LSB (at 0x1b0a0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a00 0x1b0a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT48_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT48_MSB (at 0x1b0a1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a10 0x1b0a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT49_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT49_LSB (at 0x1b0a2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a20 0x1b0a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT49_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT49_MSB (at 0x1b0a3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a30 0x1b0a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT50_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT50_LSB (at 0x1b0a4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a40 0x1b0a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT50_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT50_MSB (at 0x1b0a5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a50 0x1b0a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT51_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT51_LSB (at 0x1b0a6)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a60 0x1b0a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT51_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT51_MSB (at 0x1b0a7)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a70 0x1b0a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT52_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT52_LSB (at 0x1b0a8)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a80 0x1b0a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT52_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT52_MSB (at 0x1b0a9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0a90 0x1b0a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT53_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT53_LSB (at 0x1b0aa)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0aa0 0x1b0aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT53_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT53_MSB (at 0x1b0ab)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0ab0 0x1b0ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT54_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT54_LSB (at 0x1b0ac)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0ac0 0x1b0ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT54_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT54_MSB (at 0x1b0ad)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0ad0 0x1b0ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT55_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT55_LSB (at 0x1b0ae)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0ae0 0x1b0ae0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT55_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT55_MSB (at 0x1b0af)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0af0 0x1b0af0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT56_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT56_LSB (at 0x1b0b0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b00 0x1b0b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT56_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT56_MSB (at 0x1b0b1)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b10 0x1b0b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT57_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT57_LSB (at 0x1b0b2)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b20 0x1b0b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT57_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT57_MSB (at 0x1b0b3)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b30 0x1b0b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT58_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT58_LSB (at 0x1b0b4)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b40 0x1b0b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT58_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT58_MSB (at 0x1b0b5)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b50 0x1b0b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT59_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT59_LSB (at 0x1b0b6)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b60 0x1b0b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT59_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT59_MSB (at 0x1b0b7)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b70 0x1b0b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT60_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT60_LSB (at 0x1b0b8)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b80 0x1b0b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT60_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT60_MSB (at 0x1b0b9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0b90 0x1b0b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT61_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT61_LSB (at 0x1b0ba)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0ba0 0x1b0ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT61_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT61_MSB (at 0x1b0bb)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0bb0 0x1b0bb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT62_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT62_LSB (at 0x1b0bc)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0bc0 0x1b0bc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT62_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT62_MSB (at 0x1b0bd)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0bd0 0x1b0bd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT63_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT63_LSB (at 0x1b0be)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0be0 0x1b0be0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT63_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_LUT63_MSB (at 0x1b0bf)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0bf0 0x1b0bf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_RAMP_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_RAMP_CONTROL (at 0x1b0c8)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0c80 0x1b0c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S7_RAMP_START                            = " "0 (LPG8_RAMP_DIS),1 (LPG8_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   S6_RAMP_START                            = " "0 (LPG7_RAMP_DIS),1 (LPG7_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   S5_RAMP_START                            = " "0 (LPG6_RAMP_DIS),1 (LPG6_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   S4_RAMP_START                            = " "0 (LPG5_RAMP_DIS),1 (LPG5_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   S3_RAMP_START                            = " "0 (LPG4_RAMP_DIS),1 (LPG4_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   S2_RAMP_START                            = " "0 (LPG3_RAMP_DIS),1 (LPG3_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   S1_RAMP_START                            = " "0 (LPG2_RAMP_DIS),1 (LPG2_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   S0_RAMP_START                            = " "0 (LPG1_RAMP_DIS),1 (LPG1_RAMP_START)"
    tree.end
    tree "LPG_LUT_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_SEC_ACCESS (at 0x1b0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0d00 0x1b0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_RESET_CTL2 (at 0x1b0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0d90 0x1b0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_RESET_CTL3 (at 0x1b0da)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0da0 0x1b0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LPG_LUT_PERPH_RESET_CTL4 (at 0x1b0db)"
      tindex ezaxi:0xfc4cf980 %l 0x81b0db0 0x1b0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "LVS1"
  tree "LVS1"
    tree "LVS1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_REVISION1 (at 0x18000)"
      tindex ezaxi:0xfc4cf980 %l 0x8180000 0x180000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LVS1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_REVISION2 (at 0x18001)"
      tindex ezaxi:0xfc4cf980 %l 0x8180010 0x180010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LVS1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_REVISION3 (at 0x18002)"
      tindex ezaxi:0xfc4cf980 %l 0x8180020 0x180020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LVS1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_REVISION4 (at 0x18003)"
      tindex ezaxi:0xfc4cf980 %l 0x8180030 0x180030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LVS1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_PERPH_TYPE (at 0x18004)"
      tindex ezaxi:0xfc4cf980 %l 0x8180040 0x180040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LVS1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_PERPH_SUBTYPE (at 0x18005)"
      tindex ezaxi:0xfc4cf980 %l 0x8180050 0x180050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LVS1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_STATUS1 (at 0x18008)"
      tindex ezaxi:0xfc4cf980 %l 0x8180080 0x180080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VS_NOT_OK),1 (VS_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVERCURRENT                              = " "0 (NO_OC_EVENT),1 (OC_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (LPM),1 (NPM)"
    tree.end
    tree "LVS1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_RT_STS (at 0x18010)"
      tindex ezaxi:0xfc4cf980 %l 0x8180100 0x180100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "LVS1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_SET_TYPE (at 0x18011)"
      tindex ezaxi:0xfc4cf980 %l 0x8180110 0x180110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LVS1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_POLARITY_HIGH (at 0x18012)"
      tindex ezaxi:0xfc4cf980 %l 0x8180120 0x180120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LVS1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_POLARITY_LOW (at 0x18013)"
      tindex ezaxi:0xfc4cf980 %l 0x8180130 0x180130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LVS1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_LATCHED_CLR (at 0x18014)"
      tindex ezaxi:0xfc4cf980 %l 0x8180140 0x180140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LVS1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_EN_SET (at 0x18015)"
      tindex ezaxi:0xfc4cf980 %l 0x8180150 0x180150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LVS1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_EN_CLR (at 0x18016)"
      tindex ezaxi:0xfc4cf980 %l 0x8180160 0x180160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LVS1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_LATCHED_STS (at 0x18018)"
      tindex ezaxi:0xfc4cf980 %l 0x8180180 0x180180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LVS1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_PENDING_STS (at 0x18019)"
      tindex ezaxi:0xfc4cf980 %l 0x8180190 0x180190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LVS1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_MID_SEL (at 0x1801a)"
      tindex ezaxi:0xfc4cf980 %l 0x81801a0 0x1801a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LVS1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_PRIORITY (at 0x1801b)"
      tindex ezaxi:0xfc4cf980 %l 0x81801b0 0x1801b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LVS1_MODE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_MODE_CTL1 (at 0x18045)"
      tindex ezaxi:0xfc4cf980 %l 0x8180450 0x180450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NO_FORCE),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO                                     = " "0 (NO_AUTO),1 (AUTO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
    tree.end
    tree "LVS1_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_EN_CTL1 (at 0x18046)"
      tindex ezaxi:0xfc4cf980 %l 0x8180460 0x180460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (NO_FORCE),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
    tree.end
    tree "LVS1_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_PD_CTL (at 0x18048)"
      tindex ezaxi:0xfc4cf980 %l 0x8180480 0x180480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "LVS1_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_CURRENT_LIM_CTL (at 0x1804a)"
      tindex ezaxi:0xfc4cf980 %l 0x81804a0 0x1804a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_OVERRIDE                             = " "0 (DISABLE_ON_OCP),1 (STAY_ENABLED_ON_OCP)"
    tree.end
    tree "LVS1_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_SOFT_START_CTL (at 0x1804c)"
      tindex ezaxi:0xfc4cf980 %l 0x81804c0 0x1804c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_EN                            = " "0 (SOFTSTART_ENABLED),1 (SOFTSTART_DISABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SOFT_START_SEL                           = " "0 (SS_PD_50NA),1 (SS_PD_250NA),2 (SS_PD_550NA),3 (SS_PD_750NA)"
    tree.end
    tree "LVS1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_SEC_ACCESS (at 0x180d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8180d00 0x180d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LVS1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_PERPH_RESET_CTL1 (at 0x180d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8180d80 0x180d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LVS1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_PERPH_RESET_CTL2 (at 0x180d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8180d90 0x180d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LVS1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_PERPH_RESET_CTL3 (at 0x180da)"
      tindex ezaxi:0xfc4cf980 %l 0x8180da0 0x180da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LVS1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_PERPH_RESET_CTL4 (at 0x180db)"
      tindex ezaxi:0xfc4cf980 %l 0x8180db0 0x180db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LVS1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_TEST1 (at 0x180e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8180e00 0x180e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LVS1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_INT_TEST_VAL (at 0x180e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8180e10 0x180e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LVS1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_TEST1 (at 0x180e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8180e20 0x180e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_TM                               = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST_SEL                                = " "0 (DISABLE_RDS_ON_TEST),1 (ENABLE_RDS_ON_TEST)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DTEST_SEL                                = " "0 (DTEST_DISABLED),1 (DTEST_VOUT_OK),2 (DTEST_OCP),3 (RESERVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TM                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "LVS1_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_TRIM_NUM (at 0x180f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8180f00 0x180f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LVS1_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS1_TRIM1 (at 0x180f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8180f10 0x180f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   OTA_TRIM                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   OCP_TRIM                                 = " "0 (MINUS_10PCT),1 (MINUS_20PCT),2 (MINUS_30PCT),3 (MINUS_40PCT),4 (PLUS_30PCT),5 (PLUS_20PCT),6 (PLUS_10PCT),7 (NOMINAL_450MA)"
    tree.end
  tree.end
tree.end
tree "LVS2"
  tree "LVS2"
    tree "LVS2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_REVISION1 (at 0x18100)"
      tindex ezaxi:0xfc4cf980 %l 0x8181000 0x181000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LVS2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_REVISION2 (at 0x18101)"
      tindex ezaxi:0xfc4cf980 %l 0x8181010 0x181010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LVS2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_REVISION3 (at 0x18102)"
      tindex ezaxi:0xfc4cf980 %l 0x8181020 0x181020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LVS2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_REVISION4 (at 0x18103)"
      tindex ezaxi:0xfc4cf980 %l 0x8181030 0x181030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LVS2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_PERPH_TYPE (at 0x18104)"
      tindex ezaxi:0xfc4cf980 %l 0x8181040 0x181040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LVS2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_PERPH_SUBTYPE (at 0x18105)"
      tindex ezaxi:0xfc4cf980 %l 0x8181050 0x181050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LVS2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_STATUS1 (at 0x18108)"
      tindex ezaxi:0xfc4cf980 %l 0x8181080 0x181080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VS_NOT_OK),1 (VS_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVERCURRENT                              = " "0 (NO_OC_EVENT),1 (OC_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (LPM),1 (NPM)"
    tree.end
    tree "LVS2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_RT_STS (at 0x18110)"
      tindex ezaxi:0xfc4cf980 %l 0x8181100 0x181100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "LVS2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_SET_TYPE (at 0x18111)"
      tindex ezaxi:0xfc4cf980 %l 0x8181110 0x181110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LVS2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_POLARITY_HIGH (at 0x18112)"
      tindex ezaxi:0xfc4cf980 %l 0x8181120 0x181120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LVS2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_POLARITY_LOW (at 0x18113)"
      tindex ezaxi:0xfc4cf980 %l 0x8181130 0x181130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LVS2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_LATCHED_CLR (at 0x18114)"
      tindex ezaxi:0xfc4cf980 %l 0x8181140 0x181140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LVS2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_EN_SET (at 0x18115)"
      tindex ezaxi:0xfc4cf980 %l 0x8181150 0x181150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LVS2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_EN_CLR (at 0x18116)"
      tindex ezaxi:0xfc4cf980 %l 0x8181160 0x181160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LVS2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_LATCHED_STS (at 0x18118)"
      tindex ezaxi:0xfc4cf980 %l 0x8181180 0x181180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LVS2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_PENDING_STS (at 0x18119)"
      tindex ezaxi:0xfc4cf980 %l 0x8181190 0x181190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LVS2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_MID_SEL (at 0x1811a)"
      tindex ezaxi:0xfc4cf980 %l 0x81811a0 0x1811a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LVS2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_PRIORITY (at 0x1811b)"
      tindex ezaxi:0xfc4cf980 %l 0x81811b0 0x1811b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LVS2_MODE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_MODE_CTL1 (at 0x18145)"
      tindex ezaxi:0xfc4cf980 %l 0x8181450 0x181450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NO_FORCE),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO                                     = " "0 (NO_AUTO),1 (AUTO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
    tree.end
    tree "LVS2_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_EN_CTL1 (at 0x18146)"
      tindex ezaxi:0xfc4cf980 %l 0x8181460 0x181460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (NO_FORCE),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
    tree.end
    tree "LVS2_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_PD_CTL (at 0x18148)"
      tindex ezaxi:0xfc4cf980 %l 0x8181480 0x181480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "LVS2_CURRENT_LIM_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_CURRENT_LIM_CTL (at 0x1814a)"
      tindex ezaxi:0xfc4cf980 %l 0x81814a0 0x1814a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_OVERRIDE                             = " "0 (DISABLE_ON_OCP),1 (STAY_ENABLED_ON_OCP)"
    tree.end
    tree "LVS2_SOFT_START_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_SOFT_START_CTL (at 0x1814c)"
      tindex ezaxi:0xfc4cf980 %l 0x81814c0 0x1814c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_EN                            = " "0 (SOFTSTART_ENABLED),1 (SOFTSTART_DISABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SOFT_START_SEL                           = " "0 (SS_PD_50NA),1 (SS_PD_250NA),2 (SS_PD_550NA),3 (SS_PD_750NA)"
    tree.end
    tree "LVS2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_SEC_ACCESS (at 0x181d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8181d00 0x181d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LVS2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_PERPH_RESET_CTL1 (at 0x181d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8181d80 0x181d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LVS2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_PERPH_RESET_CTL2 (at 0x181d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8181d90 0x181d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LVS2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_PERPH_RESET_CTL3 (at 0x181da)"
      tindex ezaxi:0xfc4cf980 %l 0x8181da0 0x181da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LVS2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_PERPH_RESET_CTL4 (at 0x181db)"
      tindex ezaxi:0xfc4cf980 %l 0x8181db0 0x181db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LVS2_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_TEST1 (at 0x181e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8181e00 0x181e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LVS2_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_INT_TEST_VAL (at 0x181e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8181e10 0x181e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LVS2_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_TEST1 (at 0x181e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8181e20 0x181e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_TM                               = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST_SEL                                = " "0 (DISABLE_RDS_ON_TEST),1 (ENABLE_RDS_ON_TEST)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DTEST_SEL                                = " "0 (DTEST_DISABLED),1 (DTEST_VOUT_OK),2 (DTEST_OCP),3 (RESERVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TM                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "LVS2_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_TRIM_NUM (at 0x181f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8181f00 0x181f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LVS2_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "LVS2_TRIM1 (at 0x181f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8181f10 0x181f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   OTA_TRIM                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   OCP_TRIM                                 = " "0 (MINUS_10PCT),1 (MINUS_20PCT),2 (MINUS_30PCT),3 (MINUS_40PCT),4 (PLUS_30PCT),5 (PLUS_20PCT),6 (PLUS_10PCT),7 (NOMINAL_450MA)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION1 (at 0x2c00)"
      tindex ezaxi:0xfc4cf980 %l 0x802c000 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION2 (at 0x2c01)"
      tindex ezaxi:0xfc4cf980 %l 0x802c010 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION3 (at 0x2c02)"
      tindex ezaxi:0xfc4cf980 %l 0x802c020 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_REVISION4 (at 0x2c03)"
      tindex ezaxi:0xfc4cf980 %l 0x802c030 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_TYPE (at 0x2c04)"
      tindex ezaxi:0xfc4cf980 %l 0x802c040 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_SUBTYPE (at 0x2c05)"
      tindex ezaxi:0xfc4cf980 %l 0x802c050 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_STATUS1 (at 0x2c08)"
      tindex ezaxi:0xfc4cf980 %l 0x802c080 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MODE_CTRL (at 0x2c44)"
      tindex ezaxi:0xfc4cf980 %l 0x802c440 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_EN_CTL (at 0x2c46)"
      tindex ezaxi:0xfc4cf980 %l 0x802c460 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_SEC_ACCESS (at 0x2cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x802cd00 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x802cd80 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x802cd90 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
      tindex ezaxi:0xfc4cf980 %l 0x802cda0 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x802cdb0 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_TEST1 (at 0x2ce2)"
      tindex ezaxi:0xfc4cf980 %l 0x802ce20 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_TEST2 (at 0x2ce3)"
      tindex ezaxi:0xfc4cf980 %l 0x802ce30 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_TRIM_NUM (at 0x2cf0)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf00 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM1 (at 0x2cf1)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf10 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM2 (at 0x2cf2)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf20 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM3 (at 0x2cf3)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf30 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM4 (at 0x2cf4)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf40 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM5 (at 0x2cf5)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf50 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM6 (at 0x2cf6)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf60 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM7 (at 0x2cf7)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf70 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MBG1_MBG_TRIM8 (at 0x2cf8)"
      tindex ezaxi:0xfc4cf980 %l 0x802cf80 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION1 (at 0x900)"
      tindex ezaxi:0xfc4cf980 %l 0x8009000 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION2 (at 0x901)"
      tindex ezaxi:0xfc4cf980 %l 0x8009010 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION3 (at 0x902)"
      tindex ezaxi:0xfc4cf980 %l 0x8009020 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_REVISION4 (at 0x903)"
      tindex ezaxi:0xfc4cf980 %l 0x8009030 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_TYPE (at 0x904)"
      tindex ezaxi:0xfc4cf980 %l 0x8009040 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_SUBTYPE (at 0x905)"
      tindex ezaxi:0xfc4cf980 %l 0x8009050 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_STATUS1 (at 0x908)"
      tindex ezaxi:0xfc4cf980 %l 0x8009080 0x9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USB_ID                                   = " "0 (USB_ID_DISABLED),1 (USB_ID_ENABLED)"
    tree.end
    tree "MISC_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_STATUS2 (at 0x909)"
      tindex ezaxi:0xfc4cf980 %l 0x8009090 0x9090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST                                    = "
    tree.end
    tree "MISC_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_STATUS3 (at 0x90a)"
      tindex ezaxi:0xfc4cf980 %l 0x80090a0 0x90a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NSLDO_PIN_CTL                            = " "0 (PIN_CTL_DISABLED),1 (PIN_CTL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   NSLDO_VOL_SET                            = " "0 (NSLDO_RETENTION_VOL),1 (NSLDO_NOMINAL_VOL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LDO26A_MODE                              = " "0 (LPM),1 (NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LDO3A_MODE                               = " "0 (LPM),1 (NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LDO11A_MODE                              = " "0 (LPM),1 (NPM)"
    tree.end
    tree "MISC_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_RT_STS (at 0x910)"
      tindex ezaxi:0xfc4cf980 %l 0x8009100 0x9100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_STS                               = " "0 (USB_ID_INT_STATUS_LOW),1 (USB_ID_INT_STATUS_HI)"
    tree.end
    tree "MISC_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_SET_TYPE (at 0x911)"
      tindex ezaxi:0xfc4cf980 %l 0x8009110 0x9110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MISC_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_POLARITY_HIGH (at 0x912)"
      tindex ezaxi:0xfc4cf980 %l 0x8009120 0x9120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MISC_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_POLARITY_LOW (at 0x913)"
      tindex ezaxi:0xfc4cf980 %l 0x8009130 0x9130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MISC_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_LATCHED_CLR (at 0x914)"
      tindex ezaxi:0xfc4cf980 %l 0x8009140 0x9140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_LATCHED_CLR                       = " "0 (INT_LATCHED_CLR_DISABLED),1 (INT_LATCHED_CLR_ENABLED)"
    tree.end
    tree "MISC_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_EN_SET (at 0x915)"
      tindex ezaxi:0xfc4cf980 %l 0x8009150 0x9150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MISC_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_EN_CLR (at 0x916)"
      tindex ezaxi:0xfc4cf980 %l 0x8009160 0x9160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MISC_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_LATCHED_STS (at 0x918)"
      tindex ezaxi:0xfc4cf980 %l 0x8009180 0x9180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "MISC_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_PENDING_STS (at 0x919)"
      tindex ezaxi:0xfc4cf980 %l 0x8009190 0x9190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_IDPENDING_STS                        = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "MISC_TEST_CONNECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_TEST_CONNECT (at 0x940)"
      tindex ezaxi:0xfc4cf980 %l 0x8009400 0x9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_CONNECT                            = " "0 (ATEST_CONNECT_DISABLED),1 (ATEST_CONNECT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST_CONNECT_1                          = " "0 (DTEST_CONNECT_H_TO_L_DISABLED),1 (DTEST_CONNECT_H_TO_L_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_CONNECT_0                          = " "0 (DTEST_CONNECT_L_TO_H_DISABLED),1 (DTEST_CONNECT_H_TO_L_ENABLED)"
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_DTEST_DRV_CTL (at 0x943)"
      tindex ezaxi:0xfc4cf980 %l 0x8009430 0x9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_DRV_EN                             = "
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_DTEST_DRV_VAL (at 0x944)"
      tindex ezaxi:0xfc4cf980 %l 0x8009440 0x9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_VAL                                = "
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_BUCK_CMN_CTL1 (at 0x945)"
      tindex ezaxi:0xfc4cf980 %l 0x8009450 0x9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   VPRE_CHARGE_SEL                          = " "0 (VPRE_CHARGE_LOW_RANGE_0P35V),1 (VPRE_CHARGE_LOW_RANGE_0P40V),2 (VPRE_CHARGE_LOW_RANGE_0P45V),3 (VPRE_CHARGE_LOW_RANGE_0P50V)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0 (BYPASS_IBG_DLY_DISABLED),1 (BYPASS_IBG_DLY_ENABLED)"
    tree.end
    tree "MISC_USB_ID_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_USB_ID_CTL1 (at 0x946)"
      tindex ezaxi:0xfc4cf980 %l 0x8009460 0x9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USB_ID_PU_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_ID_LVDET_EN                          = " "0, 1"
    tree.end
    tree "MISC_SHDN_N_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_SHDN_N_CTL1 (at 0x947)"
      tindex ezaxi:0xfc4cf980 %l 0x8009470 0x9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SHDN_N_POLARITY                          = " "0 (SHDN_N_POLARITY_ACTIVE_LOW),1 (SHDN_N_POLARITY_ACTIVE_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SHDN_N_DET_EN                            = " "0, 1"
    tree.end
    tree "MISC_NSLDO_PIN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_NSLDO_PIN_CTL1 (at 0x948)"
      tindex ezaxi:0xfc4cf980 %l 0x8009480 0x9480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN_CTL_EN                               = " "0 (NSLDO_PIN_CTL_DISABLED),1 (NSLDO_PIN_CTL_ENABLED)"
    tree.end
    tree "MISC_MISC_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_MISC_CTL1 (at 0x949)"
      tindex ezaxi:0xfc4cf980 %l 0x8009490 0x9490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MISC_CTL                                 = "
    tree.end
    tree "MISC_NSLDO_L26_RET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_NSLDO_L26_RET (at 0x950)"
      tindex ezaxi:0xfc4cf980 %l 0x8009500 0x9500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_CTL                                 = " "0 (LPM_FORCED),1 (NPM_FORCED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "MISC_NSLDO_L26_NOM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_NSLDO_L26_NOM (at 0x951)"
      tindex ezaxi:0xfc4cf980 %l 0x8009510 0x9510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_CTL                                 = " "0 (LPM_FORCED),1 (NPM_FORCED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "MISC_NSLDO_L3_RET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_NSLDO_L3_RET (at 0x952)"
      tindex ezaxi:0xfc4cf980 %l 0x8009520 0x9520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_CTL                                 = " "0 (LPM_FORCED),1 (NPM_FORCED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "MISC_NSLDO_L3_NOM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_NSLDO_L3_NOM (at 0x953)"
      tindex ezaxi:0xfc4cf980 %l 0x8009530 0x9530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_CTL                                 = " "0 (LPM_FORCED),1 (NPM_FORCED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "MISC_NSLDO_L11_RET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_NSLDO_L11_RET (at 0x954)"
      tindex ezaxi:0xfc4cf980 %l 0x8009540 0x9540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_CTL                                 = " "0 (LPM_FORCED),1 (NPM_FORCED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "MISC_NSLDO_L11_NOM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_NSLDO_L11_NOM (at 0x955)"
      tindex ezaxi:0xfc4cf980 %l 0x8009550 0x9550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_CTL                                 = " "0 (LPM_FORCED),1 (NPM_FORCED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "MISC_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_SEC_ACCESS (at 0x9d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8009d00 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8009d90 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_RESET_CTL3 (at 0x9da)"
      tindex ezaxi:0xfc4cf980 %l 0x8009da0 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_PERPH_RESET_CTL4 (at 0x9db)"
      tindex ezaxi:0xfc4cf980 %l 0x8009db0 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_TEST1 (at 0x9dc)"
      tindex ezaxi:0xfc4cf980 %l 0x8009dc0 0x9dc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MOD_ENABLED)"
    tree.end
    tree "MISC_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_INT_TEST_VAL (at 0x9de)"
      tindex ezaxi:0xfc4cf980 %l 0x8009de0 0x9de0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_TEST_VAL                          = " "0 (USB_ID_TEST_VALUE_LOW),1 (USB_ID_TEST_VALUE_HI)"
    tree.end
    tree "MISC_TEST_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_TEST_ACCESS (at 0x9e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8009e00 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (TEST_ACCESS_DISABLED),1 (TEST_ACCESS_ENABLED)"
    tree.end
    tree "MISC_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_TEST1 (at 0x9e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8009e10 0x9e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (MISC_TEST1_DISABLE_DTEST7),1 (MISC_TEST1_USB_ID_INT),2 (MISC_TEST1_SHDN_LV),3 (MISC_TEST1_TEST_ACCESS),4 (MISC_TEST1_BUCK_PWM_MSTR_EN),5 (MISC_TEST1_BUCK_MBG_MSTR_EN),6 (MISC_TEST1_NS_VCTRL_GATED),7 (MISC_TEST1_NSLDO_PINCTL_EN)"
    tree.end
    tree "MISC_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MISC_TRIM_NUM (at 0x9f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8009f00 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION1 (at 0xa000)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0000 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION2 (at 0xa001)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0010 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION3 (at 0xa002)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0020 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_REVISION4 (at 0xa003)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0030 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_TYPE (at 0xa004)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0040 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_SUBTYPE (at 0xa005)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0050 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_STATUS1 (at 0xa008)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0080 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_RT_STS (at 0xa010)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0100 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_SET_TYPE (at 0xa011)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0110 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_POLARITY_HIGH (at 0xa012)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0120 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_POLARITY_LOW (at 0xa013)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0130 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_LATCHED_CLR (at 0xa014)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0140 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_EN_SET (at 0xa015)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0150 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_EN_CLR (at 0xa016)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0160 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_LATCHED_STS (at 0xa018)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0180 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_PENDING_STS (at 0xa019)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0190 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_MID_SEL (at 0xa01a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a01a0 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_INT_PRIORITY (at 0xa01b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a01b0 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_MODE_CTL (at 0xa040)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0400 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_DIG_VIN_CTL (at 0xa041)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0410 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_DIG_PULL_CTL (at 0xa042)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0420 0xa0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_DIG_IN_CTL (at 0xa043)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0430 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_EN_CTL (at 0xa046)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0460 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_ANA_OUT_CTL (at 0xa048)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0480 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_ANA_IN_CTL (at 0xa04a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a04a0 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_SINK_CTL (at 0xa04c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a04c0 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_SEC_ACCESS (at 0xa0d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0d00 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0d80 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0d90 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0da0 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a0db0 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION1 (at 0xa100)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1000 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION2 (at 0xa101)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1010 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION3 (at 0xa102)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1020 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_REVISION4 (at 0xa103)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1030 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_TYPE (at 0xa104)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1040 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_SUBTYPE (at 0xa105)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1050 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_STATUS1 (at 0xa108)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1080 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_RT_STS (at 0xa110)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1100 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_SET_TYPE (at 0xa111)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1110 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_POLARITY_HIGH (at 0xa112)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1120 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_POLARITY_LOW (at 0xa113)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1130 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_LATCHED_CLR (at 0xa114)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1140 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_EN_SET (at 0xa115)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1150 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_EN_CLR (at 0xa116)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1160 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_LATCHED_STS (at 0xa118)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1180 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_PENDING_STS (at 0xa119)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1190 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_MID_SEL (at 0xa11a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a11a0 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_INT_PRIORITY (at 0xa11b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a11b0 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_MODE_CTL (at 0xa140)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1400 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_DIG_VIN_CTL (at 0xa141)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1410 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_DIG_PULL_CTL (at 0xa142)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1420 0xa1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_DIG_IN_CTL (at 0xa143)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1430 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_EN_CTL (at 0xa146)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1460 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_ANA_OUT_CTL (at 0xa148)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1480 0xa1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_ANA_IN_CTL (at 0xa14a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a14a0 0xa14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_SINK_CTL (at 0xa14c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a14c0 0xa14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_SEC_ACCESS (at 0xa1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1d00 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1d80 0xa1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1d90 0xa1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1da0 0xa1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a1db0 0xa1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION1 (at 0xa200)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2000 0xa2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION2 (at 0xa201)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2010 0xa2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION3 (at 0xa202)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2020 0xa2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_REVISION4 (at 0xa203)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2030 0xa2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_TYPE (at 0xa204)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2040 0xa2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_SUBTYPE (at 0xa205)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2050 0xa2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_STATUS1 (at 0xa208)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2080 0xa2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_RT_STS (at 0xa210)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2100 0xa2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_SET_TYPE (at 0xa211)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2110 0xa2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_POLARITY_HIGH (at 0xa212)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2120 0xa2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_POLARITY_LOW (at 0xa213)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2130 0xa2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_LATCHED_CLR (at 0xa214)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2140 0xa2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_EN_SET (at 0xa215)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2150 0xa2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_EN_CLR (at 0xa216)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2160 0xa2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_LATCHED_STS (at 0xa218)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2180 0xa2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_PENDING_STS (at 0xa219)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2190 0xa2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_MID_SEL (at 0xa21a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a21a0 0xa21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_INT_PRIORITY (at 0xa21b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a21b0 0xa21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_MODE_CTL (at 0xa240)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2400 0xa2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_DIG_VIN_CTL (at 0xa241)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2410 0xa2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_DIG_PULL_CTL (at 0xa242)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2420 0xa2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_DIG_IN_CTL (at 0xa243)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2430 0xa2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_EN_CTL (at 0xa246)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2460 0xa2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_ANA_OUT_CTL (at 0xa248)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2480 0xa2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_ANA_IN_CTL (at 0xa24a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a24a0 0xa24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_SINK_CTL (at 0xa24c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a24c0 0xa24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_SEC_ACCESS (at 0xa2d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2d00 0xa2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2d80 0xa2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2d90 0xa2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2da0 0xa2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a2db0 0xa2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION1 (at 0xa300)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3000 0xa3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION2 (at 0xa301)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3010 0xa3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION3 (at 0xa302)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3020 0xa3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_REVISION4 (at 0xa303)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3030 0xa3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_TYPE (at 0xa304)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3040 0xa3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_SUBTYPE (at 0xa305)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3050 0xa3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_STATUS1 (at 0xa308)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3080 0xa3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_RT_STS (at 0xa310)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3100 0xa3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_SET_TYPE (at 0xa311)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3110 0xa3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_POLARITY_HIGH (at 0xa312)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3120 0xa3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_POLARITY_LOW (at 0xa313)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3130 0xa3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_LATCHED_CLR (at 0xa314)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3140 0xa3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_EN_SET (at 0xa315)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3150 0xa3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_EN_CLR (at 0xa316)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3160 0xa3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_LATCHED_STS (at 0xa318)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3180 0xa3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_PENDING_STS (at 0xa319)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3190 0xa3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_MID_SEL (at 0xa31a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a31a0 0xa31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_INT_PRIORITY (at 0xa31b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a31b0 0xa31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_MODE_CTL (at 0xa340)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3400 0xa3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_DIG_VIN_CTL (at 0xa341)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3410 0xa3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_DIG_PULL_CTL (at 0xa342)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3420 0xa3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_DIG_IN_CTL (at 0xa343)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3430 0xa3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_EN_CTL (at 0xa346)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3460 0xa3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_ANA_OUT_CTL (at 0xa348)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3480 0xa3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_ANA_IN_CTL (at 0xa34a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a34a0 0xa34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_SINK_CTL (at 0xa34c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a34c0 0xa34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_SEC_ACCESS (at 0xa3d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3d00 0xa3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3d80 0xa3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3d90 0xa3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3da0 0xa3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a3db0 0xa3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP5"
  tree "MPP5"
    tree "MPP5_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_REVISION1 (at 0xa400)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4000 0xa4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP5_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_REVISION2 (at 0xa401)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4010 0xa4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP5_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_REVISION3 (at 0xa402)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4020 0xa4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP5_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_REVISION4 (at 0xa403)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4030 0xa4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP5_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_PERPH_TYPE (at 0xa404)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4040 0xa4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP5_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_PERPH_SUBTYPE (at 0xa405)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4050 0xa4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP5_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_STATUS1 (at 0xa408)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4080 0xa4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP5_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_RT_STS (at 0xa410)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4100 0xa4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP5_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_SET_TYPE (at 0xa411)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4110 0xa4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP5_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_POLARITY_HIGH (at 0xa412)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4120 0xa4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_POLARITY_LOW (at 0xa413)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4130 0xa4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_LATCHED_CLR (at 0xa414)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4140 0xa4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP5_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_EN_SET (at 0xa415)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4150 0xa4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_EN_CLR (at 0xa416)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4160 0xa4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_LATCHED_STS (at 0xa418)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4180 0xa4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP5_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_PENDING_STS (at 0xa419)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4190 0xa4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP5_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_MID_SEL (at 0xa41a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a41a0 0xa41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP5_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_INT_PRIORITY (at 0xa41b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a41b0 0xa41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP5_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_MODE_CTL (at 0xa440)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4400 0xa4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP5_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_DIG_VIN_CTL (at 0xa441)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4410 0xa4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_DIG_PULL_CTL (at 0xa442)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4420 0xa4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_DIG_IN_CTL (at 0xa443)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4430 0xa4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP5_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_EN_CTL (at 0xa446)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4460 0xa4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP5_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_ANA_OUT_CTL (at 0xa448)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4480 0xa4480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_ANA_IN_CTL (at 0xa44a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a44a0 0xa44a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_SINK_CTL (at 0xa44c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a44c0 0xa44c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP5_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_SEC_ACCESS (at 0xa4d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4d00 0xa4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP5_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_PERPH_RESET_CTL1 (at 0xa4d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4d80 0xa4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_PERPH_RESET_CTL2 (at 0xa4d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4d90 0xa4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_PERPH_RESET_CTL3 (at 0xa4da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4da0 0xa4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP5_PERPH_RESET_CTL4 (at 0xa4db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a4db0 0xa4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP6"
  tree "MPP6"
    tree "MPP6_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_REVISION1 (at 0xa500)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5000 0xa5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP6_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_REVISION2 (at 0xa501)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5010 0xa5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP6_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_REVISION3 (at 0xa502)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5020 0xa5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP6_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_REVISION4 (at 0xa503)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5030 0xa5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP6_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_PERPH_TYPE (at 0xa504)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5040 0xa5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP6_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_PERPH_SUBTYPE (at 0xa505)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5050 0xa5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP6_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_STATUS1 (at 0xa508)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5080 0xa5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP6_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_RT_STS (at 0xa510)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5100 0xa5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP6_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_SET_TYPE (at 0xa511)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5110 0xa5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP6_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_POLARITY_HIGH (at 0xa512)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5120 0xa5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_POLARITY_LOW (at 0xa513)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5130 0xa5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_LATCHED_CLR (at 0xa514)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5140 0xa5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP6_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_EN_SET (at 0xa515)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5150 0xa5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_EN_CLR (at 0xa516)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5160 0xa5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_LATCHED_STS (at 0xa518)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5180 0xa5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP6_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_PENDING_STS (at 0xa519)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5190 0xa5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP6_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_MID_SEL (at 0xa51a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a51a0 0xa51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP6_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_INT_PRIORITY (at 0xa51b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a51b0 0xa51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP6_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_MODE_CTL (at 0xa540)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5400 0xa5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP6_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_DIG_VIN_CTL (at 0xa541)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5410 0xa5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_DIG_PULL_CTL (at 0xa542)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5420 0xa5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_DIG_IN_CTL (at 0xa543)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5430 0xa5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP6_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_EN_CTL (at 0xa546)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5460 0xa5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP6_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_ANA_OUT_CTL (at 0xa548)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5480 0xa5480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_ANA_IN_CTL (at 0xa54a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a54a0 0xa54a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_SINK_CTL (at 0xa54c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a54c0 0xa54c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP6_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_SEC_ACCESS (at 0xa5d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5d00 0xa5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP6_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_PERPH_RESET_CTL1 (at 0xa5d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5d80 0xa5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_PERPH_RESET_CTL2 (at 0xa5d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5d90 0xa5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_PERPH_RESET_CTL3 (at 0xa5da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5da0 0xa5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP6_PERPH_RESET_CTL4 (at 0xa5db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a5db0 0xa5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP7"
  tree "MPP7"
    tree "MPP7_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_REVISION1 (at 0xa600)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6000 0xa6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP7_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_REVISION2 (at 0xa601)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6010 0xa6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP7_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_REVISION3 (at 0xa602)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6020 0xa6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP7_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_REVISION4 (at 0xa603)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6030 0xa6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP7_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_PERPH_TYPE (at 0xa604)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6040 0xa6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP7_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_PERPH_SUBTYPE (at 0xa605)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6050 0xa6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP7_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_STATUS1 (at 0xa608)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6080 0xa6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP7_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_RT_STS (at 0xa610)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6100 0xa6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP7_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_SET_TYPE (at 0xa611)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6110 0xa6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP7_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_POLARITY_HIGH (at 0xa612)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6120 0xa6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP7_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_POLARITY_LOW (at 0xa613)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6130 0xa6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP7_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_LATCHED_CLR (at 0xa614)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6140 0xa6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP7_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_EN_SET (at 0xa615)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6150 0xa6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP7_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_EN_CLR (at 0xa616)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6160 0xa6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP7_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_LATCHED_STS (at 0xa618)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6180 0xa6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP7_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_PENDING_STS (at 0xa619)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6190 0xa6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP7_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_MID_SEL (at 0xa61a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a61a0 0xa61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP7_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_INT_PRIORITY (at 0xa61b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a61b0 0xa61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP7_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_MODE_CTL (at 0xa640)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6400 0xa6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP7_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_DIG_VIN_CTL (at 0xa641)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6410 0xa6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP7_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_DIG_PULL_CTL (at 0xa642)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6420 0xa6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP7_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_DIG_IN_CTL (at 0xa643)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6430 0xa6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP7_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_EN_CTL (at 0xa646)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6460 0xa6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP7_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_ANA_OUT_CTL (at 0xa648)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6480 0xa6480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP7_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_ANA_IN_CTL (at 0xa64a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a64a0 0xa64a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP7_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_SINK_CTL (at 0xa64c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a64c0 0xa64c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP7_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_SEC_ACCESS (at 0xa6d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6d00 0xa6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP7_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_PERPH_RESET_CTL1 (at 0xa6d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6d80 0xa6d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP7_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_PERPH_RESET_CTL2 (at 0xa6d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6d90 0xa6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP7_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_PERPH_RESET_CTL3 (at 0xa6da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6da0 0xa6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP7_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP7_PERPH_RESET_CTL4 (at 0xa6db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a6db0 0xa6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP8"
  tree "MPP8"
    tree "MPP8_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_REVISION1 (at 0xa700)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7000 0xa7000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP8_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_REVISION2 (at 0xa701)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7010 0xa7010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP8_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_REVISION3 (at 0xa702)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7020 0xa7020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP8_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_REVISION4 (at 0xa703)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7030 0xa7030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP8_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_PERPH_TYPE (at 0xa704)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7040 0xa7040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP8_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_PERPH_SUBTYPE (at 0xa705)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7050 0xa7050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP8_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_STATUS1 (at 0xa708)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7080 0xa7080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP8_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_RT_STS (at 0xa710)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7100 0xa7100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP8_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_SET_TYPE (at 0xa711)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7110 0xa7110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP8_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_POLARITY_HIGH (at 0xa712)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7120 0xa7120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP8_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_POLARITY_LOW (at 0xa713)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7130 0xa7130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP8_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_LATCHED_CLR (at 0xa714)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7140 0xa7140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP8_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_EN_SET (at 0xa715)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7150 0xa7150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP8_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_EN_CLR (at 0xa716)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7160 0xa7160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP8_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_LATCHED_STS (at 0xa718)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7180 0xa7180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP8_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_PENDING_STS (at 0xa719)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7190 0xa7190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP8_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_MID_SEL (at 0xa71a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a71a0 0xa71a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP8_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_INT_PRIORITY (at 0xa71b)"
      tindex ezaxi:0xfc4cf980 %l 0x80a71b0 0xa71b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP8_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_MODE_CTL (at 0xa740)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7400 0xa7400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP8_DIG_VIN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_DIG_VIN_CTL (at 0xa741)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7410 0xa7410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP8_DIG_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_DIG_PULL_CTL (at 0xa742)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7420 0xa7420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP8_DIG_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_DIG_IN_CTL (at 0xa743)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7430 0xa7430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP8_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_EN_CTL (at 0xa746)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7460 0xa7460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP8_ANA_OUT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_ANA_OUT_CTL (at 0xa748)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7480 0xa7480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP8_ANA_IN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_ANA_IN_CTL (at 0xa74a)"
      tindex ezaxi:0xfc4cf980 %l 0x80a74a0 0xa74a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP8_SINK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_SINK_CTL (at 0xa74c)"
      tindex ezaxi:0xfc4cf980 %l 0x80a74c0 0xa74c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP8_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_SEC_ACCESS (at 0xa7d0)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7d00 0xa7d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP8_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_PERPH_RESET_CTL1 (at 0xa7d8)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7d80 0xa7d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP8_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_PERPH_RESET_CTL2 (at 0xa7d9)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7d90 0xa7d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP8_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_PERPH_RESET_CTL3 (at 0xa7da)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7da0 0xa7da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP8_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "MPP8_PERPH_RESET_CTL4 (at 0xa7db)"
      tindex ezaxi:0xfc4cf980 %l 0x80a7db0 0xa7db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION1 (at 0x7100)"
      tindex ezaxi:0xfc4cf980 %l 0x8071000 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION2 (at 0x7101)"
      tindex ezaxi:0xfc4cf980 %l 0x8071010 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION3 (at 0x7102)"
      tindex ezaxi:0xfc4cf980 %l 0x8071020 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_REVISION4 (at 0x7103)"
      tindex ezaxi:0xfc4cf980 %l 0x8071030 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
      tindex ezaxi:0xfc4cf980 %l 0x8071040 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
      tindex ezaxi:0xfc4cf980 %l 0x8071050 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_STATUS0 (at 0x7108)"
      tindex ezaxi:0xfc4cf980 %l 0x8071080 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_STATUS1 (at 0x7109)"
      tindex ezaxi:0xfc4cf980 %l 0x8071090 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
      tindex ezaxi:0xfc4cf980 %l 0x8071100 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
      tindex ezaxi:0xfc4cf980 %l 0x8071110 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
      tindex ezaxi:0xfc4cf980 %l 0x8071120 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
      tindex ezaxi:0xfc4cf980 %l 0x8071130 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
      tindex ezaxi:0xfc4cf980 %l 0x8071140 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
      tindex ezaxi:0xfc4cf980 %l 0x8071150 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
      tindex ezaxi:0xfc4cf980 %l 0x8071160 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
      tindex ezaxi:0xfc4cf980 %l 0x8071180 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
      tindex ezaxi:0xfc4cf980 %l 0x8071190 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
      tindex ezaxi:0xfc4cf980 %l 0x80711a0 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
      tindex ezaxi:0xfc4cf980 %l 0x80711b0 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
      tindex ezaxi:0xfc4cf980 %l 0x8071400 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
      tindex ezaxi:0xfc4cf980 %l 0x8071420 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_EN_CTL (at 0x7146)"
      tindex ezaxi:0xfc4cf980 %l 0x8071460 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8071d00 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8071d80 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8071d90 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
      tindex ezaxi:0xfc4cf980 %l 0x8071da0 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
      tindex ezaxi:0xfc4cf980 %l 0x8071db0 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8071e00 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8071e10 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION1 (at 0x7200)"
      tindex ezaxi:0xfc4cf980 %l 0x8072000 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION2 (at 0x7201)"
      tindex ezaxi:0xfc4cf980 %l 0x8072010 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION3 (at 0x7202)"
      tindex ezaxi:0xfc4cf980 %l 0x8072020 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_REVISION4 (at 0x7203)"
      tindex ezaxi:0xfc4cf980 %l 0x8072030 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
      tindex ezaxi:0xfc4cf980 %l 0x8072040 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
      tindex ezaxi:0xfc4cf980 %l 0x8072050 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_STATUS0 (at 0x7208)"
      tindex ezaxi:0xfc4cf980 %l 0x8072080 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_STATUS1 (at 0x7209)"
      tindex ezaxi:0xfc4cf980 %l 0x8072090 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
      tindex ezaxi:0xfc4cf980 %l 0x8072100 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
      tindex ezaxi:0xfc4cf980 %l 0x8072110 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
      tindex ezaxi:0xfc4cf980 %l 0x8072120 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
      tindex ezaxi:0xfc4cf980 %l 0x8072130 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
      tindex ezaxi:0xfc4cf980 %l 0x8072140 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
      tindex ezaxi:0xfc4cf980 %l 0x8072150 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
      tindex ezaxi:0xfc4cf980 %l 0x8072160 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
      tindex ezaxi:0xfc4cf980 %l 0x8072180 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
      tindex ezaxi:0xfc4cf980 %l 0x8072190 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
      tindex ezaxi:0xfc4cf980 %l 0x80721a0 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
      tindex ezaxi:0xfc4cf980 %l 0x80721b0 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
      tindex ezaxi:0xfc4cf980 %l 0x8072400 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
      tindex ezaxi:0xfc4cf980 %l 0x8072420 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_EN_CTL (at 0x7246)"
      tindex ezaxi:0xfc4cf980 %l 0x8072460 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8072d00 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8072d80 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8072d90 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
      tindex ezaxi:0xfc4cf980 %l 0x8072da0 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
      tindex ezaxi:0xfc4cf980 %l 0x8072db0 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8072e00 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8072e10 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT10"
  tree "PBS_CLIENT10"
    tree "PBS_CLIENT10_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION1 (at 0x7b00)"
      tindex ezaxi:0xfc4cf980 %l 0x807b000 0x7b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION2 (at 0x7b01)"
      tindex ezaxi:0xfc4cf980 %l 0x807b010 0x7b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION3 (at 0x7b02)"
      tindex ezaxi:0xfc4cf980 %l 0x807b020 0x7b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_REVISION4 (at 0x7b03)"
      tindex ezaxi:0xfc4cf980 %l 0x807b030 0x7b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_TYPE (at 0x7b04)"
      tindex ezaxi:0xfc4cf980 %l 0x807b040 0x7b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT10_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_SUBTYPE (at 0x7b05)"
      tindex ezaxi:0xfc4cf980 %l 0x807b050 0x7b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT10_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_STATUS0 (at 0x7b08)"
      tindex ezaxi:0xfc4cf980 %l 0x807b080 0x7b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_STATUS1 (at 0x7b09)"
      tindex ezaxi:0xfc4cf980 %l 0x807b090 0x7b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT10_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_RT_STS (at 0x7b10)"
      tindex ezaxi:0xfc4cf980 %l 0x807b100 0x7b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT10_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_SET_TYPE (at 0x7b11)"
      tindex ezaxi:0xfc4cf980 %l 0x807b110 0x7b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_POLARITY_HIGH (at 0x7b12)"
      tindex ezaxi:0xfc4cf980 %l 0x807b120 0x7b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_POLARITY_LOW (at 0x7b13)"
      tindex ezaxi:0xfc4cf980 %l 0x807b130 0x7b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_LATCHED_CLR (at 0x7b14)"
      tindex ezaxi:0xfc4cf980 %l 0x807b140 0x7b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_EN_SET (at 0x7b15)"
      tindex ezaxi:0xfc4cf980 %l 0x807b150 0x7b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_EN_CLR (at 0x7b16)"
      tindex ezaxi:0xfc4cf980 %l 0x807b160 0x7b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_LATCHED_STS (at 0x7b18)"
      tindex ezaxi:0xfc4cf980 %l 0x807b180 0x7b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT10_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_PENDING_STS (at 0x7b19)"
      tindex ezaxi:0xfc4cf980 %l 0x807b190 0x7b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT10_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_MID_SEL (at 0x7b1a)"
      tindex ezaxi:0xfc4cf980 %l 0x807b1a0 0x7b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT10_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_PRIORITY (at 0x7b1b)"
      tindex ezaxi:0xfc4cf980 %l 0x807b1b0 0x7b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_TRIG_CFG (at 0x7b40)"
      tindex ezaxi:0xfc4cf980 %l 0x807b400 0x7b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT10_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_TRIG_CTL (at 0x7b42)"
      tindex ezaxi:0xfc4cf980 %l 0x807b420 0x7b420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_EN_CTL (at 0x7b46)"
      tindex ezaxi:0xfc4cf980 %l 0x807b460 0x7b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_SEC_ACCESS (at 0x7bd0)"
      tindex ezaxi:0xfc4cf980 %l 0x807bd00 0x7bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL1 (at 0x7bd8)"
      tindex ezaxi:0xfc4cf980 %l 0x807bd80 0x7bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL2 (at 0x7bd9)"
      tindex ezaxi:0xfc4cf980 %l 0x807bd90 0x7bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL3 (at 0x7bda)"
      tindex ezaxi:0xfc4cf980 %l 0x807bda0 0x7bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_PERPH_RESET_CTL4 (at 0x7bdb)"
      tindex ezaxi:0xfc4cf980 %l 0x807bdb0 0x7bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_TEST1 (at 0x7be0)"
      tindex ezaxi:0xfc4cf980 %l 0x807be00 0x7be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT10_INT_TEST_VAL (at 0x7be1)"
      tindex ezaxi:0xfc4cf980 %l 0x807be10 0x7be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT11"
  tree "PBS_CLIENT11"
    tree "PBS_CLIENT11_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION1 (at 0x7c00)"
      tindex ezaxi:0xfc4cf980 %l 0x807c000 0x7c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION2 (at 0x7c01)"
      tindex ezaxi:0xfc4cf980 %l 0x807c010 0x7c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION3 (at 0x7c02)"
      tindex ezaxi:0xfc4cf980 %l 0x807c020 0x7c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_REVISION4 (at 0x7c03)"
      tindex ezaxi:0xfc4cf980 %l 0x807c030 0x7c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_TYPE (at 0x7c04)"
      tindex ezaxi:0xfc4cf980 %l 0x807c040 0x7c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT11_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_SUBTYPE (at 0x7c05)"
      tindex ezaxi:0xfc4cf980 %l 0x807c050 0x7c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT11_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_STATUS0 (at 0x7c08)"
      tindex ezaxi:0xfc4cf980 %l 0x807c080 0x7c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_STATUS1 (at 0x7c09)"
      tindex ezaxi:0xfc4cf980 %l 0x807c090 0x7c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT11_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_RT_STS (at 0x7c10)"
      tindex ezaxi:0xfc4cf980 %l 0x807c100 0x7c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT11_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_SET_TYPE (at 0x7c11)"
      tindex ezaxi:0xfc4cf980 %l 0x807c110 0x7c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_POLARITY_HIGH (at 0x7c12)"
      tindex ezaxi:0xfc4cf980 %l 0x807c120 0x7c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_POLARITY_LOW (at 0x7c13)"
      tindex ezaxi:0xfc4cf980 %l 0x807c130 0x7c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_LATCHED_CLR (at 0x7c14)"
      tindex ezaxi:0xfc4cf980 %l 0x807c140 0x7c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_EN_SET (at 0x7c15)"
      tindex ezaxi:0xfc4cf980 %l 0x807c150 0x7c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_EN_CLR (at 0x7c16)"
      tindex ezaxi:0xfc4cf980 %l 0x807c160 0x7c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_LATCHED_STS (at 0x7c18)"
      tindex ezaxi:0xfc4cf980 %l 0x807c180 0x7c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT11_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_PENDING_STS (at 0x7c19)"
      tindex ezaxi:0xfc4cf980 %l 0x807c190 0x7c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT11_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_MID_SEL (at 0x7c1a)"
      tindex ezaxi:0xfc4cf980 %l 0x807c1a0 0x7c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT11_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_PRIORITY (at 0x7c1b)"
      tindex ezaxi:0xfc4cf980 %l 0x807c1b0 0x7c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_TRIG_CFG (at 0x7c40)"
      tindex ezaxi:0xfc4cf980 %l 0x807c400 0x7c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT11_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_TRIG_CTL (at 0x7c42)"
      tindex ezaxi:0xfc4cf980 %l 0x807c420 0x7c420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_EN_CTL (at 0x7c46)"
      tindex ezaxi:0xfc4cf980 %l 0x807c460 0x7c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_SEC_ACCESS (at 0x7cd0)"
      tindex ezaxi:0xfc4cf980 %l 0x807cd00 0x7cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL1 (at 0x7cd8)"
      tindex ezaxi:0xfc4cf980 %l 0x807cd80 0x7cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL2 (at 0x7cd9)"
      tindex ezaxi:0xfc4cf980 %l 0x807cd90 0x7cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL3 (at 0x7cda)"
      tindex ezaxi:0xfc4cf980 %l 0x807cda0 0x7cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_PERPH_RESET_CTL4 (at 0x7cdb)"
      tindex ezaxi:0xfc4cf980 %l 0x807cdb0 0x7cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_TEST1 (at 0x7ce0)"
      tindex ezaxi:0xfc4cf980 %l 0x807ce00 0x7ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT11_INT_TEST_VAL (at 0x7ce1)"
      tindex ezaxi:0xfc4cf980 %l 0x807ce10 0x7ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT12"
  tree "PBS_CLIENT12"
    tree "PBS_CLIENT12_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_REVISION1 (at 0x7d00)"
      tindex ezaxi:0xfc4cf980 %l 0x807d000 0x7d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_REVISION2 (at 0x7d01)"
      tindex ezaxi:0xfc4cf980 %l 0x807d010 0x7d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_REVISION3 (at 0x7d02)"
      tindex ezaxi:0xfc4cf980 %l 0x807d020 0x7d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_REVISION4 (at 0x7d03)"
      tindex ezaxi:0xfc4cf980 %l 0x807d030 0x7d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_PERPH_TYPE (at 0x7d04)"
      tindex ezaxi:0xfc4cf980 %l 0x807d040 0x7d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT12_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_PERPH_SUBTYPE (at 0x7d05)"
      tindex ezaxi:0xfc4cf980 %l 0x807d050 0x7d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT12_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_STATUS0 (at 0x7d08)"
      tindex ezaxi:0xfc4cf980 %l 0x807d080 0x7d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_STATUS1 (at 0x7d09)"
      tindex ezaxi:0xfc4cf980 %l 0x807d090 0x7d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT12_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_RT_STS (at 0x7d10)"
      tindex ezaxi:0xfc4cf980 %l 0x807d100 0x7d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT12_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_SET_TYPE (at 0x7d11)"
      tindex ezaxi:0xfc4cf980 %l 0x807d110 0x7d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_POLARITY_HIGH (at 0x7d12)"
      tindex ezaxi:0xfc4cf980 %l 0x807d120 0x7d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_POLARITY_LOW (at 0x7d13)"
      tindex ezaxi:0xfc4cf980 %l 0x807d130 0x7d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_LATCHED_CLR (at 0x7d14)"
      tindex ezaxi:0xfc4cf980 %l 0x807d140 0x7d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_EN_SET (at 0x7d15)"
      tindex ezaxi:0xfc4cf980 %l 0x807d150 0x7d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_EN_CLR (at 0x7d16)"
      tindex ezaxi:0xfc4cf980 %l 0x807d160 0x7d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_LATCHED_STS (at 0x7d18)"
      tindex ezaxi:0xfc4cf980 %l 0x807d180 0x7d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT12_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_PENDING_STS (at 0x7d19)"
      tindex ezaxi:0xfc4cf980 %l 0x807d190 0x7d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT12_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_MID_SEL (at 0x7d1a)"
      tindex ezaxi:0xfc4cf980 %l 0x807d1a0 0x7d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT12_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_PRIORITY (at 0x7d1b)"
      tindex ezaxi:0xfc4cf980 %l 0x807d1b0 0x7d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_TRIG_CFG (at 0x7d40)"
      tindex ezaxi:0xfc4cf980 %l 0x807d400 0x7d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT12_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_TRIG_CTL (at 0x7d42)"
      tindex ezaxi:0xfc4cf980 %l 0x807d420 0x7d420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_EN_CTL (at 0x7d46)"
      tindex ezaxi:0xfc4cf980 %l 0x807d460 0x7d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_SEC_ACCESS (at 0x7dd0)"
      tindex ezaxi:0xfc4cf980 %l 0x807dd00 0x7dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_PERPH_RESET_CTL1 (at 0x7dd8)"
      tindex ezaxi:0xfc4cf980 %l 0x807dd80 0x7dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_PERPH_RESET_CTL2 (at 0x7dd9)"
      tindex ezaxi:0xfc4cf980 %l 0x807dd90 0x7dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_PERPH_RESET_CTL3 (at 0x7dda)"
      tindex ezaxi:0xfc4cf980 %l 0x807dda0 0x7dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_PERPH_RESET_CTL4 (at 0x7ddb)"
      tindex ezaxi:0xfc4cf980 %l 0x807ddb0 0x7ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_TEST1 (at 0x7de0)"
      tindex ezaxi:0xfc4cf980 %l 0x807de00 0x7de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT12_INT_TEST_VAL (at 0x7de1)"
      tindex ezaxi:0xfc4cf980 %l 0x807de10 0x7de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT13"
  tree "PBS_CLIENT13"
    tree "PBS_CLIENT13_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_REVISION1 (at 0x7e00)"
      tindex ezaxi:0xfc4cf980 %l 0x807e000 0x7e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_REVISION2 (at 0x7e01)"
      tindex ezaxi:0xfc4cf980 %l 0x807e010 0x7e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_REVISION3 (at 0x7e02)"
      tindex ezaxi:0xfc4cf980 %l 0x807e020 0x7e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_REVISION4 (at 0x7e03)"
      tindex ezaxi:0xfc4cf980 %l 0x807e030 0x7e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_PERPH_TYPE (at 0x7e04)"
      tindex ezaxi:0xfc4cf980 %l 0x807e040 0x7e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT13_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_PERPH_SUBTYPE (at 0x7e05)"
      tindex ezaxi:0xfc4cf980 %l 0x807e050 0x7e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT13_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_STATUS0 (at 0x7e08)"
      tindex ezaxi:0xfc4cf980 %l 0x807e080 0x7e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_STATUS1 (at 0x7e09)"
      tindex ezaxi:0xfc4cf980 %l 0x807e090 0x7e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT13_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_RT_STS (at 0x7e10)"
      tindex ezaxi:0xfc4cf980 %l 0x807e100 0x7e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT13_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_SET_TYPE (at 0x7e11)"
      tindex ezaxi:0xfc4cf980 %l 0x807e110 0x7e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_POLARITY_HIGH (at 0x7e12)"
      tindex ezaxi:0xfc4cf980 %l 0x807e120 0x7e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_POLARITY_LOW (at 0x7e13)"
      tindex ezaxi:0xfc4cf980 %l 0x807e130 0x7e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_LATCHED_CLR (at 0x7e14)"
      tindex ezaxi:0xfc4cf980 %l 0x807e140 0x7e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_EN_SET (at 0x7e15)"
      tindex ezaxi:0xfc4cf980 %l 0x807e150 0x7e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_EN_CLR (at 0x7e16)"
      tindex ezaxi:0xfc4cf980 %l 0x807e160 0x7e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_LATCHED_STS (at 0x7e18)"
      tindex ezaxi:0xfc4cf980 %l 0x807e180 0x7e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT13_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_PENDING_STS (at 0x7e19)"
      tindex ezaxi:0xfc4cf980 %l 0x807e190 0x7e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT13_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_MID_SEL (at 0x7e1a)"
      tindex ezaxi:0xfc4cf980 %l 0x807e1a0 0x7e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT13_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_PRIORITY (at 0x7e1b)"
      tindex ezaxi:0xfc4cf980 %l 0x807e1b0 0x7e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_TRIG_CFG (at 0x7e40)"
      tindex ezaxi:0xfc4cf980 %l 0x807e400 0x7e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT13_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_TRIG_CTL (at 0x7e42)"
      tindex ezaxi:0xfc4cf980 %l 0x807e420 0x7e420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_EN_CTL (at 0x7e46)"
      tindex ezaxi:0xfc4cf980 %l 0x807e460 0x7e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_SEC_ACCESS (at 0x7ed0)"
      tindex ezaxi:0xfc4cf980 %l 0x807ed00 0x7ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_PERPH_RESET_CTL1 (at 0x7ed8)"
      tindex ezaxi:0xfc4cf980 %l 0x807ed80 0x7ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_PERPH_RESET_CTL2 (at 0x7ed9)"
      tindex ezaxi:0xfc4cf980 %l 0x807ed90 0x7ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_PERPH_RESET_CTL3 (at 0x7eda)"
      tindex ezaxi:0xfc4cf980 %l 0x807eda0 0x7eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_PERPH_RESET_CTL4 (at 0x7edb)"
      tindex ezaxi:0xfc4cf980 %l 0x807edb0 0x7edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT13_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_TEST1 (at 0x7ee0)"
      tindex ezaxi:0xfc4cf980 %l 0x807ee00 0x7ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT13_INT_TEST_VAL (at 0x7ee1)"
      tindex ezaxi:0xfc4cf980 %l 0x807ee10 0x7ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT14"
  tree "PBS_CLIENT14"
    tree "PBS_CLIENT14_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_REVISION1 (at 0x7f00)"
      tindex ezaxi:0xfc4cf980 %l 0x807f000 0x7f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_REVISION2 (at 0x7f01)"
      tindex ezaxi:0xfc4cf980 %l 0x807f010 0x7f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_REVISION3 (at 0x7f02)"
      tindex ezaxi:0xfc4cf980 %l 0x807f020 0x7f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_REVISION4 (at 0x7f03)"
      tindex ezaxi:0xfc4cf980 %l 0x807f030 0x7f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT14_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_PERPH_TYPE (at 0x7f04)"
      tindex ezaxi:0xfc4cf980 %l 0x807f040 0x7f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT14_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_PERPH_SUBTYPE (at 0x7f05)"
      tindex ezaxi:0xfc4cf980 %l 0x807f050 0x7f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT14_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_STATUS0 (at 0x7f08)"
      tindex ezaxi:0xfc4cf980 %l 0x807f080 0x7f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_STATUS1 (at 0x7f09)"
      tindex ezaxi:0xfc4cf980 %l 0x807f090 0x7f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT14_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_RT_STS (at 0x7f10)"
      tindex ezaxi:0xfc4cf980 %l 0x807f100 0x7f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT14_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_SET_TYPE (at 0x7f11)"
      tindex ezaxi:0xfc4cf980 %l 0x807f110 0x7f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT14_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_POLARITY_HIGH (at 0x7f12)"
      tindex ezaxi:0xfc4cf980 %l 0x807f120 0x7f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_POLARITY_LOW (at 0x7f13)"
      tindex ezaxi:0xfc4cf980 %l 0x807f130 0x7f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_LATCHED_CLR (at 0x7f14)"
      tindex ezaxi:0xfc4cf980 %l 0x807f140 0x7f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_EN_SET (at 0x7f15)"
      tindex ezaxi:0xfc4cf980 %l 0x807f150 0x7f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_EN_CLR (at 0x7f16)"
      tindex ezaxi:0xfc4cf980 %l 0x807f160 0x7f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_LATCHED_STS (at 0x7f18)"
      tindex ezaxi:0xfc4cf980 %l 0x807f180 0x7f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT14_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_PENDING_STS (at 0x7f19)"
      tindex ezaxi:0xfc4cf980 %l 0x807f190 0x7f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT14_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_MID_SEL (at 0x7f1a)"
      tindex ezaxi:0xfc4cf980 %l 0x807f1a0 0x7f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT14_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_PRIORITY (at 0x7f1b)"
      tindex ezaxi:0xfc4cf980 %l 0x807f1b0 0x7f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_TRIG_CFG (at 0x7f40)"
      tindex ezaxi:0xfc4cf980 %l 0x807f400 0x7f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT14_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_TRIG_CTL (at 0x7f42)"
      tindex ezaxi:0xfc4cf980 %l 0x807f420 0x7f420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_EN_CTL (at 0x7f46)"
      tindex ezaxi:0xfc4cf980 %l 0x807f460 0x7f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_SEC_ACCESS (at 0x7fd0)"
      tindex ezaxi:0xfc4cf980 %l 0x807fd00 0x7fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_PERPH_RESET_CTL1 (at 0x7fd8)"
      tindex ezaxi:0xfc4cf980 %l 0x807fd80 0x7fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_PERPH_RESET_CTL2 (at 0x7fd9)"
      tindex ezaxi:0xfc4cf980 %l 0x807fd90 0x7fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_PERPH_RESET_CTL3 (at 0x7fda)"
      tindex ezaxi:0xfc4cf980 %l 0x807fda0 0x7fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_PERPH_RESET_CTL4 (at 0x7fdb)"
      tindex ezaxi:0xfc4cf980 %l 0x807fdb0 0x7fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT14_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_TEST1 (at 0x7fe0)"
      tindex ezaxi:0xfc4cf980 %l 0x807fe00 0x7fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT14_INT_TEST_VAL (at 0x7fe1)"
      tindex ezaxi:0xfc4cf980 %l 0x807fe10 0x7fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT15"
  tree "PBS_CLIENT15"
    tree "PBS_CLIENT15_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_REVISION1 (at 0x8000)"
      tindex ezaxi:0xfc4cf980 %l 0x8080000 0x80000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_REVISION2 (at 0x8001)"
      tindex ezaxi:0xfc4cf980 %l 0x8080010 0x80010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_REVISION3 (at 0x8002)"
      tindex ezaxi:0xfc4cf980 %l 0x8080020 0x80020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_REVISION4 (at 0x8003)"
      tindex ezaxi:0xfc4cf980 %l 0x8080030 0x80030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT15_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_PERPH_TYPE (at 0x8004)"
      tindex ezaxi:0xfc4cf980 %l 0x8080040 0x80040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT15_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_PERPH_SUBTYPE (at 0x8005)"
      tindex ezaxi:0xfc4cf980 %l 0x8080050 0x80050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT15_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_STATUS0 (at 0x8008)"
      tindex ezaxi:0xfc4cf980 %l 0x8080080 0x80080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_STATUS1 (at 0x8009)"
      tindex ezaxi:0xfc4cf980 %l 0x8080090 0x80090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT15_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_RT_STS (at 0x8010)"
      tindex ezaxi:0xfc4cf980 %l 0x8080100 0x80100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT15_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_SET_TYPE (at 0x8011)"
      tindex ezaxi:0xfc4cf980 %l 0x8080110 0x80110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT15_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_POLARITY_HIGH (at 0x8012)"
      tindex ezaxi:0xfc4cf980 %l 0x8080120 0x80120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_POLARITY_LOW (at 0x8013)"
      tindex ezaxi:0xfc4cf980 %l 0x8080130 0x80130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_LATCHED_CLR (at 0x8014)"
      tindex ezaxi:0xfc4cf980 %l 0x8080140 0x80140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_EN_SET (at 0x8015)"
      tindex ezaxi:0xfc4cf980 %l 0x8080150 0x80150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_EN_CLR (at 0x8016)"
      tindex ezaxi:0xfc4cf980 %l 0x8080160 0x80160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_LATCHED_STS (at 0x8018)"
      tindex ezaxi:0xfc4cf980 %l 0x8080180 0x80180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT15_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_PENDING_STS (at 0x8019)"
      tindex ezaxi:0xfc4cf980 %l 0x8080190 0x80190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT15_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_MID_SEL (at 0x801a)"
      tindex ezaxi:0xfc4cf980 %l 0x80801a0 0x801a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT15_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_PRIORITY (at 0x801b)"
      tindex ezaxi:0xfc4cf980 %l 0x80801b0 0x801b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_TRIG_CFG (at 0x8040)"
      tindex ezaxi:0xfc4cf980 %l 0x8080400 0x80400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT15_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_TRIG_CTL (at 0x8042)"
      tindex ezaxi:0xfc4cf980 %l 0x8080420 0x80420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_EN_CTL (at 0x8046)"
      tindex ezaxi:0xfc4cf980 %l 0x8080460 0x80460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_SEC_ACCESS (at 0x80d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8080d00 0x80d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_PERPH_RESET_CTL1 (at 0x80d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8080d80 0x80d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_PERPH_RESET_CTL2 (at 0x80d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8080d90 0x80d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_PERPH_RESET_CTL3 (at 0x80da)"
      tindex ezaxi:0xfc4cf980 %l 0x8080da0 0x80da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_PERPH_RESET_CTL4 (at 0x80db)"
      tindex ezaxi:0xfc4cf980 %l 0x8080db0 0x80db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT15_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_TEST1 (at 0x80e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8080e00 0x80e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT15_INT_TEST_VAL (at 0x80e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8080e10 0x80e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION1 (at 0x7300)"
      tindex ezaxi:0xfc4cf980 %l 0x8073000 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION2 (at 0x7301)"
      tindex ezaxi:0xfc4cf980 %l 0x8073010 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION3 (at 0x7302)"
      tindex ezaxi:0xfc4cf980 %l 0x8073020 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_REVISION4 (at 0x7303)"
      tindex ezaxi:0xfc4cf980 %l 0x8073030 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
      tindex ezaxi:0xfc4cf980 %l 0x8073040 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
      tindex ezaxi:0xfc4cf980 %l 0x8073050 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_STATUS0 (at 0x7308)"
      tindex ezaxi:0xfc4cf980 %l 0x8073080 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_STATUS1 (at 0x7309)"
      tindex ezaxi:0xfc4cf980 %l 0x8073090 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
      tindex ezaxi:0xfc4cf980 %l 0x8073100 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
      tindex ezaxi:0xfc4cf980 %l 0x8073110 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
      tindex ezaxi:0xfc4cf980 %l 0x8073120 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
      tindex ezaxi:0xfc4cf980 %l 0x8073130 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
      tindex ezaxi:0xfc4cf980 %l 0x8073140 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
      tindex ezaxi:0xfc4cf980 %l 0x8073150 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
      tindex ezaxi:0xfc4cf980 %l 0x8073160 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
      tindex ezaxi:0xfc4cf980 %l 0x8073180 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
      tindex ezaxi:0xfc4cf980 %l 0x8073190 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
      tindex ezaxi:0xfc4cf980 %l 0x80731a0 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
      tindex ezaxi:0xfc4cf980 %l 0x80731b0 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
      tindex ezaxi:0xfc4cf980 %l 0x8073400 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
      tindex ezaxi:0xfc4cf980 %l 0x8073420 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_EN_CTL (at 0x7346)"
      tindex ezaxi:0xfc4cf980 %l 0x8073460 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8073d00 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8073d80 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8073d90 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
      tindex ezaxi:0xfc4cf980 %l 0x8073da0 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
      tindex ezaxi:0xfc4cf980 %l 0x8073db0 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8073e00 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8073e10 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION1 (at 0x7400)"
      tindex ezaxi:0xfc4cf980 %l 0x8074000 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION2 (at 0x7401)"
      tindex ezaxi:0xfc4cf980 %l 0x8074010 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION3 (at 0x7402)"
      tindex ezaxi:0xfc4cf980 %l 0x8074020 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_REVISION4 (at 0x7403)"
      tindex ezaxi:0xfc4cf980 %l 0x8074030 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
      tindex ezaxi:0xfc4cf980 %l 0x8074040 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
      tindex ezaxi:0xfc4cf980 %l 0x8074050 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_STATUS0 (at 0x7408)"
      tindex ezaxi:0xfc4cf980 %l 0x8074080 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_STATUS1 (at 0x7409)"
      tindex ezaxi:0xfc4cf980 %l 0x8074090 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
      tindex ezaxi:0xfc4cf980 %l 0x8074100 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
      tindex ezaxi:0xfc4cf980 %l 0x8074110 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
      tindex ezaxi:0xfc4cf980 %l 0x8074120 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
      tindex ezaxi:0xfc4cf980 %l 0x8074130 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
      tindex ezaxi:0xfc4cf980 %l 0x8074140 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
      tindex ezaxi:0xfc4cf980 %l 0x8074150 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
      tindex ezaxi:0xfc4cf980 %l 0x8074160 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
      tindex ezaxi:0xfc4cf980 %l 0x8074180 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
      tindex ezaxi:0xfc4cf980 %l 0x8074190 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
      tindex ezaxi:0xfc4cf980 %l 0x80741a0 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
      tindex ezaxi:0xfc4cf980 %l 0x80741b0 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
      tindex ezaxi:0xfc4cf980 %l 0x8074400 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
      tindex ezaxi:0xfc4cf980 %l 0x8074420 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_EN_CTL (at 0x7446)"
      tindex ezaxi:0xfc4cf980 %l 0x8074460 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8074d00 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8074d80 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8074d90 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
      tindex ezaxi:0xfc4cf980 %l 0x8074da0 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
      tindex ezaxi:0xfc4cf980 %l 0x8074db0 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8074e00 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8074e10 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION1 (at 0x7500)"
      tindex ezaxi:0xfc4cf980 %l 0x8075000 0x75000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION2 (at 0x7501)"
      tindex ezaxi:0xfc4cf980 %l 0x8075010 0x75010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION3 (at 0x7502)"
      tindex ezaxi:0xfc4cf980 %l 0x8075020 0x75020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_REVISION4 (at 0x7503)"
      tindex ezaxi:0xfc4cf980 %l 0x8075030 0x75030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
      tindex ezaxi:0xfc4cf980 %l 0x8075040 0x75040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
      tindex ezaxi:0xfc4cf980 %l 0x8075050 0x75050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_STATUS0 (at 0x7508)"
      tindex ezaxi:0xfc4cf980 %l 0x8075080 0x75080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_STATUS1 (at 0x7509)"
      tindex ezaxi:0xfc4cf980 %l 0x8075090 0x75090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
      tindex ezaxi:0xfc4cf980 %l 0x8075100 0x75100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
      tindex ezaxi:0xfc4cf980 %l 0x8075110 0x75110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
      tindex ezaxi:0xfc4cf980 %l 0x8075120 0x75120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
      tindex ezaxi:0xfc4cf980 %l 0x8075130 0x75130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
      tindex ezaxi:0xfc4cf980 %l 0x8075140 0x75140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
      tindex ezaxi:0xfc4cf980 %l 0x8075150 0x75150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
      tindex ezaxi:0xfc4cf980 %l 0x8075160 0x75160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
      tindex ezaxi:0xfc4cf980 %l 0x8075180 0x75180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
      tindex ezaxi:0xfc4cf980 %l 0x8075190 0x75190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
      tindex ezaxi:0xfc4cf980 %l 0x80751a0 0x751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
      tindex ezaxi:0xfc4cf980 %l 0x80751b0 0x751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
      tindex ezaxi:0xfc4cf980 %l 0x8075400 0x75400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
      tindex ezaxi:0xfc4cf980 %l 0x8075420 0x75420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_EN_CTL (at 0x7546)"
      tindex ezaxi:0xfc4cf980 %l 0x8075460 0x75460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8075d00 0x75d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8075d80 0x75d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8075d90 0x75d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
      tindex ezaxi:0xfc4cf980 %l 0x8075da0 0x75da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
      tindex ezaxi:0xfc4cf980 %l 0x8075db0 0x75db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8075e00 0x75e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8075e10 0x75e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION1 (at 0x7600)"
      tindex ezaxi:0xfc4cf980 %l 0x8076000 0x76000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION2 (at 0x7601)"
      tindex ezaxi:0xfc4cf980 %l 0x8076010 0x76010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION3 (at 0x7602)"
      tindex ezaxi:0xfc4cf980 %l 0x8076020 0x76020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_REVISION4 (at 0x7603)"
      tindex ezaxi:0xfc4cf980 %l 0x8076030 0x76030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
      tindex ezaxi:0xfc4cf980 %l 0x8076040 0x76040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
      tindex ezaxi:0xfc4cf980 %l 0x8076050 0x76050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_STATUS0 (at 0x7608)"
      tindex ezaxi:0xfc4cf980 %l 0x8076080 0x76080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_STATUS1 (at 0x7609)"
      tindex ezaxi:0xfc4cf980 %l 0x8076090 0x76090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
      tindex ezaxi:0xfc4cf980 %l 0x8076100 0x76100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
      tindex ezaxi:0xfc4cf980 %l 0x8076110 0x76110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
      tindex ezaxi:0xfc4cf980 %l 0x8076120 0x76120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
      tindex ezaxi:0xfc4cf980 %l 0x8076130 0x76130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
      tindex ezaxi:0xfc4cf980 %l 0x8076140 0x76140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
      tindex ezaxi:0xfc4cf980 %l 0x8076150 0x76150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
      tindex ezaxi:0xfc4cf980 %l 0x8076160 0x76160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
      tindex ezaxi:0xfc4cf980 %l 0x8076180 0x76180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
      tindex ezaxi:0xfc4cf980 %l 0x8076190 0x76190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
      tindex ezaxi:0xfc4cf980 %l 0x80761a0 0x761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
      tindex ezaxi:0xfc4cf980 %l 0x80761b0 0x761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
      tindex ezaxi:0xfc4cf980 %l 0x8076400 0x76400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
      tindex ezaxi:0xfc4cf980 %l 0x8076420 0x76420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_EN_CTL (at 0x7646)"
      tindex ezaxi:0xfc4cf980 %l 0x8076460 0x76460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8076d00 0x76d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8076d80 0x76d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8076d90 0x76d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
      tindex ezaxi:0xfc4cf980 %l 0x8076da0 0x76da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
      tindex ezaxi:0xfc4cf980 %l 0x8076db0 0x76db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8076e00 0x76e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8076e10 0x76e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION1 (at 0x7700)"
      tindex ezaxi:0xfc4cf980 %l 0x8077000 0x77000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION2 (at 0x7701)"
      tindex ezaxi:0xfc4cf980 %l 0x8077010 0x77010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION3 (at 0x7702)"
      tindex ezaxi:0xfc4cf980 %l 0x8077020 0x77020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_REVISION4 (at 0x7703)"
      tindex ezaxi:0xfc4cf980 %l 0x8077030 0x77030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
      tindex ezaxi:0xfc4cf980 %l 0x8077040 0x77040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
      tindex ezaxi:0xfc4cf980 %l 0x8077050 0x77050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_STATUS0 (at 0x7708)"
      tindex ezaxi:0xfc4cf980 %l 0x8077080 0x77080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_STATUS1 (at 0x7709)"
      tindex ezaxi:0xfc4cf980 %l 0x8077090 0x77090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
      tindex ezaxi:0xfc4cf980 %l 0x8077100 0x77100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
      tindex ezaxi:0xfc4cf980 %l 0x8077110 0x77110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
      tindex ezaxi:0xfc4cf980 %l 0x8077120 0x77120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
      tindex ezaxi:0xfc4cf980 %l 0x8077130 0x77130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
      tindex ezaxi:0xfc4cf980 %l 0x8077140 0x77140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
      tindex ezaxi:0xfc4cf980 %l 0x8077150 0x77150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
      tindex ezaxi:0xfc4cf980 %l 0x8077160 0x77160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
      tindex ezaxi:0xfc4cf980 %l 0x8077180 0x77180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
      tindex ezaxi:0xfc4cf980 %l 0x8077190 0x77190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
      tindex ezaxi:0xfc4cf980 %l 0x80771a0 0x771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
      tindex ezaxi:0xfc4cf980 %l 0x80771b0 0x771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
      tindex ezaxi:0xfc4cf980 %l 0x8077400 0x77400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
      tindex ezaxi:0xfc4cf980 %l 0x8077420 0x77420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_EN_CTL (at 0x7746)"
      tindex ezaxi:0xfc4cf980 %l 0x8077460 0x77460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8077d00 0x77d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8077d80 0x77d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8077d90 0x77d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
      tindex ezaxi:0xfc4cf980 %l 0x8077da0 0x77da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
      tindex ezaxi:0xfc4cf980 %l 0x8077db0 0x77db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8077e00 0x77e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8077e10 0x77e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION1 (at 0x7800)"
      tindex ezaxi:0xfc4cf980 %l 0x8078000 0x78000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION2 (at 0x7801)"
      tindex ezaxi:0xfc4cf980 %l 0x8078010 0x78010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION3 (at 0x7802)"
      tindex ezaxi:0xfc4cf980 %l 0x8078020 0x78020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_REVISION4 (at 0x7803)"
      tindex ezaxi:0xfc4cf980 %l 0x8078030 0x78030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
      tindex ezaxi:0xfc4cf980 %l 0x8078040 0x78040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
      tindex ezaxi:0xfc4cf980 %l 0x8078050 0x78050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_STATUS0 (at 0x7808)"
      tindex ezaxi:0xfc4cf980 %l 0x8078080 0x78080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_STATUS1 (at 0x7809)"
      tindex ezaxi:0xfc4cf980 %l 0x8078090 0x78090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
      tindex ezaxi:0xfc4cf980 %l 0x8078100 0x78100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
      tindex ezaxi:0xfc4cf980 %l 0x8078110 0x78110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
      tindex ezaxi:0xfc4cf980 %l 0x8078120 0x78120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
      tindex ezaxi:0xfc4cf980 %l 0x8078130 0x78130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
      tindex ezaxi:0xfc4cf980 %l 0x8078140 0x78140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
      tindex ezaxi:0xfc4cf980 %l 0x8078150 0x78150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
      tindex ezaxi:0xfc4cf980 %l 0x8078160 0x78160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
      tindex ezaxi:0xfc4cf980 %l 0x8078180 0x78180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
      tindex ezaxi:0xfc4cf980 %l 0x8078190 0x78190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
      tindex ezaxi:0xfc4cf980 %l 0x80781a0 0x781a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
      tindex ezaxi:0xfc4cf980 %l 0x80781b0 0x781b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
      tindex ezaxi:0xfc4cf980 %l 0x8078400 0x78400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
      tindex ezaxi:0xfc4cf980 %l 0x8078420 0x78420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_EN_CTL (at 0x7846)"
      tindex ezaxi:0xfc4cf980 %l 0x8078460 0x78460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8078d00 0x78d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8078d80 0x78d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8078d90 0x78d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
      tindex ezaxi:0xfc4cf980 %l 0x8078da0 0x78da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
      tindex ezaxi:0xfc4cf980 %l 0x8078db0 0x78db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8078e00 0x78e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8078e10 0x78e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT8"
  tree "PBS_CLIENT8"
    tree "PBS_CLIENT8_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION1 (at 0x7900)"
      tindex ezaxi:0xfc4cf980 %l 0x8079000 0x79000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION2 (at 0x7901)"
      tindex ezaxi:0xfc4cf980 %l 0x8079010 0x79010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION3 (at 0x7902)"
      tindex ezaxi:0xfc4cf980 %l 0x8079020 0x79020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_REVISION4 (at 0x7903)"
      tindex ezaxi:0xfc4cf980 %l 0x8079030 0x79030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_TYPE (at 0x7904)"
      tindex ezaxi:0xfc4cf980 %l 0x8079040 0x79040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT8_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_SUBTYPE (at 0x7905)"
      tindex ezaxi:0xfc4cf980 %l 0x8079050 0x79050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT8_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_STATUS0 (at 0x7908)"
      tindex ezaxi:0xfc4cf980 %l 0x8079080 0x79080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_STATUS1 (at 0x7909)"
      tindex ezaxi:0xfc4cf980 %l 0x8079090 0x79090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT8_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_RT_STS (at 0x7910)"
      tindex ezaxi:0xfc4cf980 %l 0x8079100 0x79100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT8_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_SET_TYPE (at 0x7911)"
      tindex ezaxi:0xfc4cf980 %l 0x8079110 0x79110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_POLARITY_HIGH (at 0x7912)"
      tindex ezaxi:0xfc4cf980 %l 0x8079120 0x79120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_POLARITY_LOW (at 0x7913)"
      tindex ezaxi:0xfc4cf980 %l 0x8079130 0x79130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_LATCHED_CLR (at 0x7914)"
      tindex ezaxi:0xfc4cf980 %l 0x8079140 0x79140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_EN_SET (at 0x7915)"
      tindex ezaxi:0xfc4cf980 %l 0x8079150 0x79150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_EN_CLR (at 0x7916)"
      tindex ezaxi:0xfc4cf980 %l 0x8079160 0x79160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_LATCHED_STS (at 0x7918)"
      tindex ezaxi:0xfc4cf980 %l 0x8079180 0x79180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT8_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_PENDING_STS (at 0x7919)"
      tindex ezaxi:0xfc4cf980 %l 0x8079190 0x79190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT8_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_MID_SEL (at 0x791a)"
      tindex ezaxi:0xfc4cf980 %l 0x80791a0 0x791a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT8_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_PRIORITY (at 0x791b)"
      tindex ezaxi:0xfc4cf980 %l 0x80791b0 0x791b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_TRIG_CFG (at 0x7940)"
      tindex ezaxi:0xfc4cf980 %l 0x8079400 0x79400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT8_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_TRIG_CTL (at 0x7942)"
      tindex ezaxi:0xfc4cf980 %l 0x8079420 0x79420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_EN_CTL (at 0x7946)"
      tindex ezaxi:0xfc4cf980 %l 0x8079460 0x79460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_SEC_ACCESS (at 0x79d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8079d00 0x79d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL1 (at 0x79d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8079d80 0x79d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL2 (at 0x79d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8079d90 0x79d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL3 (at 0x79da)"
      tindex ezaxi:0xfc4cf980 %l 0x8079da0 0x79da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_PERPH_RESET_CTL4 (at 0x79db)"
      tindex ezaxi:0xfc4cf980 %l 0x8079db0 0x79db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_TEST1 (at 0x79e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8079e00 0x79e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT8_INT_TEST_VAL (at 0x79e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8079e10 0x79e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT9"
  tree "PBS_CLIENT9"
    tree "PBS_CLIENT9_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION1 (at 0x7a00)"
      tindex ezaxi:0xfc4cf980 %l 0x807a000 0x7a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION2 (at 0x7a01)"
      tindex ezaxi:0xfc4cf980 %l 0x807a010 0x7a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION3 (at 0x7a02)"
      tindex ezaxi:0xfc4cf980 %l 0x807a020 0x7a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_REVISION4 (at 0x7a03)"
      tindex ezaxi:0xfc4cf980 %l 0x807a030 0x7a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_TYPE (at 0x7a04)"
      tindex ezaxi:0xfc4cf980 %l 0x807a040 0x7a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT9_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_SUBTYPE (at 0x7a05)"
      tindex ezaxi:0xfc4cf980 %l 0x807a050 0x7a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT9_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_STATUS0 (at 0x7a08)"
      tindex ezaxi:0xfc4cf980 %l 0x807a080 0x7a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_STATUS1 (at 0x7a09)"
      tindex ezaxi:0xfc4cf980 %l 0x807a090 0x7a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT9_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_RT_STS (at 0x7a10)"
      tindex ezaxi:0xfc4cf980 %l 0x807a100 0x7a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT9_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_SET_TYPE (at 0x7a11)"
      tindex ezaxi:0xfc4cf980 %l 0x807a110 0x7a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_POLARITY_HIGH (at 0x7a12)"
      tindex ezaxi:0xfc4cf980 %l 0x807a120 0x7a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_POLARITY_LOW (at 0x7a13)"
      tindex ezaxi:0xfc4cf980 %l 0x807a130 0x7a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_LATCHED_CLR (at 0x7a14)"
      tindex ezaxi:0xfc4cf980 %l 0x807a140 0x7a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_EN_SET (at 0x7a15)"
      tindex ezaxi:0xfc4cf980 %l 0x807a150 0x7a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_EN_CLR (at 0x7a16)"
      tindex ezaxi:0xfc4cf980 %l 0x807a160 0x7a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_LATCHED_STS (at 0x7a18)"
      tindex ezaxi:0xfc4cf980 %l 0x807a180 0x7a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT9_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_PENDING_STS (at 0x7a19)"
      tindex ezaxi:0xfc4cf980 %l 0x807a190 0x7a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT9_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_MID_SEL (at 0x7a1a)"
      tindex ezaxi:0xfc4cf980 %l 0x807a1a0 0x7a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT9_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_PRIORITY (at 0x7a1b)"
      tindex ezaxi:0xfc4cf980 %l 0x807a1b0 0x7a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_TRIG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_TRIG_CFG (at 0x7a40)"
      tindex ezaxi:0xfc4cf980 %l 0x807a400 0x7a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT9_TRIG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_TRIG_CTL (at 0x7a42)"
      tindex ezaxi:0xfc4cf980 %l 0x807a420 0x7a420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_EN_CTL (at 0x7a46)"
      tindex ezaxi:0xfc4cf980 %l 0x807a460 0x7a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_SEC_ACCESS (at 0x7ad0)"
      tindex ezaxi:0xfc4cf980 %l 0x807ad00 0x7ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL1 (at 0x7ad8)"
      tindex ezaxi:0xfc4cf980 %l 0x807ad80 0x7ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL2 (at 0x7ad9)"
      tindex ezaxi:0xfc4cf980 %l 0x807ad90 0x7ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL3 (at 0x7ada)"
      tindex ezaxi:0xfc4cf980 %l 0x807ada0 0x7ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_PERPH_RESET_CTL4 (at 0x7adb)"
      tindex ezaxi:0xfc4cf980 %l 0x807adb0 0x7adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_TEST1 (at 0x7ae0)"
      tindex ezaxi:0xfc4cf980 %l 0x807ae00 0x7ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CLIENT9_INT_TEST_VAL (at 0x7ae1)"
      tindex ezaxi:0xfc4cf980 %l 0x807ae10 0x7ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION1 (at 0x7000)"
      tindex ezaxi:0xfc4cf980 %l 0x8070000 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION2 (at 0x7001)"
      tindex ezaxi:0xfc4cf980 %l 0x8070010 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION3 (at 0x7002)"
      tindex ezaxi:0xfc4cf980 %l 0x8070020 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_REVISION4 (at 0x7003)"
      tindex ezaxi:0xfc4cf980 %l 0x8070030 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_TYPE (at 0x7004)"
      tindex ezaxi:0xfc4cf980 %l 0x8070040 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
      tindex ezaxi:0xfc4cf980 %l 0x8070050 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
      tindex ezaxi:0xfc4cf980 %l 0x8070080 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
      tindex ezaxi:0xfc4cf980 %l 0x8070090 0x70090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
      tindex ezaxi:0xfc4cf980 %l 0x80700a0 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
      tindex ezaxi:0xfc4cf980 %l 0x80700b0 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
      tindex ezaxi:0xfc4cf980 %l 0x80700c0 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
      tindex ezaxi:0xfc4cf980 %l 0x80700d0 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
      tindex ezaxi:0xfc4cf980 %l 0x80700e0 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
      tindex ezaxi:0xfc4cf980 %l 0x80700f0 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
      tindex ezaxi:0xfc4cf980 %l 0x8070400 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
      tindex ezaxi:0xfc4cf980 %l 0x8070410 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
      tindex ezaxi:0xfc4cf980 %l 0x8070420 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
      tindex ezaxi:0xfc4cf980 %l 0x8070430 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
      tindex ezaxi:0xfc4cf980 %l 0x8070480 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
      tindex ezaxi:0xfc4cf980 %l 0x8070490 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
      tindex ezaxi:0xfc4cf980 %l 0x80704a0 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
      tindex ezaxi:0xfc4cf980 %l 0x80704b0 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
      tindex ezaxi:0xfc4cf980 %l 0x80704c0 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
      tindex ezaxi:0xfc4cf980 %l 0x80704d0 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
      tindex ezaxi:0xfc4cf980 %l 0x80704e0 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
      tindex ezaxi:0xfc4cf980 %l 0x80704f0 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
      tindex ezaxi:0xfc4cf980 %l 0x8070500 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
      tindex ezaxi:0xfc4cf980 %l 0x8070510 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
      tindex ezaxi:0xfc4cf980 %l 0x8070540 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
      tindex ezaxi:0xfc4cf980 %l 0x8070550 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
      tindex ezaxi:0xfc4cf980 %l 0x8070580 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
      tindex ezaxi:0xfc4cf980 %l 0x8070590 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
      tindex ezaxi:0xfc4cf980 %l 0x80705c0 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
      tindex ezaxi:0xfc4cf980 %l 0x80705d0 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
      tindex ezaxi:0xfc4cf980 %l 0x8070600 0x70600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
      tindex ezaxi:0xfc4cf980 %l 0x8070610 0x70610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
      tindex ezaxi:0xfc4cf980 %l 0x8070640 0x70640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
      tindex ezaxi:0xfc4cf980 %l 0x8070650 0x70650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
      tindex ezaxi:0xfc4cf980 %l 0x8070680 0x70680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
      tindex ezaxi:0xfc4cf980 %l 0x8070690 0x70690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
      tindex ezaxi:0xfc4cf980 %l 0x80706c0 0x706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
      tindex ezaxi:0xfc4cf980 %l 0x80706d0 0x706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
      tindex ezaxi:0xfc4cf980 %l 0x8070700 0x70700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
      tindex ezaxi:0xfc4cf980 %l 0x8070710 0x70710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
      tindex ezaxi:0xfc4cf980 %l 0x8070740 0x70740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
      tindex ezaxi:0xfc4cf980 %l 0x8070750 0x70750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
      tindex ezaxi:0xfc4cf980 %l 0x8070780 0x70780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
      tindex ezaxi:0xfc4cf980 %l 0x8070790 0x70790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
      tindex ezaxi:0xfc4cf980 %l 0x80707c0 0x707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
      tindex ezaxi:0xfc4cf980 %l 0x80707d0 0x707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
      tindex ezaxi:0xfc4cf980 %l 0x8070800 0x70800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
      tindex ezaxi:0xfc4cf980 %l 0x8070810 0x70810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
      tindex ezaxi:0xfc4cf980 %l 0x8070840 0x70840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
      tindex ezaxi:0xfc4cf980 %l 0x8070850 0x70850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
      tindex ezaxi:0xfc4cf980 %l 0x8070880 0x70880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
      tindex ezaxi:0xfc4cf980 %l 0x8070890 0x70890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
      tindex ezaxi:0xfc4cf980 %l 0x80708c0 0x708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
      tindex ezaxi:0xfc4cf980 %l 0x80708d0 0x708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
      tindex ezaxi:0xfc4cf980 %l 0x8070900 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
      tindex ezaxi:0xfc4cf980 %l 0x8070910 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
      tindex ezaxi:0xfc4cf980 %l 0x8070920 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
      tindex ezaxi:0xfc4cf980 %l 0x8070930 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
      tindex ezaxi:0xfc4cf980 %l 0x8070940 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
      tindex ezaxi:0xfc4cf980 %l 0x8070950 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
      tindex ezaxi:0xfc4cf980 %l 0x8070960 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
      tindex ezaxi:0xfc4cf980 %l 0x8070970 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEC_ACCESS (at 0x70d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8070d00 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8070d90 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
      tindex ezaxi:0xfc4cf980 %l 0x8070da0 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
      tindex ezaxi:0xfc4cf980 %l 0x8070db0 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8070e00 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8070e10 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_OTP_CFG1 (at 0x70e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8070e20 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_OTP_CFG2 (at 0x70e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8070e30 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PBS_CORE_TEST1 (at 0x70e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8070e40 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION1 (at 0x800)"
      tindex ezaxi:0xfc4cf980 %l 0x8008000 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION2 (at 0x801)"
      tindex ezaxi:0xfc4cf980 %l 0x8008010 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION3 (at 0x802)"
      tindex ezaxi:0xfc4cf980 %l 0x8008020 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_REVISION4 (at 0x803)"
      tindex ezaxi:0xfc4cf980 %l 0x8008030 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_TYPE (at 0x804)"
      tindex ezaxi:0xfc4cf980 %l 0x8008040 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_SUBTYPE (at 0x805)"
      tindex ezaxi:0xfc4cf980 %l 0x8008050 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_PBL_STATUS (at 0x807)"
      tindex ezaxi:0xfc4cf980 %l 0x8008070 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   POFF_FAULT_OCCURRED                      = " "0 (NO_FAULT),1 (FAULT_OCCURRED)"
    tree.end
    tree "PON_PON_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_REASON1 (at 0x808)"
      tindex ezaxi:0xfc4cf980 %l 0x8008080 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_WARM_RESET_REASON1 (at 0x80a)"
      tindex ezaxi:0xfc4cf980 %l 0x80080a0 0x80a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_WARM_RESET_REASON2 (at 0x80b)"
      tindex ezaxi:0xfc4cf980 %l 0x80080b0 0x80b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_POFF_REASON1 (at 0x80c)"
      tindex ezaxi:0xfc4cf980 %l 0x80080c0 0x80c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_POFF_REASON2 (at 0x80d)"
      tindex ezaxi:0xfc4cf980 %l 0x80080d0 0x80d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SOFT_RESET_REASON1 (at 0x80e)"
      tindex ezaxi:0xfc4cf980 %l 0x80080e0 0x80e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SOFT_RESET_REASON2 (at 0x80f)"
      tindex ezaxi:0xfc4cf980 %l 0x80080f0 0x80f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_RT_STS (at 0x810)"
      tindex ezaxi:0xfc4cf980 %l 0x8008100 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_SET_TYPE (at 0x811)"
      tindex ezaxi:0xfc4cf980 %l 0x8008110 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_POLARITY_HIGH (at 0x812)"
      tindex ezaxi:0xfc4cf980 %l 0x8008120 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_POLARITY_LOW (at 0x813)"
      tindex ezaxi:0xfc4cf980 %l 0x8008130 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_LATCHED_CLR (at 0x814)"
      tindex ezaxi:0xfc4cf980 %l 0x8008140 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_EN_SET (at 0x815)"
      tindex ezaxi:0xfc4cf980 %l 0x8008150 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_EN_CLR (at 0x816)"
      tindex ezaxi:0xfc4cf980 %l 0x8008160 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_LATCHED_STS (at 0x818)"
      tindex ezaxi:0xfc4cf980 %l 0x8008180 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_PENDING_STS (at 0x819)"
      tindex ezaxi:0xfc4cf980 %l 0x8008190 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_MID_SEL (at 0x81a)"
      tindex ezaxi:0xfc4cf980 %l 0x80081a0 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_PRIORITY (at 0x81b)"
      tindex ezaxi:0xfc4cf980 %l 0x80081b0 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
      tindex ezaxi:0xfc4cf980 %l 0x8008400 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
      tindex ezaxi:0xfc4cf980 %l 0x8008410 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
      tindex ezaxi:0xfc4cf980 %l 0x8008420 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
      tindex ezaxi:0xfc4cf980 %l 0x8008430 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
      tindex ezaxi:0xfc4cf980 %l 0x8008440 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
      tindex ezaxi:0xfc4cf980 %l 0x8008450 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
      tindex ezaxi:0xfc4cf980 %l 0x8008460 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
      tindex ezaxi:0xfc4cf980 %l 0x8008470 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
      tindex ezaxi:0xfc4cf980 %l 0x8008480 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
      tindex ezaxi:0xfc4cf980 %l 0x8008490 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
      tindex ezaxi:0xfc4cf980 %l 0x80084a0 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
      tindex ezaxi:0xfc4cf980 %l 0x80084b0 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S1_TIMER (at 0x84c)"
      tindex ezaxi:0xfc4cf980 %l 0x80084c0 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S2_TIMER (at 0x84d)"
      tindex ezaxi:0xfc4cf980 %l 0x80084d0 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S2_CTL (at 0x84e)"
      tindex ezaxi:0xfc4cf980 %l 0x80084e0 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
      tindex ezaxi:0xfc4cf980 %l 0x80084f0 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S1_TIMER (at 0x850)"
      tindex ezaxi:0xfc4cf980 %l 0x8008500 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S2_TIMER (at 0x851)"
      tindex ezaxi:0xfc4cf980 %l 0x8008510 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S2_CTL (at 0x852)"
      tindex ezaxi:0xfc4cf980 %l 0x8008520 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_GP1_RESET_S2_CTL2 (at 0x853)"
      tindex ezaxi:0xfc4cf980 %l 0x8008530 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
      tindex ezaxi:0xfc4cf980 %l 0x8008540 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
      tindex ezaxi:0xfc4cf980 %l 0x8008550 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
      tindex ezaxi:0xfc4cf980 %l 0x8008560 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
      tindex ezaxi:0xfc4cf980 %l 0x8008570 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PMIC_WD_RESET_PET (at 0x858)"
      tindex ezaxi:0xfc4cf980 %l 0x8008580 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PS_HOLD_RESET_CTL (at 0x85a)"
      tindex ezaxi:0xfc4cf980 %l 0x80085a0 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
      tindex ezaxi:0xfc4cf980 %l 0x80085b0 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SW_RESET_S2_CTL (at 0x862)"
      tindex ezaxi:0xfc4cf980 %l 0x8008620 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SW_RESET_S2_CTL2 (at 0x863)"
      tindex ezaxi:0xfc4cf980 %l 0x8008630 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SW_RESET_GO (at 0x864)"
      tindex ezaxi:0xfc4cf980 %l 0x8008640 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_OVERTEMP_RESET_CTL (at 0x866)"
      tindex ezaxi:0xfc4cf980 %l 0x8008660 0x8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
      tindex ezaxi:0xfc4cf980 %l 0x8008670 0x8670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESERVED_FAULT_RESET_CTL (at 0x868)"
      tindex ezaxi:0xfc4cf980 %l 0x8008680 0x8680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESERVED_FAULT_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESERVED_FAULT_RESET_CTL2 (at 0x869)"
      tindex ezaxi:0xfc4cf980 %l 0x8008690 0x8690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TFT_RESET_CTL (at 0x86a)"
      tindex ezaxi:0xfc4cf980 %l 0x80086a0 0x86a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TFT_RESET_CTL2 (at 0x86b)"
      tindex ezaxi:0xfc4cf980 %l 0x80086b0 0x86b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PULL_CTL (at 0x870)"
      tindex ezaxi:0xfc4cf980 %l 0x8008700 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DEBOUNCE_CTL (at 0x871)"
      tindex ezaxi:0xfc4cf980 %l 0x8008710 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_DEBOUNCE                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESET_S3_SRC (at 0x874)"
      tindex ezaxi:0xfc4cf980 %l 0x8008740 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_RESET_S3_TIMER (at 0x875)"
      tindex ezaxi:0xfc4cf980 %l 0x8008750 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_TRIGGER_EN (at 0x880)"
      tindex ezaxi:0xfc4cf980 %l 0x8008800 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_OPTION_BITS (at 0x882)"
      tindex ezaxi:0xfc4cf980 %l 0x8008820 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_DEBOUNCE_DLY                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_WATCHDOG_LOCK (at 0x883)"
      tindex ezaxi:0xfc4cf980 %l 0x8008830 0x8830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_UVLO (at 0x888)"
      tindex ezaxi:0xfc4cf980 %l 0x8008880 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   WIPWR_UVLO_DLY                           = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_AVDD_VPH (at 0x88a)"
      tindex ezaxi:0xfc4cf980 %l 0x80088a0 0x88a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   AVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_DVDD_VPH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DVDD_VPH (at 0x88b)"
      tindex ezaxi:0xfc4cf980 %l 0x80088b0 0x88b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   XVDD_DVDD_SRC_CTRL                       = " "0 (DVDD_SRC_FROM_LDO),1 (DVDD_SRC_FROM_SMPS),2 (DVDD_SRC_FROM_PON_DVDDREG),3 (DVDD_SRC_FROM_PON_DVDDREG1)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RB_SPARE (at 0x88c)"
      tindex ezaxi:0xfc4cf980 %l 0x80088c0 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DVDD_RB_SPARE (at 0x88d)"
      tindex ezaxi:0xfc4cf980 %l 0x80088d0 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_XVDD_RB_SPARE (at 0x88e)"
      tindex ezaxi:0xfc4cf980 %l 0x80088e0 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SOFT_RB_SPARE (at 0x88f)"
      tindex ezaxi:0xfc4cf980 %l 0x80088f0 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON1_INTERFACE (at 0x890)"
      tindex ezaxi:0xfc4cf980 %l 0x8008900 0x8900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PBS_INTERFACE (at 0x891)"
      tindex ezaxi:0xfc4cf980 %l 0x8008910 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_DEBUG_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DEBUG_CTL (at 0x894)"
      tindex ezaxi:0xfc4cf980 %l 0x8008940 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEBUG_CLOCK                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEBUG_CLOCK_SRC                          = " "0 (RESIN_N),1 (CLK_50K)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_DEBUG                                = "
    tree.end
    tree "PON_DEBUG_STATUS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_DEBUG_STATUS (at 0x895)"
      tindex ezaxi:0xfc4cf980 %l 0x8008950 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEBUG_STATE                              = "
    tree.end
    tree "PON_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_SEC_ACCESS (at 0x8d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8008d00 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RESET_CTL2 (at 0x8d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8008d90 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RESET_CTL3 (at 0x8da)"
      tindex ezaxi:0xfc4cf980 %l 0x8008da0 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PERPH_RESET_CTL4 (at 0x8db)"
      tindex ezaxi:0xfc4cf980 %l 0x8008db0 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_TEST1 (at 0x8e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e00 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_INT_TEST_VAL (at 0x8e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e10 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST1 (at 0x8e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e20 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST2 (at 0x8e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e30 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST2_DVDD_INT                          = " "0, 1"
    tree.end
    tree "PON_TEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST3 (at 0x8e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e40 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST4 (at 0x8e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e50 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_ATEST1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_TEST5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TEST5 (at 0x8e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e60 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_VMAX_SEL (at 0x8e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8008e70 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_TRIM_NUM (at 0x8f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8008f00 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_TRIM (at 0x8f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8008f10 0x8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_CNTL_2_TRIM (at 0x8f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8008f20 0x8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_3_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_CNTL_3_TRIM (at 0x8f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8008f30 0x8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_4_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PON_PON_CNTL_4_TRIM (at 0x8f4)"
      tindex ezaxi:0xfc4cf980 %l 0x8008f40 0x8f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RZ_HPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   RZ_LPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "PWM_3D"
  tree "PWM_3D"
    tree "PWM_3D_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_REVISION1 (at 0x1bc00)"
      tindex ezaxi:0xfc4cf980 %l 0x81bc000 0x1bc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PWM_3D_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_REVISION2 (at 0x1bc01)"
      tindex ezaxi:0xfc4cf980 %l 0x81bc010 0x1bc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PWM_3D_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_PERPH_TYPE (at 0x1bc04)"
      tindex ezaxi:0xfc4cf980 %l 0x81bc040 0x1bc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PWM_3D_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_PERPH_SUBTYPE (at 0x1bc05)"
      tindex ezaxi:0xfc4cf980 %l 0x81bc050 0x1bc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PWM_3D_PWM_SOURCE_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_PWM_SOURCE_SEL (at 0x1bc45)"
      tindex ezaxi:0xfc4cf980 %l 0x81bc450 0x1bc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_SOURCE                               = " "0 (PWM_SRC_LPG0),1 (PWM_SRC_LPG1),2 (PWM_SRC_LPG2),3 (PWM_SRC_LPG3),4 (PWM_SRC_LPG4),5 (PWM_SRC_LPG5),6 (PWM_SRC_LPG6),7 (PWM_SRC_LPG7)"
    tree.end
    tree "PWM_3D_ENABLE_CONTROL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_ENABLE_CONTROL (at 0x1bc46)"
      tindex ezaxi:0xfc4cf980 %l 0x81bc460 0x1bc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_3D_PWM                                = " "0 (PWM_3D_DIS),1 (PWM_3D_EN)"
    tree.end
    tree "PWM_3D_PHASE_SELECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_PHASE_SELECT (at 0x1bc47)"
      tindex ezaxi:0xfc4cf980 %l 0x81bc470 0x1bc470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_SEL                                = "
    tree.end
    tree "PWM_3D_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_SEC_ACCESS (at 0x1bcd0)"
      tindex ezaxi:0xfc4cf980 %l 0x81bcd00 0x1bcd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PWM_3D_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_PERPH_RESET_CTL2 (at 0x1bcd9)"
      tindex ezaxi:0xfc4cf980 %l 0x81bcd90 0x1bcd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_3D_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_PERPH_RESET_CTL3 (at 0x1bcda)"
      tindex ezaxi:0xfc4cf980 %l 0x81bcda0 0x1bcda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_3D_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "PWM_3D_PERPH_RESET_CTL4 (at 0x1bcdb)"
      tindex ezaxi:0xfc4cf980 %l 0x81bcdb0 0x1bcdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION1 (at 0x100)"
      tindex ezaxi:0xfc4cf980 %l 0x8001000 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION2 (at 0x101)"
      tindex ezaxi:0xfc4cf980 %l 0x8001010 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION3 (at 0x102)"
      tindex ezaxi:0xfc4cf980 %l 0x8001020 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_REVISION4 (at 0x103)"
      tindex ezaxi:0xfc4cf980 %l 0x8001030 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_PERPH_TYPE (at 0x104)"
      tindex ezaxi:0xfc4cf980 %l 0x8001040 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_PERPH_SUBTYPE (at 0x105)"
      tindex ezaxi:0xfc4cf980 %l 0x8001050 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_STATUS1 (at 0x108)"
      tindex ezaxi:0xfc4cf980 %l 0x8001080 0x1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OP4                                      = " "0 (OP4_GND),1 (reserved),2 (OP4_HIZ),3 (OP4_VDD)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OP3                                      = " "0 (OP3_GND),1 (reserved),2 (OP3_HIZ),3 (OP3_VDD)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OP2                                      = " "0 (OP2_GND),1 (reserved),2 (OP2_HIZ),3 (OP2_VDD)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OP1                                      = " "0 (OP1_GND),1 (reserved),2 (OP1_HIZ),3 (OP1_VDD)"
    tree.end
    tree "REVID_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_SEC_ACCESS (at 0x1d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8001d00 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "REVID_TEST1 (at 0x1e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8001e00 0x1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0 (FORCE_ON_DISABLED),1 (FORCE_ON_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (DTEST_DISABLED),1 (DTEST_OPT1),2 (DTEST_OPT2),3 (DTEST_OPT3),4 (DTEST_OPT4),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "RF_CLK1"
  tree "RF_CLK1"
    tree "RF_CLK1_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_REVISION1 (at 0x5400)"
      tindex ezaxi:0xfc4cf980 %l 0x8054000 0x54000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_REVISION2 (at 0x5401)"
      tindex ezaxi:0xfc4cf980 %l 0x8054010 0x54010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK1_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_REVISION3 (at 0x5402)"
      tindex ezaxi:0xfc4cf980 %l 0x8054020 0x54020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_REVISION4 (at 0x5403)"
      tindex ezaxi:0xfc4cf980 %l 0x8054030 0x54030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK1_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_PERPH_TYPE (at 0x5404)"
      tindex ezaxi:0xfc4cf980 %l 0x8054040 0x54040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK1_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_PERPH_SUBTYPE (at 0x5405)"
      tindex ezaxi:0xfc4cf980 %l 0x8054050 0x54050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK1_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_STATUS1 (at 0x5408)"
      tindex ezaxi:0xfc4cf980 %l 0x8054080 0x54080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK1_EDGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_EDGE_CTL1 (at 0x5443)"
      tindex ezaxi:0xfc4cf980 %l 0x8054430 0x54430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK1_DRV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_DRV_CTL1 (at 0x5444)"
      tindex ezaxi:0xfc4cf980 %l 0x8054440 0x54440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK1_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_EN_CTL (at 0x5446)"
      tindex ezaxi:0xfc4cf980 %l 0x8054460 0x54460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK1_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_PD_CTL (at 0x5448)"
      tindex ezaxi:0xfc4cf980 %l 0x8054480 0x54480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK1_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_SEC_ACCESS (at 0x54d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8054d00 0x54d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_PERPH_RESET_CTL1 (at 0x54d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8054d80 0x54d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_PERPH_RESET_CTL2 (at 0x54d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8054d90 0x54d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_PERPH_RESET_CTL3 (at 0x54da)"
      tindex ezaxi:0xfc4cf980 %l 0x8054da0 0x54da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK1_PERPH_RESET_CTL4 (at 0x54db)"
      tindex ezaxi:0xfc4cf980 %l 0x8054db0 0x54db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK2"
  tree "RF_CLK2"
    tree "RF_CLK2_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_REVISION1 (at 0x5500)"
      tindex ezaxi:0xfc4cf980 %l 0x8055000 0x55000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_REVISION2 (at 0x5501)"
      tindex ezaxi:0xfc4cf980 %l 0x8055010 0x55010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK2_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_REVISION3 (at 0x5502)"
      tindex ezaxi:0xfc4cf980 %l 0x8055020 0x55020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_REVISION4 (at 0x5503)"
      tindex ezaxi:0xfc4cf980 %l 0x8055030 0x55030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK2_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_PERPH_TYPE (at 0x5504)"
      tindex ezaxi:0xfc4cf980 %l 0x8055040 0x55040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK2_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_PERPH_SUBTYPE (at 0x5505)"
      tindex ezaxi:0xfc4cf980 %l 0x8055050 0x55050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK2_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_STATUS1 (at 0x5508)"
      tindex ezaxi:0xfc4cf980 %l 0x8055080 0x55080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK2_EDGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_EDGE_CTL1 (at 0x5543)"
      tindex ezaxi:0xfc4cf980 %l 0x8055430 0x55430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUT_EDGE                                 = "
    tree.end
    tree "RF_CLK2_DRV_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_DRV_CTL1 (at 0x5544)"
      tindex ezaxi:0xfc4cf980 %l 0x8055440 0x55440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK2_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_EN_CTL (at 0x5546)"
      tindex ezaxi:0xfc4cf980 %l 0x8055460 0x55460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK2_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_PD_CTL (at 0x5548)"
      tindex ezaxi:0xfc4cf980 %l 0x8055480 0x55480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK2_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_SEC_ACCESS (at 0x55d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8055d00 0x55d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_PERPH_RESET_CTL1 (at 0x55d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8055d80 0x55d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_PERPH_RESET_CTL2 (at 0x55d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8055d90 0x55d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_PERPH_RESET_CTL3 (at 0x55da)"
      tindex ezaxi:0xfc4cf980 %l 0x8055da0 0x55da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RF_CLK2_PERPH_RESET_CTL4 (at 0x55db)"
      tindex ezaxi:0xfc4cf980 %l 0x8055db0 0x55db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RTC_ALARM"
  tree "RTC_ALARM"
    tree "RTC_ALARM_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_REVISION1 (at 0x6100)"
      tindex ezaxi:0xfc4cf980 %l 0x8061000 0x61000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_ALARM_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_REVISION2 (at 0x6101)"
      tindex ezaxi:0xfc4cf980 %l 0x8061010 0x61010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_ALARM_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_PERPH_TYPE (at 0x6104)"
      tindex ezaxi:0xfc4cf980 %l 0x8061040 0x61040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_ALARM_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_PERPH_SUBTYPE (at 0x6105)"
      tindex ezaxi:0xfc4cf980 %l 0x8061050 0x61050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_ALARM_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_STATUS1 (at 0x6108)"
      tindex ezaxi:0xfc4cf980 %l 0x8061080 0x61080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_ALARM_OK                             = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
    tree.end
    tree "RTC_ALARM_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_RT_STS (at 0x6110)"
      tindex ezaxi:0xfc4cf980 %l 0x8061100 0x61100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (RTC_ALARM_NOT_EXPIRED),1 (RTC_ALARM_EXPIRED)"
    tree.end
    tree "RTC_ALARM_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_SET_TYPE (at 0x6111)"
      tindex ezaxi:0xfc4cf980 %l 0x8061110 0x61110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_POLARITY_HIGH (at 0x6112)"
      tindex ezaxi:0xfc4cf980 %l 0x8061120 0x61120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_POLARITY_LOW (at 0x6113)"
      tindex ezaxi:0xfc4cf980 %l 0x8061130 0x61130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_LATCHED_CLR (at 0x6114)"
      tindex ezaxi:0xfc4cf980 %l 0x8061140 0x61140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_EN_SET (at 0x6115)"
      tindex ezaxi:0xfc4cf980 %l 0x8061150 0x61150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_EN_CLR (at 0x6116)"
      tindex ezaxi:0xfc4cf980 %l 0x8061160 0x61160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_LATCHED_STS (at 0x6118)"
      tindex ezaxi:0xfc4cf980 %l 0x8061180 0x61180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_ALARM_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_PENDING_STS (at 0x6119)"
      tindex ezaxi:0xfc4cf980 %l 0x8061190 0x61190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_ALARM_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_MID_SEL (at 0x611a)"
      tindex ezaxi:0xfc4cf980 %l 0x80611a0 0x611a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_ALARM_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_PRIORITY (at 0x611b)"
      tindex ezaxi:0xfc4cf980 %l 0x80611b0 0x611b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_ALARM_ALARM_DATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_ALARM_DATA0 (at 0x6140)"
      tindex ezaxi:0xfc4cf980 %l 0x8061400 0x61400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA0                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_ALARM_DATA1 (at 0x6141)"
      tindex ezaxi:0xfc4cf980 %l 0x8061410 0x61410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA1                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_ALARM_DATA2 (at 0x6142)"
      tindex ezaxi:0xfc4cf980 %l 0x8061420 0x61420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA2                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_ALARM_DATA3 (at 0x6143)"
      tindex ezaxi:0xfc4cf980 %l 0x8061430 0x61430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA3                          = "
    tree.end
    tree "RTC_ALARM_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_EN_CTL1 (at 0x6146)"
      tindex ezaxi:0xfc4cf980 %l 0x8061460 0x61460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ALARM_EN                                 = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABORT_EN                                 = " "0 (RTC_STARTUP_DOESNT_ABORT),1 (RTC_STARTUP_ABORT_EN)"
    tree.end
    tree "RTC_ALARM_ALARM_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_ALARM_CLR (at 0x6148)"
      tindex ezaxi:0xfc4cf980 %l 0x8061480 0x61480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALARM_CLR                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_SEC_ACCESS (at 0x61d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8061d00 0x61d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_PERPH_RESET_CTL1 (at 0x61d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8061d80 0x61d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_PERPH_RESET_CTL2 (at 0x61d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8061d90 0x61d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_PERPH_RESET_CTL3 (at 0x61da)"
      tindex ezaxi:0xfc4cf980 %l 0x8061da0 0x61da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_PERPH_RESET_CTL4 (at 0x61db)"
      tindex ezaxi:0xfc4cf980 %l 0x8061db0 0x61db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_TEST1 (at 0x61e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8061e00 0x61e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_ALARM_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_ALARM_INT_TEST_VAL (at 0x61e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8061e10 0x61e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM_TEST_VAL                       = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_TIMER"
  tree "RTC_TIMER"
    tree "RTC_TIMER_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_REVISION1 (at 0x6200)"
      tindex ezaxi:0xfc4cf980 %l 0x8062000 0x62000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_TIMER_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_REVISION2 (at 0x6201)"
      tindex ezaxi:0xfc4cf980 %l 0x8062010 0x62010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_TIMER_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_PERPH_TYPE (at 0x6204)"
      tindex ezaxi:0xfc4cf980 %l 0x8062040 0x62040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_TIMER_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_PERPH_SUBTYPE (at 0x6205)"
      tindex ezaxi:0xfc4cf980 %l 0x8062050 0x62050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_TIMER_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_STATUS1 (at 0x6208)"
      tindex ezaxi:0xfc4cf980 %l 0x8062080 0x62080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_OK                                 = " "0 (TIMER_OFF),1 (TIMER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_RT_STS (at 0x6210)"
      tindex ezaxi:0xfc4cf980 %l 0x8062100 0x62100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_SET_TYPE (at 0x6211)"
      tindex ezaxi:0xfc4cf980 %l 0x8062110 0x62110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_POLARITY_HIGH (at 0x6212)"
      tindex ezaxi:0xfc4cf980 %l 0x8062120 0x62120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_POLARITY_LOW (at 0x6213)"
      tindex ezaxi:0xfc4cf980 %l 0x8062130 0x62130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_LATCHED_CLR (at 0x6214)"
      tindex ezaxi:0xfc4cf980 %l 0x8062140 0x62140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_EN_SET (at 0x6215)"
      tindex ezaxi:0xfc4cf980 %l 0x8062150 0x62150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_EN_CLR (at 0x6216)"
      tindex ezaxi:0xfc4cf980 %l 0x8062160 0x62160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_LATCHED_STS (at 0x6218)"
      tindex ezaxi:0xfc4cf980 %l 0x8062180 0x62180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_TIMER_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_PENDING_STS (at 0x6219)"
      tindex ezaxi:0xfc4cf980 %l 0x8062190 0x62190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_TIMER_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_MID_SEL (at 0x621a)"
      tindex ezaxi:0xfc4cf980 %l 0x80621a0 0x621a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_TIMER_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_PRIORITY (at 0x621b)"
      tindex ezaxi:0xfc4cf980 %l 0x80621b0 0x621b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_TIMER_TIMER_DATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_TIMER_DATA1 (at 0x6240)"
      tindex ezaxi:0xfc4cf980 %l 0x8062400 0x62400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA1                              = "
    tree.end
    tree "RTC_TIMER_TIMER_DATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_TIMER_DATA2 (at 0x6242)"
      tindex ezaxi:0xfc4cf980 %l 0x8062420 0x62420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA2                              = "
    tree.end
    tree "RTC_TIMER_TIMER_MODE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_TIMER_MODE (at 0x6245)"
      tindex ezaxi:0xfc4cf980 %l 0x8062450 0x62450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONTINUOUS                               = " "0 (TIMER_STOPS),1 (TIMER_RESTARTS)"
    tree.end
    tree "RTC_TIMER_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_EN_CTL (at 0x6246)"
      tindex ezaxi:0xfc4cf980 %l 0x8062460 0x62460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_EN                                 = " "0 (TIMER_DIS),1 (TIMER_EN)"
    tree.end
    tree "RTC_TIMER_TIMER_RDATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_TIMER_RDATA1 (at 0x6248)"
      tindex ezaxi:0xfc4cf980 %l 0x8062480 0x62480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA1                             = "
    tree.end
    tree "RTC_TIMER_TIMER_RDATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_TIMER_RDATA2 (at 0x6249)"
      tindex ezaxi:0xfc4cf980 %l 0x8062490 0x62490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA2                             = "
    tree.end
    tree "RTC_TIMER_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_SEC_ACCESS (at 0x62d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8062d00 0x62d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_PERPH_RESET_CTL1 (at 0x62d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8062d80 0x62d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_PERPH_RESET_CTL2 (at 0x62d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8062d90 0x62d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_PERPH_RESET_CTL3 (at 0x62da)"
      tindex ezaxi:0xfc4cf980 %l 0x8062da0 0x62da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_PERPH_RESET_CTL4 (at 0x62db)"
      tindex ezaxi:0xfc4cf980 %l 0x8062db0 0x62db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_TEST1 (at 0x62e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8062e00 0x62e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_TIMER_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_TIMER_INT_TEST_VAL (at 0x62e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8062e10 0x62e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED_TEST_VAL                   = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_WR"
  tree "RTC_WR"
    tree "RTC_WR_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_REVISION1 (at 0x6000)"
      tindex ezaxi:0xfc4cf980 %l 0x8060000 0x60000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_WR_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_REVISION2 (at 0x6001)"
      tindex ezaxi:0xfc4cf980 %l 0x8060010 0x60010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_WR_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_PERPH_TYPE (at 0x6004)"
      tindex ezaxi:0xfc4cf980 %l 0x8060040 0x60040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_WR_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_PERPH_SUBTYPE (at 0x6005)"
      tindex ezaxi:0xfc4cf980 %l 0x8060050 0x60050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_WR_STATUS1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_STATUS1 (at 0x6008)"
      tindex ezaxi:0xfc4cf980 %l 0x8060080 0x60080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_OK                                   = " "0 (RTC_OFF),1 (RTC_ON)"
    tree.end
    tree "RTC_WR_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_RT_STS (at 0x6010)"
      tindex ezaxi:0xfc4cf980 %l 0x8060100 0x60100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (RTC_1SEC_NOT_EXPIRED),1 (RTC_1SEC_EXPIRED)"
    tree.end
    tree "RTC_WR_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_SET_TYPE (at 0x6011)"
      tindex ezaxi:0xfc4cf980 %l 0x8060110 0x60110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_WR_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_POLARITY_HIGH (at 0x6012)"
      tindex ezaxi:0xfc4cf980 %l 0x8060120 0x60120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_WR_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_POLARITY_LOW (at 0x6013)"
      tindex ezaxi:0xfc4cf980 %l 0x8060130 0x60130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_WR_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_LATCHED_CLR (at 0x6014)"
      tindex ezaxi:0xfc4cf980 %l 0x8060140 0x60140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_WR_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_EN_SET (at 0x6015)"
      tindex ezaxi:0xfc4cf980 %l 0x8060150 0x60150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_WR_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_EN_CLR (at 0x6016)"
      tindex ezaxi:0xfc4cf980 %l 0x8060160 0x60160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_WR_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_LATCHED_STS (at 0x6018)"
      tindex ezaxi:0xfc4cf980 %l 0x8060180 0x60180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_WR_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_PENDING_STS (at 0x6019)"
      tindex ezaxi:0xfc4cf980 %l 0x8060190 0x60190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_WR_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_MID_SEL (at 0x601a)"
      tindex ezaxi:0xfc4cf980 %l 0x80601a0 0x601a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_WR_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_PRIORITY (at 0x601b)"
      tindex ezaxi:0xfc4cf980 %l 0x80601b0 0x601b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_WR_WDATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_WDATA0 (at 0x6040)"
      tindex ezaxi:0xfc4cf980 %l 0x8060400 0x60400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA0                               = "
    tree.end
    tree "RTC_WR_WDATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_WDATA1 (at 0x6041)"
      tindex ezaxi:0xfc4cf980 %l 0x8060410 0x60410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA1                               = "
    tree.end
    tree "RTC_WR_WDATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_WDATA2 (at 0x6042)"
      tindex ezaxi:0xfc4cf980 %l 0x8060420 0x60420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA2                               = "
    tree.end
    tree "RTC_WR_WDATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_WDATA3 (at 0x6043)"
      tindex ezaxi:0xfc4cf980 %l 0x8060430 0x60430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA3                               = "
    tree.end
    tree "RTC_WR_TIME_ADJ"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_TIME_ADJ (at 0x6044)"
      tindex ezaxi:0xfc4cf980 %l 0x8060440 0x60440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RTC_TIME_ADJ                             = "
    tree.end
    tree "RTC_WR_EN_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_EN_CTL1 (at 0x6046)"
      tindex ezaxi:0xfc4cf980 %l 0x8060460 0x60460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_EN                                   = " "0 (RTC_COUNTER_DIS),1 (RTC_COUNTER_EN)"
    tree.end
    tree "RTC_WR_RDATA0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_RDATA0 (at 0x6048)"
      tindex ezaxi:0xfc4cf980 %l 0x8060480 0x60480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA0                               = "
    tree.end
    tree "RTC_WR_RDATA1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_RDATA1 (at 0x6049)"
      tindex ezaxi:0xfc4cf980 %l 0x8060490 0x60490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA1                               = "
    tree.end
    tree "RTC_WR_RDATA2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_RDATA2 (at 0x604a)"
      tindex ezaxi:0xfc4cf980 %l 0x80604a0 0x604a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA2                               = "
    tree.end
    tree "RTC_WR_RDATA3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_RDATA3 (at 0x604b)"
      tindex ezaxi:0xfc4cf980 %l 0x80604b0 0x604b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA3                               = "
    tree.end
    tree "RTC_WR_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_SEC_ACCESS (at 0x60d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8060d00 0x60d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_PERPH_RESET_CTL1 (at 0x60d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8060d80 0x60d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_PERPH_RESET_CTL2 (at 0x60d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8060d90 0x60d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_PERPH_RESET_CTL3 (at 0x60da)"
      tindex ezaxi:0xfc4cf980 %l 0x8060da0 0x60da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_PERPH_RESET_CTL4 (at 0x60db)"
      tindex ezaxi:0xfc4cf980 %l 0x8060db0 0x60db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_WR_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_TEST1 (at 0x60e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8060e00 0x60e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_WR_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_INT_TEST_VAL (at 0x60e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8060e10 0x60e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ_TEST_VAL                         = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "RTC_WR_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "RTC_WR_TEST1 (at 0x60e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8060e20 0x60e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST1                                   = " "0 (NORMAL),1 (RTC_1HZ_ON_DTEST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIV20CLKSEL                              = " "0 (NORMAL),1 (ALT_SLP_ON_DIV20)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIVSEL                                   = " "0 (DIV16384),1 (DIV20)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASSDIV2                               = " "0 (DIV2),1 (BYPASS_DIV2)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (NONE),1 (CLK_1HZ),2 (CLK_1HZ_LATCH),3 (LOAD),4 (ABORT_ALARM),5 (ALARM_INT),6 (RTC_ALARM),7 (ALARM_RST_N)"
    tree.end
  tree.end
tree.end
tree "S10_CTRL"
  tree "S10_CTRL"
    tree "S10_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_REVISION1 (at 0x12f00)"
      tindex ezaxi:0xfc4cf980 %l 0x812f000 0x12f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S10_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_REVISION2 (at 0x12f01)"
      tindex ezaxi:0xfc4cf980 %l 0x812f010 0x12f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S10_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_REVISION3 (at 0x12f02)"
      tindex ezaxi:0xfc4cf980 %l 0x812f020 0x12f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S10_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_REVISION4 (at 0x12f03)"
      tindex ezaxi:0xfc4cf980 %l 0x812f030 0x12f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S10_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PERPH_TYPE (at 0x12f04)"
      tindex ezaxi:0xfc4cf980 %l 0x812f040 0x12f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S10_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PERPH_SUBTYPE (at 0x12f05)"
      tindex ezaxi:0xfc4cf980 %l 0x812f050 0x12f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S10_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_STATUS_1 (at 0x12f08)"
      tindex ezaxi:0xfc4cf980 %l 0x812f080 0x12f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S10_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_STATUS_2 (at 0x12f09)"
      tindex ezaxi:0xfc4cf980 %l 0x812f090 0x12f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S10_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_STATUS_3 (at 0x12f0a)"
      tindex ezaxi:0xfc4cf980 %l 0x812f0a0 0x12f0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S10_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_STATUS_4 (at 0x12f0b)"
      tindex ezaxi:0xfc4cf980 %l 0x812f0b0 0x12f0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S10_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_STATUS_5 (at 0x12f0c)"
      tindex ezaxi:0xfc4cf980 %l 0x812f0c0 0x12f0c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S10_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_RT_STS (at 0x12f10)"
      tindex ezaxi:0xfc4cf980 %l 0x812f100 0x12f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S10_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_SET_TYPE (at 0x12f11)"
      tindex ezaxi:0xfc4cf980 %l 0x812f110 0x12f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S10_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_POLARITY_HIGH (at 0x12f12)"
      tindex ezaxi:0xfc4cf980 %l 0x812f120 0x12f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S10_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_POLARITY_LOW (at 0x12f13)"
      tindex ezaxi:0xfc4cf980 %l 0x812f130 0x12f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S10_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_LATCHED_CLR (at 0x12f14)"
      tindex ezaxi:0xfc4cf980 %l 0x812f140 0x12f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S10_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_EN_SET (at 0x12f15)"
      tindex ezaxi:0xfc4cf980 %l 0x812f150 0x12f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S10_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_EN_CLR (at 0x12f16)"
      tindex ezaxi:0xfc4cf980 %l 0x812f160 0x12f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S10_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_LATCHED_STS (at 0x12f18)"
      tindex ezaxi:0xfc4cf980 %l 0x812f180 0x12f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S10_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_PENDING_STS (at 0x12f19)"
      tindex ezaxi:0xfc4cf980 %l 0x812f190 0x12f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S10_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_MID_SEL (at 0x12f1a)"
      tindex ezaxi:0xfc4cf980 %l 0x812f1a0 0x12f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S10_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_PRIORITY (at 0x12f1b)"
      tindex ezaxi:0xfc4cf980 %l 0x812f1b0 0x12f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S10_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VOLTAGE_CTL1 (at 0x12f40)"
      tindex ezaxi:0xfc4cf980 %l 0x812f400 0x12f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S10_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VOLTAGE_CTL2 (at 0x12f41)"
      tindex ezaxi:0xfc4cf980 %l 0x812f410 0x12f410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S10_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VSET_VALID (at 0x12f42)"
      tindex ezaxi:0xfc4cf980 %l 0x812f420 0x12f420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S10_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MPPFM_VOFFSET (at 0x12f44)"
      tindex ezaxi:0xfc4cf980 %l 0x812f440 0x12f440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S10_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MODE_CTL (at 0x12f45)"
      tindex ezaxi:0xfc4cf980 %l 0x812f450 0x12f450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S10_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_EN_CTL (at 0x12f46)"
      tindex ezaxi:0xfc4cf980 %l 0x812f460 0x12f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S10_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PD_CTL (at 0x12f48)"
      tindex ezaxi:0xfc4cf980 %l 0x812f480 0x12f480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S10_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_FREQ_CTL (at 0x12f50)"
      tindex ezaxi:0xfc4cf980 %l 0x812f500 0x12f500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S10_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MULTIPHASE_CTL (at 0x12f51)"
      tindex ezaxi:0xfc4cf980 %l 0x812f510 0x12f510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S10_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PHASE_CTL (at 0x12f52)"
      tindex ezaxi:0xfc4cf980 %l 0x812f520 0x12f520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S10_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PHASE_ID (at 0x12f53)"
      tindex ezaxi:0xfc4cf980 %l 0x812f530 0x12f530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S10_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PHASE_CNT_MAX (at 0x12f54)"
      tindex ezaxi:0xfc4cf980 %l 0x812f540 0x12f540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S10_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PH_READY (at 0x12f55)"
      tindex ezaxi:0xfc4cf980 %l 0x812f550 0x12f550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S10_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_SS_CTL (at 0x12f60)"
      tindex ezaxi:0xfc4cf980 %l 0x812f600 0x12f600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S10_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VS_CTL (at 0x12f61)"
      tindex ezaxi:0xfc4cf980 %l 0x812f610 0x12f610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S10_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CORR_CFG (at 0x12f62)"
      tindex ezaxi:0xfc4cf980 %l 0x812f620 0x12f620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S10_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_RAMP_CFG (at 0x12f63)"
      tindex ezaxi:0xfc4cf980 %l 0x812f630 0x12f630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S10_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_COMPENS_CFG (at 0x12f64)"
      tindex ezaxi:0xfc4cf980 %l 0x812f640 0x12f640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S10_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_VREG_MON (at 0x12f65)"
      tindex ezaxi:0xfc4cf980 %l 0x812f650 0x12f650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S10_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_VREG_OCP (at 0x12f66)"
      tindex ezaxi:0xfc4cf980 %l 0x812f660 0x12f660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S10_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_PFM_COMP (at 0x12f67)"
      tindex ezaxi:0xfc4cf980 %l 0x812f670 0x12f670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S10_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_UL_LL_CTL (at 0x12f68)"
      tindex ezaxi:0xfc4cf980 %l 0x812f680 0x12f680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S10_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VSET_ULS (at 0x12f69)"
      tindex ezaxi:0xfc4cf980 %l 0x812f690 0x12f690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S10_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_ULS_VALID (at 0x12f6a)"
      tindex ezaxi:0xfc4cf980 %l 0x812f6a0 0x12f6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S10_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VSET_LLS (at 0x12f6b)"
      tindex ezaxi:0xfc4cf980 %l 0x812f6b0 0x12f6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S10_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_LLS_VALID (at 0x12f6c)"
      tindex ezaxi:0xfc4cf980 %l 0x812f6c0 0x12f6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S10_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_GPL_HI (at 0x12f6d)"
      tindex ezaxi:0xfc4cf980 %l 0x812f6d0 0x12f6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S10_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_GPL_LO (at 0x12f6e)"
      tindex ezaxi:0xfc4cf980 %l 0x812f6e0 0x12f6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S10_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_FB_FILT_CFG (at 0x12f6f)"
      tindex ezaxi:0xfc4cf980 %l 0x812f6f0 0x12f6f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S10_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VDIP_CFG (at 0x12f71)"
      tindex ezaxi:0xfc4cf980 %l 0x812f710 0x12f710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S10_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MPH_STROBE (at 0x12f79)"
      tindex ezaxi:0xfc4cf980 %l 0x812f790 0x12f790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S10_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MODE_FSM_MASK (at 0x12fa0)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa00 0x12fa00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S10_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MODE_FSM_WAITS_1 (at 0x12fa1)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa10 0x12fa10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S10_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MODE_FSM_WAIT_2 (at 0x12fa2)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa20 0x12fa20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S10_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_GATE_DRV_MUX (at 0x12fa3)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa30 0x12fa30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S10_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CORR_DUTY_MUX (at 0x12fa4)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa40 0x12fa40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S10_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_EN_OPTIONS_DFT_1 (at 0x12fa5)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa50 0x12fa50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S10_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_EN_OPTIONS_DFT_2 (at 0x12fa6)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa60 0x12fa60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S10_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MPHASE_IDAC (at 0x12fa7)"
      tindex ezaxi:0xfc4cf980 %l 0x812fa70 0x12fa70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S10_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_ANTI_ESL_CFG_1 (at 0x12fac)"
      tindex ezaxi:0xfc4cf980 %l 0x812fac0 0x12fac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S10_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_ANTI_ESL_CFG_2 (at 0x12fad)"
      tindex ezaxi:0xfc4cf980 %l 0x812fad0 0x12fad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S10_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_ATEST1 (at 0x12fb0)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb00 0x12fb00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S10_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_ATEST2 (at 0x12fb1)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb10 0x12fb10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S10_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_ATEST3 (at 0x12fb2)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb20 0x12fb20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S10_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_ATEST4 (at 0x12fb3)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb30 0x12fb30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S10_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_DTEST1 (at 0x12fb4)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb40 0x12fb40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S10_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_DTEST2 (at 0x12fb5)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb50 0x12fb50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S10_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_DTEST3 (at 0x12fb6)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb60 0x12fb60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S10_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CFG_DTEST4 (at 0x12fb7)"
      tindex ezaxi:0xfc4cf980 %l 0x812fb70 0x12fb70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S10_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_GANG_CTL1 (at 0x12fc0)"
      tindex ezaxi:0xfc4cf980 %l 0x812fc00 0x12fc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S10_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_GANG_CTL2 (at 0x12fc1)"
      tindex ezaxi:0xfc4cf980 %l 0x812fc10 0x12fc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S10_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_SEC_ACCESS (at 0x12fd0)"
      tindex ezaxi:0xfc4cf980 %l 0x812fd00 0x12fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S10_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PERPH_RESET_CTL1 (at 0x12fd8)"
      tindex ezaxi:0xfc4cf980 %l 0x812fd80 0x12fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S10_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PERPH_RESET_CTL2 (at 0x12fd9)"
      tindex ezaxi:0xfc4cf980 %l 0x812fd90 0x12fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S10_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PERPH_RESET_CTL3 (at 0x12fda)"
      tindex ezaxi:0xfc4cf980 %l 0x812fda0 0x12fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S10_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PERPH_RESET_CTL4 (at 0x12fdb)"
      tindex ezaxi:0xfc4cf980 %l 0x812fdb0 0x12fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S10_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_TEST1 (at 0x12fe0)"
      tindex ezaxi:0xfc4cf980 %l 0x812fe00 0x12fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S10_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_INT_TEST_VAL (at 0x12fe1)"
      tindex ezaxi:0xfc4cf980 %l 0x812fe10 0x12fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S10_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CAL_REQUEST (at 0x12fe2)"
      tindex ezaxi:0xfc4cf980 %l 0x812fe20 0x12fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S10_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CAL_CTL_1 (at 0x12fe3)"
      tindex ezaxi:0xfc4cf980 %l 0x812fe30 0x12fe30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S10_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CAL_CTL_2 (at 0x12fe4)"
      tindex ezaxi:0xfc4cf980 %l 0x812fe40 0x12fe40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S10_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_MAN_CAL_VAL (at 0x12fe5)"
      tindex ezaxi:0xfc4cf980 %l 0x812fe50 0x12fe50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S10_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_REFDAC_CAL_VAL (at 0x12fea)"
      tindex ezaxi:0xfc4cf980 %l 0x812fea0 0x12fea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S10_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_VDIP_CAL_VAL (at 0x12feb)"
      tindex ezaxi:0xfc4cf980 %l 0x812feb0 0x12feb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S10_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_IDAC_CAL_VAL (at 0x12fec)"
      tindex ezaxi:0xfc4cf980 %l 0x812fec0 0x12fec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S10_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_CORR_CAL_VAL (at 0x12fed)"
      tindex ezaxi:0xfc4cf980 %l 0x812fed0 0x12fed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S10_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PWM_CAL_VAL (at 0x12fee)"
      tindex ezaxi:0xfc4cf980 %l 0x812fee0 0x12fee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S10_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_PFM_CAL_VAL (at 0x12fef)"
      tindex ezaxi:0xfc4cf980 %l 0x812fef0 0x12fef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S10_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_TRIM_NUM (at 0x12ff0)"
      tindex ezaxi:0xfc4cf980 %l 0x812ff00 0x12ff00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S10_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_REFDAC_TRIM (at 0x12ff1)"
      tindex ezaxi:0xfc4cf980 %l 0x812ff10 0x12ff10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S10_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_CTRL_RAMP_TRIM (at 0x12ff2)"
      tindex ezaxi:0xfc4cf980 %l 0x812ff20 0x12ff20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S10_FREQ"
  tree "S10_FREQ"
    tree "S10_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_REVISION1 (at 0x13100)"
      tindex ezaxi:0xfc4cf980 %l 0x8131000 0x131000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S10_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_REVISION2 (at 0x13101)"
      tindex ezaxi:0xfc4cf980 %l 0x8131010 0x131010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S10_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_PERPH_TYPE (at 0x13104)"
      tindex ezaxi:0xfc4cf980 %l 0x8131040 0x131040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S10_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_PERPH_SUBTYPE (at 0x13105)"
      tindex ezaxi:0xfc4cf980 %l 0x8131050 0x131050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S10_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_CLK_ENABLE (at 0x13146)"
      tindex ezaxi:0xfc4cf980 %l 0x8131460 0x131460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S10_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_CLK_DIV (at 0x13150)"
      tindex ezaxi:0xfc4cf980 %l 0x8131500 0x131500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S10_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_CLK_PHASE (at 0x13151)"
      tindex ezaxi:0xfc4cf980 %l 0x8131510 0x131510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S10_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_GANG_CTL1 (at 0x131c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8131c00 0x131c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S10_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_GANG_CTL2 (at 0x131c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8131c10 0x131c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S10_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_SEC_ACCESS (at 0x131d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8131d00 0x131d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S10_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_PERPH_RESET_CTL2 (at 0x131d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8131d90 0x131d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S10_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_PERPH_RESET_CTL3 (at 0x131da)"
      tindex ezaxi:0xfc4cf980 %l 0x8131da0 0x131da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S10_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_PERPH_RESET_CTL4 (at 0x131db)"
      tindex ezaxi:0xfc4cf980 %l 0x8131db0 0x131db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S10_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_FREQ_TEST1 (at 0x131e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8131e20 0x131e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S10_PS"
  tree "S10_PS"
    tree "S10_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_REVISION1 (at 0x13000)"
      tindex ezaxi:0xfc4cf980 %l 0x8130000 0x130000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S10_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_REVISION2 (at 0x13001)"
      tindex ezaxi:0xfc4cf980 %l 0x8130010 0x130010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S10_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_REVISION3 (at 0x13002)"
      tindex ezaxi:0xfc4cf980 %l 0x8130020 0x130020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S10_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_REVISION4 (at 0x13003)"
      tindex ezaxi:0xfc4cf980 %l 0x8130030 0x130030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S10_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PERPH_TYPE (at 0x13004)"
      tindex ezaxi:0xfc4cf980 %l 0x8130040 0x130040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S10_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PERPH_SUBTYPE (at 0x13005)"
      tindex ezaxi:0xfc4cf980 %l 0x8130050 0x130050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S10_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_STATUS_1 (at 0x13008)"
      tindex ezaxi:0xfc4cf980 %l 0x8130080 0x130080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S10_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_STATUS_2 (at 0x13009)"
      tindex ezaxi:0xfc4cf980 %l 0x8130090 0x130090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S10_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_VOLTAGE_CTL1 (at 0x13040)"
      tindex ezaxi:0xfc4cf980 %l 0x8130400 0x130400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S10_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_VOLTAGE_CTL2 (at 0x13041)"
      tindex ezaxi:0xfc4cf980 %l 0x8130410 0x130410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S10_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MODE_CTL (at 0x13045)"
      tindex ezaxi:0xfc4cf980 %l 0x8130450 0x130450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S10_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_FREQ_CTL (at 0x13050)"
      tindex ezaxi:0xfc4cf980 %l 0x8130500 0x130500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S10_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MULTIPHASE_CTL (at 0x13051)"
      tindex ezaxi:0xfc4cf980 %l 0x8130510 0x130510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S10_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PHASE_CTL (at 0x13052)"
      tindex ezaxi:0xfc4cf980 %l 0x8130520 0x130520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S10_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PHASE_ID (at 0x13053)"
      tindex ezaxi:0xfc4cf980 %l 0x8130530 0x130530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S10_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PHASE_CNT_MAX (at 0x13054)"
      tindex ezaxi:0xfc4cf980 %l 0x8130540 0x130540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S10_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PWM_CL_CTL (at 0x13060)"
      tindex ezaxi:0xfc4cf980 %l 0x8130600 0x130600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S10_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LPM_CL_CTL (at 0x13061)"
      tindex ezaxi:0xfc4cf980 %l 0x8130610 0x130610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S10_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_AUTO_CTL_1 (at 0x13062)"
      tindex ezaxi:0xfc4cf980 %l 0x8130620 0x130620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S10_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LPM_ADC_VAL (at 0x13063)"
      tindex ezaxi:0xfc4cf980 %l 0x8130630 0x130630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S10_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LPM_ADC_CTL (at 0x13064)"
      tindex ezaxi:0xfc4cf980 %l 0x8130640 0x130640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S10_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ACTIVITY_DETECT (at 0x13065)"
      tindex ezaxi:0xfc4cf980 %l 0x8130650 0x130650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S10_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LPM_CFG (at 0x13068)"
      tindex ezaxi:0xfc4cf980 %l 0x8130680 0x130680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S10_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_FSM_MINON_CFG (at 0x13070)"
      tindex ezaxi:0xfc4cf980 %l 0x8130700 0x130700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S10_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ZX_CAL_CFG (at 0x13073)"
      tindex ezaxi:0xfc4cf980 %l 0x8130730 0x130730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S10_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_NONOVLAP_CFG (at 0x13074)"
      tindex ezaxi:0xfc4cf980 %l 0x8130740 0x130740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S10_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ADC_FRONT_CFG (at 0x13075)"
      tindex ezaxi:0xfc4cf980 %l 0x8130750 0x130750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S10_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_P0_LUT_IN (at 0x13078)"
      tindex ezaxi:0xfc4cf980 %l 0x8130780 0x130780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S10_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MPH_STROBE (at 0x13079)"
      tindex ezaxi:0xfc4cf980 %l 0x8130790 0x130790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S10_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_OUT (at 0x1307a)"
      tindex ezaxi:0xfc4cf980 %l 0x81307a0 0x1307a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S10_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ADC_OUT (at 0x1307b)"
      tindex ezaxi:0xfc4cf980 %l 0x81307b0 0x1307b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S10_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ADC_FRC (at 0x1307c)"
      tindex ezaxi:0xfc4cf980 %l 0x81307c0 0x1307c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S10_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MP_CORR_DFT (at 0x1307d)"
      tindex ezaxi:0xfc4cf980 %l 0x81307d0 0x1307d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S10_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_DAC_DATA (at 0x1307e)"
      tindex ezaxi:0xfc4cf980 %l 0x81307e0 0x1307e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S10_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_DAC_FRC (at 0x1307f)"
      tindex ezaxi:0xfc4cf980 %l 0x81307f0 0x1307f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S10_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_DAC_PT_0 (at 0x13080)"
      tindex ezaxi:0xfc4cf980 %l 0x8130800 0x130800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S10_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_DAC_PT_1 (at 0x13081)"
      tindex ezaxi:0xfc4cf980 %l 0x8130810 0x130810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S10_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_DAC_PT_2 (at 0x13082)"
      tindex ezaxi:0xfc4cf980 %l 0x8130820 0x130820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S10_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_DAC_PT_3 (at 0x13083)"
      tindex ezaxi:0xfc4cf980 %l 0x8130830 0x130830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S10_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_ADC_PT_1 (at 0x13087)"
      tindex ezaxi:0xfc4cf980 %l 0x8130870 0x130870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S10_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_ADC_PT_2 (at 0x13088)"
      tindex ezaxi:0xfc4cf980 %l 0x8130880 0x130880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S10_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_ADC_PT_3 (at 0x13089)"
      tindex ezaxi:0xfc4cf980 %l 0x8130890 0x130890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S10_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_SLOPE_HI_0 (at 0x1308c)"
      tindex ezaxi:0xfc4cf980 %l 0x81308c0 0x1308c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S10_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_SLOPE_LO_0 (at 0x1308d)"
      tindex ezaxi:0xfc4cf980 %l 0x81308d0 0x1308d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S10_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_SLOPE_HI_1 (at 0x1308e)"
      tindex ezaxi:0xfc4cf980 %l 0x81308e0 0x1308e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S10_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_SLOPE_LO_1 (at 0x1308f)"
      tindex ezaxi:0xfc4cf980 %l 0x81308f0 0x1308f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S10_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_SLOPE_HI_2 (at 0x13090)"
      tindex ezaxi:0xfc4cf980 %l 0x8130900 0x130900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S10_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_LUT_SLOPE_LO_2 (at 0x13091)"
      tindex ezaxi:0xfc4cf980 %l 0x8130910 0x130910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S10_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MPHASE_PI_CFG1 (at 0x13096)"
      tindex ezaxi:0xfc4cf980 %l 0x8130960 0x130960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S10_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MPHASE_PI_CFG4 (at 0x13097)"
      tindex ezaxi:0xfc4cf980 %l 0x8130970 0x130970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S10_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MPHASE_PHASE_CNT (at 0x13098)"
      tindex ezaxi:0xfc4cf980 %l 0x8130980 0x130980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S10_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_EN_OPTIONS_DFT_1 (at 0x130a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8130a80 0x130a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S10_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_EN_OPTIONS_DFT_2 (at 0x130a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8130a90 0x130a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S10_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ZX_ADAPT_CTL (at 0x130aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8130aa0 0x130aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S10_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ZX_ADAPT_VAL (at 0x130ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8130ab0 0x130ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S10_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ADC_CLK_CTL (at 0x130ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8130ac0 0x130ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S10_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ATEST12 (at 0x130b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8130b00 0x130b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S10_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ATEST34 (at 0x130b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8130b10 0x130b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S10_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_DTEST12 (at 0x130b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8130b20 0x130b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S10_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_DTEST43 (at 0x130b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8130b30 0x130b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S10_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_GANG_CTL1 (at 0x130c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8130c00 0x130c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S10_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_GANG_CTL2 (at 0x130c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8130c10 0x130c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S10_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_SEC_ACCESS (at 0x130d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8130d00 0x130d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S10_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PERPH_RESET_CTL2 (at 0x130d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8130d90 0x130d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S10_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PERPH_RESET_CTL3 (at 0x130da)"
      tindex ezaxi:0xfc4cf980 %l 0x8130da0 0x130da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S10_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_PERPH_RESET_CTL4 (at 0x130db)"
      tindex ezaxi:0xfc4cf980 %l 0x8130db0 0x130db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S10_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_CAL_REQUEST (at 0x130e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8130e20 0x130e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S10_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_MAN_CAL_VAL (at 0x130e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8130e50 0x130e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S10_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_REPLICA_CFG (at 0x130e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8130e60 0x130e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S10_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_CAL_CTL_1 (at 0x130e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8130e70 0x130e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S10_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_CAL_CTL_2 (at 0x130e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8130e80 0x130e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S10_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_REPLICA_CAL_VAL (at 0x130ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8130ea0 0x130ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S10_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_DACMID_BUF_CAL_VAL (at 0x130ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8130ec0 0x130ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S10_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_FRONT_BUF_CAL_VAL (at 0x130ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8130ed0 0x130ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S10_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_CL_CAL_VAL (at 0x130ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8130ee0 0x130ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S10_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ZX_CAL_VAL (at 0x130ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8130ef0 0x130ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S10_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_TRIM_NUM (at 0x130f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8130f00 0x130f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S10_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_ZX_TRIM (at 0x130f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8130f10 0x130f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S10_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_CL_TRIM (at 0x130f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8130f20 0x130f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S10_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S10_PS_REPLICA_TRIM (at 0x130f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8130f30 0x130f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S11_CTRL"
  tree "S11_CTRL"
    tree "S11_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_REVISION1 (at 0x13200)"
      tindex ezaxi:0xfc4cf980 %l 0x8132000 0x132000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S11_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_REVISION2 (at 0x13201)"
      tindex ezaxi:0xfc4cf980 %l 0x8132010 0x132010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S11_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_REVISION3 (at 0x13202)"
      tindex ezaxi:0xfc4cf980 %l 0x8132020 0x132020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S11_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_REVISION4 (at 0x13203)"
      tindex ezaxi:0xfc4cf980 %l 0x8132030 0x132030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S11_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PERPH_TYPE (at 0x13204)"
      tindex ezaxi:0xfc4cf980 %l 0x8132040 0x132040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S11_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PERPH_SUBTYPE (at 0x13205)"
      tindex ezaxi:0xfc4cf980 %l 0x8132050 0x132050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S11_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_STATUS_1 (at 0x13208)"
      tindex ezaxi:0xfc4cf980 %l 0x8132080 0x132080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S11_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_STATUS_2 (at 0x13209)"
      tindex ezaxi:0xfc4cf980 %l 0x8132090 0x132090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S11_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_STATUS_3 (at 0x1320a)"
      tindex ezaxi:0xfc4cf980 %l 0x81320a0 0x1320a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S11_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_STATUS_4 (at 0x1320b)"
      tindex ezaxi:0xfc4cf980 %l 0x81320b0 0x1320b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S11_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_STATUS_5 (at 0x1320c)"
      tindex ezaxi:0xfc4cf980 %l 0x81320c0 0x1320c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S11_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_RT_STS (at 0x13210)"
      tindex ezaxi:0xfc4cf980 %l 0x8132100 0x132100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S11_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_SET_TYPE (at 0x13211)"
      tindex ezaxi:0xfc4cf980 %l 0x8132110 0x132110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S11_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_POLARITY_HIGH (at 0x13212)"
      tindex ezaxi:0xfc4cf980 %l 0x8132120 0x132120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S11_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_POLARITY_LOW (at 0x13213)"
      tindex ezaxi:0xfc4cf980 %l 0x8132130 0x132130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S11_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_LATCHED_CLR (at 0x13214)"
      tindex ezaxi:0xfc4cf980 %l 0x8132140 0x132140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S11_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_EN_SET (at 0x13215)"
      tindex ezaxi:0xfc4cf980 %l 0x8132150 0x132150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S11_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_EN_CLR (at 0x13216)"
      tindex ezaxi:0xfc4cf980 %l 0x8132160 0x132160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S11_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_LATCHED_STS (at 0x13218)"
      tindex ezaxi:0xfc4cf980 %l 0x8132180 0x132180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S11_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_PENDING_STS (at 0x13219)"
      tindex ezaxi:0xfc4cf980 %l 0x8132190 0x132190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S11_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_MID_SEL (at 0x1321a)"
      tindex ezaxi:0xfc4cf980 %l 0x81321a0 0x1321a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S11_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_PRIORITY (at 0x1321b)"
      tindex ezaxi:0xfc4cf980 %l 0x81321b0 0x1321b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S11_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VOLTAGE_CTL1 (at 0x13240)"
      tindex ezaxi:0xfc4cf980 %l 0x8132400 0x132400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S11_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VOLTAGE_CTL2 (at 0x13241)"
      tindex ezaxi:0xfc4cf980 %l 0x8132410 0x132410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S11_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VSET_VALID (at 0x13242)"
      tindex ezaxi:0xfc4cf980 %l 0x8132420 0x132420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S11_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MPPFM_VOFFSET (at 0x13244)"
      tindex ezaxi:0xfc4cf980 %l 0x8132440 0x132440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S11_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MODE_CTL (at 0x13245)"
      tindex ezaxi:0xfc4cf980 %l 0x8132450 0x132450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S11_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_EN_CTL (at 0x13246)"
      tindex ezaxi:0xfc4cf980 %l 0x8132460 0x132460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S11_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PD_CTL (at 0x13248)"
      tindex ezaxi:0xfc4cf980 %l 0x8132480 0x132480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S11_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_FREQ_CTL (at 0x13250)"
      tindex ezaxi:0xfc4cf980 %l 0x8132500 0x132500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S11_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MULTIPHASE_CTL (at 0x13251)"
      tindex ezaxi:0xfc4cf980 %l 0x8132510 0x132510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S11_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PHASE_CTL (at 0x13252)"
      tindex ezaxi:0xfc4cf980 %l 0x8132520 0x132520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S11_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PHASE_ID (at 0x13253)"
      tindex ezaxi:0xfc4cf980 %l 0x8132530 0x132530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S11_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PHASE_CNT_MAX (at 0x13254)"
      tindex ezaxi:0xfc4cf980 %l 0x8132540 0x132540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S11_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PH_READY (at 0x13255)"
      tindex ezaxi:0xfc4cf980 %l 0x8132550 0x132550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S11_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_SS_CTL (at 0x13260)"
      tindex ezaxi:0xfc4cf980 %l 0x8132600 0x132600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S11_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VS_CTL (at 0x13261)"
      tindex ezaxi:0xfc4cf980 %l 0x8132610 0x132610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S11_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CORR_CFG (at 0x13262)"
      tindex ezaxi:0xfc4cf980 %l 0x8132620 0x132620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S11_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_RAMP_CFG (at 0x13263)"
      tindex ezaxi:0xfc4cf980 %l 0x8132630 0x132630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S11_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_COMPENS_CFG (at 0x13264)"
      tindex ezaxi:0xfc4cf980 %l 0x8132640 0x132640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S11_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_VREG_MON (at 0x13265)"
      tindex ezaxi:0xfc4cf980 %l 0x8132650 0x132650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S11_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_VREG_OCP (at 0x13266)"
      tindex ezaxi:0xfc4cf980 %l 0x8132660 0x132660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S11_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_PFM_COMP (at 0x13267)"
      tindex ezaxi:0xfc4cf980 %l 0x8132670 0x132670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S11_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_UL_LL_CTL (at 0x13268)"
      tindex ezaxi:0xfc4cf980 %l 0x8132680 0x132680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S11_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VSET_ULS (at 0x13269)"
      tindex ezaxi:0xfc4cf980 %l 0x8132690 0x132690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S11_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_ULS_VALID (at 0x1326a)"
      tindex ezaxi:0xfc4cf980 %l 0x81326a0 0x1326a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S11_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VSET_LLS (at 0x1326b)"
      tindex ezaxi:0xfc4cf980 %l 0x81326b0 0x1326b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S11_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_LLS_VALID (at 0x1326c)"
      tindex ezaxi:0xfc4cf980 %l 0x81326c0 0x1326c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S11_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_GPL_HI (at 0x1326d)"
      tindex ezaxi:0xfc4cf980 %l 0x81326d0 0x1326d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S11_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_GPL_LO (at 0x1326e)"
      tindex ezaxi:0xfc4cf980 %l 0x81326e0 0x1326e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S11_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_FB_FILT_CFG (at 0x1326f)"
      tindex ezaxi:0xfc4cf980 %l 0x81326f0 0x1326f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S11_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VDIP_CFG (at 0x13271)"
      tindex ezaxi:0xfc4cf980 %l 0x8132710 0x132710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S11_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MPH_STROBE (at 0x13279)"
      tindex ezaxi:0xfc4cf980 %l 0x8132790 0x132790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S11_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MODE_FSM_MASK (at 0x132a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a00 0x132a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S11_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MODE_FSM_WAITS_1 (at 0x132a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a10 0x132a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S11_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MODE_FSM_WAIT_2 (at 0x132a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a20 0x132a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S11_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_GATE_DRV_MUX (at 0x132a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a30 0x132a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S11_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CORR_DUTY_MUX (at 0x132a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a40 0x132a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S11_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_EN_OPTIONS_DFT_1 (at 0x132a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a50 0x132a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S11_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_EN_OPTIONS_DFT_2 (at 0x132a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a60 0x132a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S11_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MPHASE_IDAC (at 0x132a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8132a70 0x132a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S11_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_ANTI_ESL_CFG_1 (at 0x132ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8132ac0 0x132ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S11_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_ANTI_ESL_CFG_2 (at 0x132ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8132ad0 0x132ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S11_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_ATEST1 (at 0x132b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b00 0x132b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S11_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_ATEST2 (at 0x132b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b10 0x132b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S11_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_ATEST3 (at 0x132b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b20 0x132b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S11_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_ATEST4 (at 0x132b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b30 0x132b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S11_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_DTEST1 (at 0x132b4)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b40 0x132b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S11_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_DTEST2 (at 0x132b5)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b50 0x132b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S11_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_DTEST3 (at 0x132b6)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b60 0x132b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S11_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CFG_DTEST4 (at 0x132b7)"
      tindex ezaxi:0xfc4cf980 %l 0x8132b70 0x132b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S11_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_GANG_CTL1 (at 0x132c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8132c00 0x132c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S11_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_GANG_CTL2 (at 0x132c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8132c10 0x132c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S11_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_SEC_ACCESS (at 0x132d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8132d00 0x132d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S11_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PERPH_RESET_CTL1 (at 0x132d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8132d80 0x132d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S11_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PERPH_RESET_CTL2 (at 0x132d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8132d90 0x132d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S11_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PERPH_RESET_CTL3 (at 0x132da)"
      tindex ezaxi:0xfc4cf980 %l 0x8132da0 0x132da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S11_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PERPH_RESET_CTL4 (at 0x132db)"
      tindex ezaxi:0xfc4cf980 %l 0x8132db0 0x132db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S11_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_TEST1 (at 0x132e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8132e00 0x132e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S11_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_INT_TEST_VAL (at 0x132e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8132e10 0x132e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S11_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CAL_REQUEST (at 0x132e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8132e20 0x132e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S11_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CAL_CTL_1 (at 0x132e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8132e30 0x132e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S11_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CAL_CTL_2 (at 0x132e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8132e40 0x132e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S11_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_MAN_CAL_VAL (at 0x132e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8132e50 0x132e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S11_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_REFDAC_CAL_VAL (at 0x132ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8132ea0 0x132ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S11_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_VDIP_CAL_VAL (at 0x132eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8132eb0 0x132eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S11_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_IDAC_CAL_VAL (at 0x132ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8132ec0 0x132ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S11_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_CORR_CAL_VAL (at 0x132ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8132ed0 0x132ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S11_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PWM_CAL_VAL (at 0x132ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8132ee0 0x132ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S11_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_PFM_CAL_VAL (at 0x132ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8132ef0 0x132ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S11_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_TRIM_NUM (at 0x132f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8132f00 0x132f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S11_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_REFDAC_TRIM (at 0x132f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8132f10 0x132f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S11_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_CTRL_RAMP_TRIM (at 0x132f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8132f20 0x132f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S11_FREQ"
  tree "S11_FREQ"
    tree "S11_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_REVISION1 (at 0x13400)"
      tindex ezaxi:0xfc4cf980 %l 0x8134000 0x134000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S11_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_REVISION2 (at 0x13401)"
      tindex ezaxi:0xfc4cf980 %l 0x8134010 0x134010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S11_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_PERPH_TYPE (at 0x13404)"
      tindex ezaxi:0xfc4cf980 %l 0x8134040 0x134040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S11_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_PERPH_SUBTYPE (at 0x13405)"
      tindex ezaxi:0xfc4cf980 %l 0x8134050 0x134050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S11_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_CLK_ENABLE (at 0x13446)"
      tindex ezaxi:0xfc4cf980 %l 0x8134460 0x134460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S11_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_CLK_DIV (at 0x13450)"
      tindex ezaxi:0xfc4cf980 %l 0x8134500 0x134500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S11_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_CLK_PHASE (at 0x13451)"
      tindex ezaxi:0xfc4cf980 %l 0x8134510 0x134510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S11_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_GANG_CTL1 (at 0x134c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8134c00 0x134c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S11_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_GANG_CTL2 (at 0x134c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8134c10 0x134c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S11_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_SEC_ACCESS (at 0x134d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8134d00 0x134d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S11_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_PERPH_RESET_CTL2 (at 0x134d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8134d90 0x134d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S11_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_PERPH_RESET_CTL3 (at 0x134da)"
      tindex ezaxi:0xfc4cf980 %l 0x8134da0 0x134da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S11_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_PERPH_RESET_CTL4 (at 0x134db)"
      tindex ezaxi:0xfc4cf980 %l 0x8134db0 0x134db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S11_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_FREQ_TEST1 (at 0x134e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8134e20 0x134e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S11_PS"
  tree "S11_PS"
    tree "S11_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_REVISION1 (at 0x13300)"
      tindex ezaxi:0xfc4cf980 %l 0x8133000 0x133000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S11_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_REVISION2 (at 0x13301)"
      tindex ezaxi:0xfc4cf980 %l 0x8133010 0x133010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S11_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_REVISION3 (at 0x13302)"
      tindex ezaxi:0xfc4cf980 %l 0x8133020 0x133020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S11_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_REVISION4 (at 0x13303)"
      tindex ezaxi:0xfc4cf980 %l 0x8133030 0x133030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S11_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PERPH_TYPE (at 0x13304)"
      tindex ezaxi:0xfc4cf980 %l 0x8133040 0x133040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S11_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PERPH_SUBTYPE (at 0x13305)"
      tindex ezaxi:0xfc4cf980 %l 0x8133050 0x133050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S11_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_STATUS_1 (at 0x13308)"
      tindex ezaxi:0xfc4cf980 %l 0x8133080 0x133080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S11_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_STATUS_2 (at 0x13309)"
      tindex ezaxi:0xfc4cf980 %l 0x8133090 0x133090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S11_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_VOLTAGE_CTL1 (at 0x13340)"
      tindex ezaxi:0xfc4cf980 %l 0x8133400 0x133400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S11_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_VOLTAGE_CTL2 (at 0x13341)"
      tindex ezaxi:0xfc4cf980 %l 0x8133410 0x133410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S11_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MODE_CTL (at 0x13345)"
      tindex ezaxi:0xfc4cf980 %l 0x8133450 0x133450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S11_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_FREQ_CTL (at 0x13350)"
      tindex ezaxi:0xfc4cf980 %l 0x8133500 0x133500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S11_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MULTIPHASE_CTL (at 0x13351)"
      tindex ezaxi:0xfc4cf980 %l 0x8133510 0x133510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S11_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PHASE_CTL (at 0x13352)"
      tindex ezaxi:0xfc4cf980 %l 0x8133520 0x133520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S11_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PHASE_ID (at 0x13353)"
      tindex ezaxi:0xfc4cf980 %l 0x8133530 0x133530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S11_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PHASE_CNT_MAX (at 0x13354)"
      tindex ezaxi:0xfc4cf980 %l 0x8133540 0x133540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S11_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PWM_CL_CTL (at 0x13360)"
      tindex ezaxi:0xfc4cf980 %l 0x8133600 0x133600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S11_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LPM_CL_CTL (at 0x13361)"
      tindex ezaxi:0xfc4cf980 %l 0x8133610 0x133610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S11_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_AUTO_CTL_1 (at 0x13362)"
      tindex ezaxi:0xfc4cf980 %l 0x8133620 0x133620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S11_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LPM_ADC_VAL (at 0x13363)"
      tindex ezaxi:0xfc4cf980 %l 0x8133630 0x133630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S11_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LPM_ADC_CTL (at 0x13364)"
      tindex ezaxi:0xfc4cf980 %l 0x8133640 0x133640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S11_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ACTIVITY_DETECT (at 0x13365)"
      tindex ezaxi:0xfc4cf980 %l 0x8133650 0x133650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S11_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LPM_CFG (at 0x13368)"
      tindex ezaxi:0xfc4cf980 %l 0x8133680 0x133680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S11_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_FSM_MINON_CFG (at 0x13370)"
      tindex ezaxi:0xfc4cf980 %l 0x8133700 0x133700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S11_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ZX_CAL_CFG (at 0x13373)"
      tindex ezaxi:0xfc4cf980 %l 0x8133730 0x133730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S11_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_NONOVLAP_CFG (at 0x13374)"
      tindex ezaxi:0xfc4cf980 %l 0x8133740 0x133740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S11_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ADC_FRONT_CFG (at 0x13375)"
      tindex ezaxi:0xfc4cf980 %l 0x8133750 0x133750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S11_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_P0_LUT_IN (at 0x13378)"
      tindex ezaxi:0xfc4cf980 %l 0x8133780 0x133780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S11_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MPH_STROBE (at 0x13379)"
      tindex ezaxi:0xfc4cf980 %l 0x8133790 0x133790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S11_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_OUT (at 0x1337a)"
      tindex ezaxi:0xfc4cf980 %l 0x81337a0 0x1337a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S11_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ADC_OUT (at 0x1337b)"
      tindex ezaxi:0xfc4cf980 %l 0x81337b0 0x1337b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S11_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ADC_FRC (at 0x1337c)"
      tindex ezaxi:0xfc4cf980 %l 0x81337c0 0x1337c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S11_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MP_CORR_DFT (at 0x1337d)"
      tindex ezaxi:0xfc4cf980 %l 0x81337d0 0x1337d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S11_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_DAC_DATA (at 0x1337e)"
      tindex ezaxi:0xfc4cf980 %l 0x81337e0 0x1337e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S11_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_DAC_FRC (at 0x1337f)"
      tindex ezaxi:0xfc4cf980 %l 0x81337f0 0x1337f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S11_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_DAC_PT_0 (at 0x13380)"
      tindex ezaxi:0xfc4cf980 %l 0x8133800 0x133800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S11_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_DAC_PT_1 (at 0x13381)"
      tindex ezaxi:0xfc4cf980 %l 0x8133810 0x133810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S11_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_DAC_PT_2 (at 0x13382)"
      tindex ezaxi:0xfc4cf980 %l 0x8133820 0x133820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S11_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_DAC_PT_3 (at 0x13383)"
      tindex ezaxi:0xfc4cf980 %l 0x8133830 0x133830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S11_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_ADC_PT_1 (at 0x13387)"
      tindex ezaxi:0xfc4cf980 %l 0x8133870 0x133870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S11_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_ADC_PT_2 (at 0x13388)"
      tindex ezaxi:0xfc4cf980 %l 0x8133880 0x133880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S11_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_ADC_PT_3 (at 0x13389)"
      tindex ezaxi:0xfc4cf980 %l 0x8133890 0x133890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S11_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_SLOPE_HI_0 (at 0x1338c)"
      tindex ezaxi:0xfc4cf980 %l 0x81338c0 0x1338c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S11_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_SLOPE_LO_0 (at 0x1338d)"
      tindex ezaxi:0xfc4cf980 %l 0x81338d0 0x1338d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S11_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_SLOPE_HI_1 (at 0x1338e)"
      tindex ezaxi:0xfc4cf980 %l 0x81338e0 0x1338e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S11_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_SLOPE_LO_1 (at 0x1338f)"
      tindex ezaxi:0xfc4cf980 %l 0x81338f0 0x1338f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S11_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_SLOPE_HI_2 (at 0x13390)"
      tindex ezaxi:0xfc4cf980 %l 0x8133900 0x133900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S11_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_LUT_SLOPE_LO_2 (at 0x13391)"
      tindex ezaxi:0xfc4cf980 %l 0x8133910 0x133910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S11_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MPHASE_PI_CFG1 (at 0x13396)"
      tindex ezaxi:0xfc4cf980 %l 0x8133960 0x133960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S11_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MPHASE_PI_CFG4 (at 0x13397)"
      tindex ezaxi:0xfc4cf980 %l 0x8133970 0x133970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S11_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MPHASE_PHASE_CNT (at 0x13398)"
      tindex ezaxi:0xfc4cf980 %l 0x8133980 0x133980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S11_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_EN_OPTIONS_DFT_1 (at 0x133a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8133a80 0x133a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S11_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_EN_OPTIONS_DFT_2 (at 0x133a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8133a90 0x133a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S11_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ZX_ADAPT_CTL (at 0x133aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8133aa0 0x133aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S11_PS_ZX_ADAPT_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ZX_ADAPT_VAL (at 0x133ab)"
      tindex ezaxi:0xfc4cf980 %l 0x8133ab0 0x133ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S11_PS_ADC_CLK_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ADC_CLK_CTL (at 0x133ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8133ac0 0x133ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CLK_SEL                              = " "0 (ADC_SEL_19P2),1 (ADC_SEL_38P4)"
    tree.end
    tree "S11_PS_ATEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ATEST12 (at 0x133b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8133b00 0x133b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL_OP),1 (ATEST2_ADC_DACTOP),2 (ATEST2_NOT_USED),3 (ATEST2_NOT_USED2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL_OP),1 (ATEST1_ADC_DACOUT),2 (ATEST1_NOT_USED),3 (ATEST1_NOT_USED2)"
    tree.end
    tree "S11_PS_ATEST34"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ATEST34 (at 0x133b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8133b10 0x133b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ATEST4_NOT_USED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_ADC_COMP_PLUS),3 (ATEST3_NOT_USED_2)"
    tree.end
    tree "S11_PS_DTEST12"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_DTEST12 (at 0x133b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8133b20 0x133b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST2                                   = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_ASYNC_FSM_STATE_1),2 (DTEST2_ZX_COMP_OUTPUT),3 (DTEST2_CLK_19P2_DTEST),4 (DTEST2_MP_ACTIVE_PHASE_CNT_OUT_1),5 (DTEST2_MP_NPM_REQ_TO_CTRL),6 (DTEST2_ADC_DATA_VALID),7 (DTEST2_LUT_DATA_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_ASYNC_FSM_STATE_0),2 (DTEST1_CL_COMP_OUTPUT),3 (DTEST1_PFM_ENTRY_TRIG_TO_CTRL),4 (DTEST1_MP_ACTIVE_PHASE_CNT_OUT_0),5 (DTEST1_LUT_DATA_VALID),6 (DTEST1_ADC_DATA_STREAM),7 (DTEST1_ACTIVITY_FLAG)"
    tree.end
    tree "S11_PS_DTEST43"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_DTEST43 (at 0x133b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8133b30 0x133b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST4                                   = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_ADC_DTEST_SELECT_0),2 (DTEST4_ADC_DTEST_SELECT_1),3 (DTEST4_ADC_DTEST_SELECT_2),4 (DTEST4_MP_ACTIVE_PHASE_CNT_OUT_3),5 (DTEST4_FRONT_BUF_DFT),6 (DTEST4_DAC_DATA_STREAM),7 (DTEST4_REC_AVERAGE_STREAM)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_ASYNC_FSM_STATE_2),2 (DTEST3_PULSE_SKIP),3 (DTEST3_PFM_EXIT_TRIG_FROM_CTRL),4 (DTEST3_MP_ACTIVE_PHASE_CNT_OUT_2),5 (DTEST3_DAC_DATA_VALID),6 (DTEST3_PHASE_ERR_STREAM),7 (DTEST3_DACMID_BUF_DFT)"
    tree.end
    tree "S11_PS_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_GANG_CTL1 (at 0x133c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8133c00 0x133c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S11_PS_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_GANG_CTL2 (at 0x133c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8133c10 0x133c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S11_PS_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_SEC_ACCESS (at 0x133d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8133d00 0x133d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S11_PS_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PERPH_RESET_CTL2 (at 0x133d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8133d90 0x133d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S11_PS_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PERPH_RESET_CTL3 (at 0x133da)"
      tindex ezaxi:0xfc4cf980 %l 0x8133da0 0x133da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S11_PS_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_PERPH_RESET_CTL4 (at 0x133db)"
      tindex ezaxi:0xfc4cf980 %l 0x8133db0 0x133db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S11_PS_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_CAL_REQUEST (at 0x133e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8133e20 0x133e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S11_PS_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_MAN_CAL_VAL (at 0x133e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8133e50 0x133e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S11_PS_REPLICA_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_REPLICA_CFG (at 0x133e6)"
      tindex ezaxi:0xfc4cf980 %l 0x8133e60 0x133e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_REP_SEL                              = " "0 (ADC_REP_SEL_DISABL),1 (ADC_REP_SEL_ENABL)"
    tree.end
    tree "S11_PS_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_CAL_CTL_1 (at 0x133e7)"
      tindex ezaxi:0xfc4cf980 %l 0x8133e70 0x133e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DACMID_BUF_CAL_EN                        = " "0 (DACMID_BUF_CAL_CENTER_CODE),1 (DACMID_BUF_CAL_MISSON_CONFIG_MANCAL),2 (DACMID_BUF_CAL_CAL_CONFIG_MANCAL),3 (DACMID_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FRONT_BUF_CAL_EN                         = " "0 (FRONT_BUF_CAL_CENTER_CODE),1 (FRONT_BUF_CAL_MISSON_CONFIG_MANCAL),2 (FRONT_BUF_CAL_CAL_CONFIG_MANCAL),3 (FRONT_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL_EN                                = " "0 (ZX_CAL_USE_ZX_TRIM),1 (ZX_CAL_NOT_USED),2 (ZX_CAL_MANUALCAL_USE_ZX_TRIM),3 (ZX_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S11_PS_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_CAL_CTL_2 (at 0x133e8)"
      tindex ezaxi:0xfc4cf980 %l 0x8133e80 0x133e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_REP_CAL_EN                           = " "0 (ADC_REP_CAL_MISSON_MODE),1 (ADC_REP_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CL_REP_CAL_EN                            = " "0 (CL_REP_CAL_MISSON_MODE),1 (CL_REP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S11_PS_REPLICA_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_REPLICA_CAL_VAL (at 0x133ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8133ea0 0x133ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_CAL_VAL                          = "
    tree.end
    tree "S11_PS_DACMID_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_DACMID_BUF_CAL_VAL (at 0x133ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8133ec0 0x133ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DACMID_BUF_CAL_VAL                       = "
    tree.end
    tree "S11_PS_FRONT_BUF_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_FRONT_BUF_CAL_VAL (at 0x133ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8133ed0 0x133ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FRONT_BUF_CAL_VAL                        = "
    tree.end
    tree "S11_PS_CL_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_CL_CAL_VAL (at 0x133ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8133ee0 0x133ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_CAL_VAL                               = "
    tree.end
    tree "S11_PS_ZX_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ZX_CAL_VAL (at 0x133ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8133ef0 0x133ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S11_PS_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_TRIM_NUM (at 0x133f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8133f00 0x133f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S11_PS_ZX_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_ZX_TRIM (at 0x133f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8133f10 0x133f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S11_PS_CL_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_CL_TRIM (at 0x133f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8133f20 0x133f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CL_TRIM                                  = "
    tree.end
    tree "S11_PS_REPLICA_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S11_PS_REPLICA_TRIM (at 0x133f3)"
      tindex ezaxi:0xfc4cf980 %l 0x8133f30 0x133f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REPLICA_TRIM                             = "
    tree.end
  tree.end
tree.end
tree "S12_CTRL"
  tree "S12_CTRL"
    tree "S12_CTRL_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_REVISION1 (at 0x13500)"
      tindex ezaxi:0xfc4cf980 %l 0x8135000 0x135000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S12_CTRL_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_REVISION2 (at 0x13501)"
      tindex ezaxi:0xfc4cf980 %l 0x8135010 0x135010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S12_CTRL_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_REVISION3 (at 0x13502)"
      tindex ezaxi:0xfc4cf980 %l 0x8135020 0x135020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S12_CTRL_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_REVISION4 (at 0x13503)"
      tindex ezaxi:0xfc4cf980 %l 0x8135030 0x135030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S12_CTRL_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PERPH_TYPE (at 0x13504)"
      tindex ezaxi:0xfc4cf980 %l 0x8135040 0x135040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S12_CTRL_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PERPH_SUBTYPE (at 0x13505)"
      tindex ezaxi:0xfc4cf980 %l 0x8135050 0x135050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S12_CTRL_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_STATUS_1 (at 0x13508)"
      tindex ezaxi:0xfc4cf980 %l 0x8135080 0x135080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S12_CTRL_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_STATUS_2 (at 0x13509)"
      tindex ezaxi:0xfc4cf980 %l 0x8135090 0x135090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S12_CTRL_STATUS_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_STATUS_3 (at 0x1350a)"
      tindex ezaxi:0xfc4cf980 %l 0x81350a0 0x1350a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_CAL_FAULT                         = " "0 (REFDAC_CAL_FAULT_FALSE),1 (REFDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDIP_CAL_FAULT                           = " "0 (VDIP_CAL_FAULT_FALSE),1 (VDIP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S12_CTRL_STATUS_4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_STATUS_4 (at 0x1350b)"
      tindex ezaxi:0xfc4cf980 %l 0x81350b0 0x1350b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S12_CTRL_STATUS_5"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_STATUS_5 (at 0x1350c)"
      tindex ezaxi:0xfc4cf980 %l 0x81350c0 0x1350c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   READY_PHASE_CNT                          = "
    tree.end
    tree "S12_CTRL_INT_RT_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_RT_STS (at 0x13510)"
      tindex ezaxi:0xfc4cf980 %l 0x8135100 0x135100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALSE),1 (LIMIT_ERROR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S12_CTRL_INT_SET_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_SET_TYPE (at 0x13511)"
      tindex ezaxi:0xfc4cf980 %l 0x8135110 0x135110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERROR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S12_CTRL_INT_POLARITY_HIGH"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_POLARITY_HIGH (at 0x13512)"
      tindex ezaxi:0xfc4cf980 %l 0x8135120 0x135120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S12_CTRL_INT_POLARITY_LOW"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_POLARITY_LOW (at 0x13513)"
      tindex ezaxi:0xfc4cf980 %l 0x8135130 0x135130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S12_CTRL_INT_LATCHED_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_LATCHED_CLR (at 0x13514)"
      tindex ezaxi:0xfc4cf980 %l 0x8135140 0x135140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S12_CTRL_INT_EN_SET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_EN_SET (at 0x13515)"
      tindex ezaxi:0xfc4cf980 %l 0x8135150 0x135150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S12_CTRL_INT_EN_CLR"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_EN_CLR (at 0x13516)"
      tindex ezaxi:0xfc4cf980 %l 0x8135160 0x135160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_DISABL),1 (LIMIT_ERROR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S12_CTRL_INT_LATCHED_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_LATCHED_STS (at 0x13518)"
      tindex ezaxi:0xfc4cf980 %l 0x8135180 0x135180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_TRIGGERED),1 (LIMIT_ERROR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S12_CTRL_INT_PENDING_STS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_PENDING_STS (at 0x13519)"
      tindex ezaxi:0xfc4cf980 %l 0x8135190 0x135190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT                          = " "0 (LIMIT_ERROR_INT_NOT_PENDING),1 (LIMIT_ERROR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S12_CTRL_INT_MID_SEL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_MID_SEL (at 0x1351a)"
      tindex ezaxi:0xfc4cf980 %l 0x81351a0 0x1351a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S12_CTRL_INT_PRIORITY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_PRIORITY (at 0x1351b)"
      tindex ezaxi:0xfc4cf980 %l 0x81351b0 0x1351b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S12_CTRL_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VOLTAGE_CTL1 (at 0x13540)"
      tindex ezaxi:0xfc4cf980 %l 0x8135400 0x135400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S12_CTRL_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VOLTAGE_CTL2 (at 0x13541)"
      tindex ezaxi:0xfc4cf980 %l 0x8135410 0x135410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S12_CTRL_VSET_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VSET_VALID (at 0x13542)"
      tindex ezaxi:0xfc4cf980 %l 0x8135420 0x135420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S12_CTRL_MPPFM_VOFFSET"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MPPFM_VOFFSET (at 0x13544)"
      tindex ezaxi:0xfc4cf980 %l 0x8135440 0x135440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MPPFM_VOFFSET                            = " "0 (VSETLO_0_LSB),1 (VSETLO_1_LSB),2 (VSETLO_2_LSB),3 (VSETLO_3_LSB),4 (VSETLO_4_LSB),5 (VSETLO_5_LSB),6 (VSETLO_6_LSB),7 (VSETLO_7_LSB)"
    tree.end
    tree "S12_CTRL_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MODE_CTL (at 0x13545)"
      tindex ezaxi:0xfc4cf980 %l 0x8135450 0x135450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S12_CTRL_EN_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_EN_CTL (at 0x13546)"
      tindex ezaxi:0xfc4cf980 %l 0x8135460 0x135460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S12_CTRL_PD_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PD_CTL (at 0x13548)"
      tindex ezaxi:0xfc4cf980 %l 0x8135480 0x135480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S12_CTRL_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_FREQ_CTL (at 0x13550)"
      tindex ezaxi:0xfc4cf980 %l 0x8135500 0x135500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S12_CTRL_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MULTIPHASE_CTL (at 0x13551)"
      tindex ezaxi:0xfc4cf980 %l 0x8135510 0x135510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S12_CTRL_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PHASE_CTL (at 0x13552)"
      tindex ezaxi:0xfc4cf980 %l 0x8135520 0x135520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S12_CTRL_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PHASE_ID (at 0x13553)"
      tindex ezaxi:0xfc4cf980 %l 0x8135530 0x135530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S12_CTRL_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PHASE_CNT_MAX (at 0x13554)"
      tindex ezaxi:0xfc4cf980 %l 0x8135540 0x135540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S12_CTRL_PH_READY"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PH_READY (at 0x13555)"
      tindex ezaxi:0xfc4cf980 %l 0x8135550 0x135550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PH_READY_NPM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PH_READY_LPM                             = "
    tree.end
    tree "S12_CTRL_SS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_SS_CTL (at 0x13560)"
      tindex ezaxi:0xfc4cf980 %l 0x8135600 0x135600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S12_CTRL_VS_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VS_CTL (at 0x13561)"
      tindex ezaxi:0xfc4cf980 %l 0x8135610 0x135610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S12_CTRL_CORR_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CORR_CFG (at 0x13562)"
      tindex ezaxi:0xfc4cf980 %l 0x8135620 0x135620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S12_CTRL_RAMP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_RAMP_CFG (at 0x13563)"
      tindex ezaxi:0xfc4cf980 %l 0x8135630 0x135630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BPLP2_EN                                 = " "0 (BPLP2_DISABL),1 (BPLP2_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_CFG                                 = "
    tree.end
    tree "S12_CTRL_COMPENS_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_COMPENS_CFG (at 0x13564)"
      tindex ezaxi:0xfc4cf980 %l 0x8135640 0x135640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP2_CFG                                = " "0 (BP_LPF2_200KHZ),1 (BP_LPF2_400KHZ),2 (BP_LPF2_600KHZ),3 (BP_LPF2_800KHZ),4 (BP_LPF2_1000KHZ),5 (BP_LPF2_1200KHZ),6 (BP_LPF2_NOT_SUPPORTED_110),7 (BP_LPF2_NOT_SUPPORTED_111)"
    tree.end
    tree "S12_CTRL_CFG_VREG_MON"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_VREG_MON (at 0x13565)"
      tindex ezaxi:0xfc4cf980 %l 0x8135650 0x135650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_FOLDBACK_EN                         = " "0 (VREG_FAULT_FOLDBACK_DISABL),1 (VREG_FAULT_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_MON_CFG                             = " "0 (VREG_MON_BURST_ENABL),1 (VREG_MON_ALWAYS_ENABL)"
    tree.end
    tree "S12_CTRL_CFG_VREG_OCP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_VREG_OCP (at 0x13566)"
      tindex ezaxi:0xfc4cf980 %l 0x8135660 0x135660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_LAT_EN                               = " "0 (OCP_LATCH_DISABL),1 (OCP_LATCH_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_RETRY_EN                             = " "0 (OCP_RETRY_DISABL),1 (OCP_RETRY_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCP_CLR                                  = " "0, 1"
    tree.end
    tree "S12_CTRL_CFG_PFM_COMP"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_PFM_COMP (at 0x13567)"
      tindex ezaxi:0xfc4cf980 %l 0x8135670 0x135670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   HCPFM_HYS                                = " "0 (HCPFM_COMPARATOR_HYSTERESIS_0MV),1 (HCPFM_COMPARATOR_HYSTERESIS_5MV),2 (HCPFM_COMPARATOR_HYSTERESIS_10MV),3 (HCPFM_COMPARATOR_HYSTERESIS_20MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S12_CTRL_UL_LL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_UL_LL_CTL (at 0x13568)"
      tindex ezaxi:0xfc4cf980 %l 0x8135680 0x135680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S12_CTRL_VSET_ULS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VSET_ULS (at 0x13569)"
      tindex ezaxi:0xfc4cf980 %l 0x8135690 0x135690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S12_CTRL_ULS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_ULS_VALID (at 0x1356a)"
      tindex ezaxi:0xfc4cf980 %l 0x81356a0 0x1356a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S12_CTRL_VSET_LLS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VSET_LLS (at 0x1356b)"
      tindex ezaxi:0xfc4cf980 %l 0x81356b0 0x1356b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S12_CTRL_LLS_VALID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_LLS_VALID (at 0x1356c)"
      tindex ezaxi:0xfc4cf980 %l 0x81356c0 0x1356c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S12_CTRL_GPL_HI"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_GPL_HI (at 0x1356d)"
      tindex ezaxi:0xfc4cf980 %l 0x81356d0 0x1356d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S12_CTRL_GPL_LO"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_GPL_LO (at 0x1356e)"
      tindex ezaxi:0xfc4cf980 %l 0x81356e0 0x1356e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S12_CTRL_FB_FILT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_FB_FILT_CFG (at 0x1356f)"
      tindex ezaxi:0xfc4cf980 %l 0x81356f0 0x1356f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   FB_FILT_SERIES_2                         = " "0 (FBLP_CORNER_INFINITE),1 (FBLP_CORNER_100MHZ),2 (FBLP_CORNER_50MHZ),3 (FBLP_CORNER_10MHZ)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_ITAIL_CFG                            = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S12_CTRL_VDIP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VDIP_CFG (at 0x13571)"
      tindex ezaxi:0xfc4cf980 %l 0x8135710 0x135710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VDIP_CFG                                 = " "0 (VDIP_DISABLED),1 (VDIP_BURST_ENABLED),2 (VDIP_ALWAYS_ENABLED),3 (VDIP_ALWAYS_ENABLED_2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_THRESH                              = " "0 (VDIP_THRESH_10MV),1 (VDIP_THRESH_15MV),2 (VDIP_THRESH_20MV),3 (VDIP_THRESH_25MV)"
    tree.end
    tree "S12_CTRL_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MPH_STROBE (at 0x13579)"
      tindex ezaxi:0xfc4cf980 %l 0x8135790 0x135790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S12_CTRL_MODE_FSM_MASK"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MODE_FSM_MASK (at 0x135a0)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a00 0x135a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S12_CTRL_MODE_FSM_WAITS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MODE_FSM_WAITS_1 (at 0x135a1)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a10 0x135a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TIMER_T3                                 = " "0 (TIMER_T3_5US),1 (TIMER_T3_10US),2 (TIMER_T3_20US),3 (TIMER_T3_30US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TIMER_T2                                 = " "0 (TIMER_T2_5US),1 (TIMER_T2_10US),2 (TIMER_T2_20US),3 (TIMER_T2_30US)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TIMER_T1                                 = " "0 (TIMER_T1_5US),1 (TIMER_T1_10US),2 (TIMER_T1_20US),3 (TIMER_T1_30US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T0                                 = " "0 (TIMER_T0_5US),1 (TIMER_T0_10US),2 (TIMER_T0_20US),3 (TIMER_T0_30US)"
    tree.end
    tree "S12_CTRL_MODE_FSM_WAIT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MODE_FSM_WAIT_2 (at 0x135a2)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a20 0x135a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_T4                                 = " "0 (TIMER_T4_20US),1 (TIMER_T4_40US),2 (TIMER_T4_80US),3 (TIMER_T4_160US)"
    tree.end
    tree "S12_CTRL_GATE_DRV_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_GATE_DRV_MUX (at 0x135a3)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a30 0x135a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S12_CTRL_CORR_DUTY_MUX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CORR_DUTY_MUX (at 0x135a4)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a40 0x135a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S12_CTRL_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_EN_OPTIONS_DFT_1 (at 0x135a5)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a50 0x135a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S12_CTRL_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_EN_OPTIONS_DFT_2 (at 0x135a6)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a60 0x135a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_EXIT_DIP_EN                          = " "0 (PFM_EXIT_DIP_DISABL),1 (PFM_EXIT_DIP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIP_LAT_BYPASS                           = " "0 (DIP_LAT_BYP_DISABL),1 (DIP_LAT_BYP_ENABL)"
    tree.end
    tree "S12_CTRL_MPHASE_IDAC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MPHASE_IDAC (at 0x135a7)"
      tindex ezaxi:0xfc4cf980 %l 0x8135a70 0x135a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "S12_CTRL_ANTI_ESL_CFG_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_ANTI_ESL_CFG_1 (at 0x135ac)"
      tindex ezaxi:0xfc4cf980 %l 0x8135ac0 0x135ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   GATE_DRV_LAT                             = " "0 (GDRV_UNLATCHED),1 (GDRV_HALF_LATCHED),2 (GRDV_FULL_LATCHED),3 (GDRV_LATCH_CTL_INVALID_11)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ESL_PULSE_MAG                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S12_CTRL_ANTI_ESL_CFG_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_ANTI_ESL_CFG_2 (at 0x135ad)"
      tindex ezaxi:0xfc4cf980 %l 0x8135ad0 0x135ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ESL_PULSE_RC_SEL                         = "
    tree.end
    tree "S12_CTRL_CFG_ATEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_ATEST1 (at 0x135b0)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b00 0x135b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S12_CTRL_CFG_ATEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_ATEST2 (at 0x135b1)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b10 0x135b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S12_CTRL_CFG_ATEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_ATEST3 (at 0x135b2)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b20 0x135b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S12_CTRL_CFG_ATEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_ATEST4 (at 0x135b3)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b30 0x135b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S12_CTRL_CFG_DTEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_DTEST1 (at 0x135b4)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b40 0x135b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST1                               = "
    tree.end
    tree "S12_CTRL_CFG_DTEST2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_DTEST2 (at 0x135b5)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b50 0x135b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST2                               = "
    tree.end
    tree "S12_CTRL_CFG_DTEST3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_DTEST3 (at 0x135b6)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b60 0x135b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST3                               = "
    tree.end
    tree "S12_CTRL_CFG_DTEST4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CFG_DTEST4 (at 0x135b7)"
      tindex ezaxi:0xfc4cf980 %l 0x8135b70 0x135b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_DTEST4                               = "
    tree.end
    tree "S12_CTRL_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_GANG_CTL1 (at 0x135c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8135c00 0x135c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S12_CTRL_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_GANG_CTL2 (at 0x135c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8135c10 0x135c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S12_CTRL_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_SEC_ACCESS (at 0x135d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8135d00 0x135d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S12_CTRL_PERPH_RESET_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PERPH_RESET_CTL1 (at 0x135d8)"
      tindex ezaxi:0xfc4cf980 %l 0x8135d80 0x135d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S12_CTRL_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PERPH_RESET_CTL2 (at 0x135d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8135d90 0x135d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S12_CTRL_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PERPH_RESET_CTL3 (at 0x135da)"
      tindex ezaxi:0xfc4cf980 %l 0x8135da0 0x135da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S12_CTRL_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PERPH_RESET_CTL4 (at 0x135db)"
      tindex ezaxi:0xfc4cf980 %l 0x8135db0 0x135db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S12_CTRL_INT_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_TEST1 (at 0x135e0)"
      tindex ezaxi:0xfc4cf980 %l 0x8135e00 0x135e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S12_CTRL_INT_TEST_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_INT_TEST_VAL (at 0x135e1)"
      tindex ezaxi:0xfc4cf980 %l 0x8135e10 0x135e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_INT_TEST_VAL                 = " "0 (LIMIT_ERROR_INT_TEST_VAL_0),1 (LIMIT_ERROR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S12_CTRL_CAL_REQUEST"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CAL_REQUEST (at 0x135e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8135e20 0x135e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S12_CTRL_CAL_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CAL_CTL_1 (at 0x135e3)"
      tindex ezaxi:0xfc4cf980 %l 0x8135e30 0x135e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IDAC_BUF_CAL_EN                          = " "0 (IDAC_BUF_CAL_CENTER_CODE),1 (IDAC_BUF_CAL_MISSON_CONFIG_MANCAL),2 (IDAC_BUF_CAL_CAL_CONFIG_MANCAL),3 (IDAC_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CORR_BUF_CAL_EN                          = " "0 (CORR_BUF_CAL_CENTER_CODE),1 (CORR_BUF_CAL_MISSON_CONFIG_MANCAL),2 (CORR_BUF_CAL_CAL_CONFIG_MANCAL),3 (CORR_BUF_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PWM_CAL_EN                               = " "0 (PWM_CAL_CENTER_CODE),1 (PWM_CAL_MISSON_CONFIG_MANCAL),2 (PWM_CAL_CAL_CONFIG_MANCAL),3 (PWM_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CAL_EN                               = " "0 (PFM_CAL_CENTER_CODE),1 (PFM_CAL_MISSON_CONFIG_MANCAL),2 (PFM_CAL_CAL_CONFIG_MANCAL),3 (PFM_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S12_CTRL_CAL_CTL_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CAL_CTL_2 (at 0x135e4)"
      tindex ezaxi:0xfc4cf980 %l 0x8135e40 0x135e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   REFDAC_CAL_EN                            = " "0 (REFDAC_CAL_USE_REFDAC_TRIM),1 (REFDAC_CAL_NOT_USED_1),2 (REFDAC_CAL_NOT_USED_2),3 (REFDAC_CAL_AUTOCAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VDIP_CAL_EN                              = " "0 (VDIP_CAL_CENTER_CODE),1 (VDIP_CAL_MISSON_CONFIG_MANCAL),2 (VDIP_CAL_CAL_CONFIG_MANCAL),3 (VDIP_CAL_AUTOCAL_ENABL)"
    tree.end
    tree "S12_CTRL_MAN_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_MAN_CAL_VAL (at 0x135e5)"
      tindex ezaxi:0xfc4cf980 %l 0x8135e50 0x135e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAN_CAL_VAL                              = "
    tree.end
    tree "S12_CTRL_REFDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_REFDAC_CAL_VAL (at 0x135ea)"
      tindex ezaxi:0xfc4cf980 %l 0x8135ea0 0x135ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_CAL_VAL                           = "
    tree.end
    tree "S12_CTRL_VDIP_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_VDIP_CAL_VAL (at 0x135eb)"
      tindex ezaxi:0xfc4cf980 %l 0x8135eb0 0x135eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_CAL_VAL                             = "
    tree.end
    tree "S12_CTRL_IDAC_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_IDAC_CAL_VAL (at 0x135ec)"
      tindex ezaxi:0xfc4cf980 %l 0x8135ec0 0x135ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S12_CTRL_CORR_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_CORR_CAL_VAL (at 0x135ed)"
      tindex ezaxi:0xfc4cf980 %l 0x8135ed0 0x135ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S12_CTRL_PWM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PWM_CAL_VAL (at 0x135ee)"
      tindex ezaxi:0xfc4cf980 %l 0x8135ee0 0x135ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S12_CTRL_PFM_CAL_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_PFM_CAL_VAL (at 0x135ef)"
      tindex ezaxi:0xfc4cf980 %l 0x8135ef0 0x135ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S12_CTRL_TRIM_NUM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_TRIM_NUM (at 0x135f0)"
      tindex ezaxi:0xfc4cf980 %l 0x8135f00 0x135f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S12_CTRL_REFDAC_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_REFDAC_TRIM (at 0x135f1)"
      tindex ezaxi:0xfc4cf980 %l 0x8135f10 0x135f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S12_CTRL_RAMP_TRIM"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_CTRL_RAMP_TRIM (at 0x135f2)"
      tindex ezaxi:0xfc4cf980 %l 0x8135f20 0x135f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S12_FREQ"
  tree "S12_FREQ"
    tree "S12_FREQ_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_REVISION1 (at 0x13700)"
      tindex ezaxi:0xfc4cf980 %l 0x8137000 0x137000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S12_FREQ_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_REVISION2 (at 0x13701)"
      tindex ezaxi:0xfc4cf980 %l 0x8137010 0x137010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S12_FREQ_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_PERPH_TYPE (at 0x13704)"
      tindex ezaxi:0xfc4cf980 %l 0x8137040 0x137040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S12_FREQ_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_PERPH_SUBTYPE (at 0x13705)"
      tindex ezaxi:0xfc4cf980 %l 0x8137050 0x137050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S12_FREQ_CLK_ENABLE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_CLK_ENABLE (at 0x13746)"
      tindex ezaxi:0xfc4cf980 %l 0x8137460 0x137460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S12_FREQ_CLK_DIV"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_CLK_DIV (at 0x13750)"
      tindex ezaxi:0xfc4cf980 %l 0x8137500 0x137500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S12_FREQ_CLK_PHASE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_CLK_PHASE (at 0x13751)"
      tindex ezaxi:0xfc4cf980 %l 0x8137510 0x137510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S12_FREQ_GANG_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_GANG_CTL1 (at 0x137c0)"
      tindex ezaxi:0xfc4cf980 %l 0x8137c00 0x137c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S12_FREQ_GANG_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_GANG_CTL2 (at 0x137c1)"
      tindex ezaxi:0xfc4cf980 %l 0x8137c10 0x137c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S12_FREQ_SEC_ACCESS"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_SEC_ACCESS (at 0x137d0)"
      tindex ezaxi:0xfc4cf980 %l 0x8137d00 0x137d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S12_FREQ_PERPH_RESET_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_PERPH_RESET_CTL2 (at 0x137d9)"
      tindex ezaxi:0xfc4cf980 %l 0x8137d90 0x137d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S12_FREQ_PERPH_RESET_CTL3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_PERPH_RESET_CTL3 (at 0x137da)"
      tindex ezaxi:0xfc4cf980 %l 0x8137da0 0x137da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S12_FREQ_PERPH_RESET_CTL4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_PERPH_RESET_CTL4 (at 0x137db)"
      tindex ezaxi:0xfc4cf980 %l 0x8137db0 0x137db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S12_FREQ_TEST1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_FREQ_TEST1 (at 0x137e2)"
      tindex ezaxi:0xfc4cf980 %l 0x8137e20 0x137e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S12_PS"
  tree "S12_PS"
    tree "S12_PS_REVISION1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_REVISION1 (at 0x13600)"
      tindex ezaxi:0xfc4cf980 %l 0x8136000 0x136000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S12_PS_REVISION2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_REVISION2 (at 0x13601)"
      tindex ezaxi:0xfc4cf980 %l 0x8136010 0x136010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S12_PS_REVISION3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_REVISION3 (at 0x13602)"
      tindex ezaxi:0xfc4cf980 %l 0x8136020 0x136020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S12_PS_REVISION4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_REVISION4 (at 0x13603)"
      tindex ezaxi:0xfc4cf980 %l 0x8136030 0x136030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S12_PS_PERPH_TYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PERPH_TYPE (at 0x13604)"
      tindex ezaxi:0xfc4cf980 %l 0x8136040 0x136040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S12_PS_PERPH_SUBTYPE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PERPH_SUBTYPE (at 0x13605)"
      tindex ezaxi:0xfc4cf980 %l 0x8136050 0x136050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S12_PS_STATUS_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_STATUS_1 (at 0x13608)"
      tindex ezaxi:0xfc4cf980 %l 0x8136080 0x136080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_DONE_PS_FLAG                         = " "0 (CAL_DONE_NOT_COMPLETE),1 (CAL_DONE_COMPLETE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADC_REP_CAL_FAULT                        = " "0 (ADC_REP_CAL_FAULT_FALSE),1 (ADC_REP_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DACMID_BUF_CAL_FAULT                     = " "0 (DACMID_BUF_CAL_FAULT_FALSE),1 (DACMID_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FRONT_BUF_CAL_FAULT                      = " "0 (FRONT_BUF_CAL_FAULT_FALSE),1 (FRONT_BUF_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CL_CAL_FAULT                             = " "0 (CL_CAL_FAULT_FALSE),1 (CL_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
    tree.end
    tree "S12_PS_STATUS_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_STATUS_2 (at 0x13609)"
      tindex ezaxi:0xfc4cf980 %l 0x8136090 0x136090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   UNFILT_PHASE_CNT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILT_PHASE_CNT                           = "
    tree.end
    tree "S12_PS_VOLTAGE_CTL1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_VOLTAGE_CTL1 (at 0x13640)"
      tindex ezaxi:0xfc4cf980 %l 0x8136400 0x136400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S12_PS_VOLTAGE_CTL2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_VOLTAGE_CTL2 (at 0x13641)"
      tindex ezaxi:0xfc4cf980 %l 0x8136410 0x136410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S12_PS_MODE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MODE_CTL (at 0x13645)"
      tindex ezaxi:0xfc4cf980 %l 0x8136450 0x136450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S12_PS_FREQ_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_FREQ_CTL (at 0x13650)"
      tindex ezaxi:0xfc4cf980 %l 0x8136500 0x136500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S12_PS_MULTIPHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MULTIPHASE_CTL (at 0x13651)"
      tindex ezaxi:0xfc4cf980 %l 0x8136510 0x136510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LUT_EN                                   = " "0 (LUT_DISABL),1 (LUT_ENABL)"
    tree.end
    tree "S12_PS_PHASE_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PHASE_CTL (at 0x13652)"
      tindex ezaxi:0xfc4cf980 %l 0x8136520 0x136520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE_CORR_EN                            = " "0 (VCORR_DISABL),1 (VCORR_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S12_PS_PHASE_ID"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PHASE_ID (at 0x13653)"
      tindex ezaxi:0xfc4cf980 %l 0x8136530 0x136530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_ID                                 = "
    tree.end
    tree "S12_PS_PHASE_CNT_MAX"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PHASE_CNT_MAX (at 0x13654)"
      tindex ezaxi:0xfc4cf980 %l 0x8136540 0x136540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_CNT_MAX                            = "
    tree.end
    tree "S12_PS_PWM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_PWM_CL_CTL (at 0x13660)"
      tindex ezaxi:0xfc4cf980 %l 0x8136600 0x136600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   HCPFM_CL                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_CL                                   = "
    tree.end
    tree "S12_PS_LPM_CL_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LPM_CL_CTL (at 0x13661)"
      tindex ezaxi:0xfc4cf980 %l 0x8136610 0x136610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LPM_CL                                   = "
    tree.end
    tree "S12_PS_AUTO_CTL_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_AUTO_CTL_1 (at 0x13662)"
      tindex ezaxi:0xfc4cf980 %l 0x8136620 0x136620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   LPM_EXIT_CL_CNT                          = " "0 (LPM_EXIT_CL_CNT_2),1 (LPM_EXIT_CL_CNT_4),2 (LPM_EXIT_CL_CNT_6),3 (LPM_EXIT_CL_CNT_8),4 (LPM_EXIT_CL_CNT_12),5 (LPM_EXIT_CL_CNT_16),6 (LPM_EXIT_CL_CNT_24),7 (LPM_EXIT_CL_CNT_32)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   LPM_ENTRY_DCM_CNT                        = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_DCM_RST                        = " "0 (LPM_ENTRY_CYCLES_RST_IN_1),1 (LPM_ENTRY_CYCLES_RST_IN_2),2 (LPM_ENTRY_CYCLES_RST_IN_4),3 (LPM_ENTRY_CYCLES_RST_IN_8)"
    tree.end
    tree "S12_PS_LPM_ADC_VAL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LPM_ADC_VAL (at 0x13663)"
      tindex ezaxi:0xfc4cf980 %l 0x8136630 0x136630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LPM_ENTRY_ADC_VAL                        = "
    tree.end
    tree "S12_PS_LPM_ADC_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LPM_ADC_CTL (at 0x13664)"
      tindex ezaxi:0xfc4cf980 %l 0x8136640 0x136640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LPM_ENTRY_ADC_DIV                        = " "0, 1, 2, 3"
    tree.end
    tree "S12_PS_ACTIVITY_DETECT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ACTIVITY_DETECT (at 0x13665)"
      tindex ezaxi:0xfc4cf980 %l 0x8136650 0x136650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ACT_LOW_TIMER                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACT_HIGH_TIMER                           = " "0, 1, 2, 3"
    tree.end
    tree "S12_PS_LPM_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LPM_CFG (at 0x13668)"
      tindex ezaxi:0xfc4cf980 %l 0x8136680 0x136680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_BIAS_CFG                             = " "0 (PFM_BIAS_LO),1 (PFM_BIAS_HI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LEGACY                                   = " "0 (LEGACY_PFM_DISABL),1 (LEGACY_PFM_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TOFF                                     = " "0 (TOFF_1X),1 (TOFF_1P5X),2 (TOFF_2X),3 (TOFF_3X)"
    tree.end
    tree "S12_PS_FSM_MINON_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_FSM_MINON_CFG (at 0x13670)"
      tindex ezaxi:0xfc4cf980 %l 0x8136700 0x136700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_10NS),1 (NMOS_MIN_ON_TIME_20NS),2 (NMOS_MIN_ON_TIME_30NS),3 (NMOS_MIN_ON_TIME_40NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_10NS),1 (PMOS_MIN_ON_TIME_20NS),2 (PMOS_MIN_ON_TIME_30NS),3 (PMOS_MIN_ON_TIME_40NS)"
    tree.end
    tree "S12_PS_ZX_CAL_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ZX_CAL_CFG (at 0x13673)"
      tindex ezaxi:0xfc4cf980 %l 0x8136730 0x136730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_VOS_NOM                               = "
    tree.end
    tree "S12_PS_NONOVLAP_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_NONOVLAP_CFG (at 0x13674)"
      tindex ezaxi:0xfc4cf980 %l 0x8136740 0x136740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRAN_CLAMP_EN                            = " "0 (TRAN_CLAMP_DISABL),1 (TRAN_CLAMP_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S12_PS_ADC_FRONT_CFG"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ADC_FRONT_CFG (at 0x13675)"
      tindex ezaxi:0xfc4cf980 %l 0x8136750 0x136750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   REP_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_FILT_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S12_PS_P0_LUT_IN"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_P0_LUT_IN (at 0x13678)"
      tindex ezaxi:0xfc4cf980 %l 0x8136780 0x136780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   P0_LUT_IN                                = "
    tree.end
    tree "S12_PS_MPH_STROBE"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MPH_STROBE (at 0x13679)"
      tindex ezaxi:0xfc4cf980 %l 0x8136790 0x136790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPH_STROBE                               = " "0, 1"
    tree.end
    tree "S12_PS_LUT_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_OUT (at 0x1367a)"
      tindex ezaxi:0xfc4cf980 %l 0x81367a0 0x1367a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LUT_OUT                                  = "
    tree.end
    tree "S12_PS_ADC_OUT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ADC_OUT (at 0x1367b)"
      tindex ezaxi:0xfc4cf980 %l 0x81367b0 0x1367b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S12_PS_ADC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ADC_FRC (at 0x1367c)"
      tindex ezaxi:0xfc4cf980 %l 0x81367c0 0x1367c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_FRC_EN                               = " "0 (DAC_FRC_DISABL),1 (DAC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_FRC_DATA                             = "
    tree.end
    tree "S12_PS_MP_CORR_DFT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MP_CORR_DFT (at 0x1367d)"
      tindex ezaxi:0xfc4cf980 %l 0x81367d0 0x1367d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_FRC                                 = " "0 (CORR_FRC_NORMAL),1 (CORR_FRC_CHECKER1),2 (CORR_FRC_CHECKER2),3 (reserved)"
    tree.end
    tree "S12_PS_DAC_DATA"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_DAC_DATA (at 0x1367e)"
      tindex ezaxi:0xfc4cf980 %l 0x81367e0 0x1367e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_DATA                                 = "
    tree.end
    tree "S12_PS_DAC_FRC"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_DAC_FRC (at 0x1367f)"
      tindex ezaxi:0xfc4cf980 %l 0x81367f0 0x1367f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DAC_FRC_EN                               = " "0 (ADC_FRC_DISABL),1 (ADC_FRC_ENABL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DAC_FRC_DATA                             = "
    tree.end
    tree "S12_PS_LUT_DAC_PT_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_DAC_PT_0 (at 0x13680)"
      tindex ezaxi:0xfc4cf980 %l 0x8136800 0x136800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_0                                 = "
    tree.end
    tree "S12_PS_LUT_DAC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_DAC_PT_1 (at 0x13681)"
      tindex ezaxi:0xfc4cf980 %l 0x8136810 0x136810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_1                                 = "
    tree.end
    tree "S12_PS_LUT_DAC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_DAC_PT_2 (at 0x13682)"
      tindex ezaxi:0xfc4cf980 %l 0x8136820 0x136820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_2                                 = "
    tree.end
    tree "S12_PS_LUT_DAC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_DAC_PT_3 (at 0x13683)"
      tindex ezaxi:0xfc4cf980 %l 0x8136830 0x136830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DAC_PT_3                                 = "
    tree.end
    tree "S12_PS_LUT_ADC_PT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_ADC_PT_1 (at 0x13687)"
      tindex ezaxi:0xfc4cf980 %l 0x8136870 0x136870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_1                                 = "
    tree.end
    tree "S12_PS_LUT_ADC_PT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_ADC_PT_2 (at 0x13688)"
      tindex ezaxi:0xfc4cf980 %l 0x8136880 0x136880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_2                                 = "
    tree.end
    tree "S12_PS_LUT_ADC_PT_3"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_ADC_PT_3 (at 0x13689)"
      tindex ezaxi:0xfc4cf980 %l 0x8136890 0x136890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ADC_PT_3                                 = "
    tree.end
    tree "S12_PS_LUT_SLOPE_HI_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_SLOPE_HI_0 (at 0x1368c)"
      tindex ezaxi:0xfc4cf980 %l 0x81368c0 0x1368c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_0                               = "
    tree.end
    tree "S12_PS_LUT_SLOPE_LO_0"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_SLOPE_LO_0 (at 0x1368d)"
      tindex ezaxi:0xfc4cf980 %l 0x81368d0 0x1368d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_0                               = "
    tree.end
    tree "S12_PS_LUT_SLOPE_HI_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_SLOPE_HI_1 (at 0x1368e)"
      tindex ezaxi:0xfc4cf980 %l 0x81368e0 0x1368e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_1                               = "
    tree.end
    tree "S12_PS_LUT_SLOPE_LO_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_SLOPE_LO_1 (at 0x1368f)"
      tindex ezaxi:0xfc4cf980 %l 0x81368f0 0x1368f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_1                               = "
    tree.end
    tree "S12_PS_LUT_SLOPE_HI_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_SLOPE_HI_2 (at 0x13690)"
      tindex ezaxi:0xfc4cf980 %l 0x8136900 0x136900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SLOPE_HI_2                               = "
    tree.end
    tree "S12_PS_LUT_SLOPE_LO_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_LUT_SLOPE_LO_2 (at 0x13691)"
      tindex ezaxi:0xfc4cf980 %l 0x8136910 0x136910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SLOPE_LO_2                               = "
    tree.end
    tree "S12_PS_MPHASE_PI_CFG1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MPHASE_PI_CFG1 (at 0x13696)"
      tindex ezaxi:0xfc4cf980 %l 0x8136960 0x136960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT                            = "
    tree.end
    tree "S12_PS_MPHASE_PI_CFG4"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MPHASE_PI_CFG4 (at 0x13697)"
      tindex ezaxi:0xfc4cf980 %l 0x8136970 0x136970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT                            = "
    tree.end
    tree "S12_PS_MPHASE_PHASE_CNT"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_MPHASE_PHASE_CNT (at 0x13698)"
      tindex ezaxi:0xfc4cf980 %l 0x8136980 0x136980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT_FILT                           = " "0, 1, 2, 3"
    tree.end
    tree "S12_PS_EN_OPTIONS_DFT_1"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_EN_OPTIONS_DFT_1 (at 0x136a8)"
      tindex ezaxi:0xfc4cf980 %l 0x8136a80 0x136a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ADAPT_ZX_TEST_EN                         = " "0 (ADAPT_ZX_TEST_DISABL),1 (ADAPT_ZX_TEST_FORCE_CLK),2 (ADAPT_ZX_TEST_FORCE_CLK_MASK_LO),3 (ADAPT_ZX_TEST_FORCE_CLK_MASK_HI)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADAPT_ZX_EN                              = " "0 (ADAPT_ZX_DISABL),1 (ADAPT_ZX_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLDBACK_FRC                             = " "0 (FORCE_FOLDBACK_DISABL),1 (FORCE_FOLDBACK_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CL_CFG                                   = " "0 (CL_COMP_DISABL),1 (CL_COMP_ENABL),2 (CL_COMP_ENABL_FRC_LO),3 (CL_COMP_ENABL_FRC_HI)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CFG                                   = " "0 (ZX_COMP_ENABL_ONLY_FOR_PWM_LPM_BURSTS_WARMUP),1 (ZX_COMP_ENABL),2 (ZX_COMP_ENABL_FRC_LO),3 (ZX_COMP_ENABL_FRC_HI)"
    tree.end
    tree "S12_PS_EN_OPTIONS_DFT_2"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_EN_OPTIONS_DFT_2 (at 0x136a9)"
      tindex ezaxi:0xfc4cf980 %l 0x8136a90 0x136a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_ENTRY_ADC_EN                         = " "0 (PFM_ENTRY_ADC_DISABL),1 (PFM_ENTRY_ADC_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_ENTRY_DCM_EN                         = " "0 (PFM_ENTRY_DCM_DISABL),1 (PFM_ENTRY_DCM_ENABL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_EXIT_CL_EN                           = " "0 (PFM_EXIT_CL_DISABL),1 (PFM_EXIT_CL_ENABL)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_DACTOP_ISRC_CFG                      = " "0 (DACTOP_ISRC_DISABL),1 (DACTOP_ISRC_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_DACMID_BUF_TRI                       = " "0 (DACMID_BUF_NORM),1 (DACMID_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_SAMPLE_BUF_TRI                       = " "0 (SAMPLE_BUF_NORM),1 (SAMPLE_BUF_TRI)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_DAC2COMP_SW_EN                       = " "0 (DAC2COMP_SW_OPEN),1 (DAC2COMP_SW_NORM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FULL_FET_SEL                             = " "0, 1"
    tree.end
    tree "S12_PS_ZX_ADAPT_CTL"
      wsgroup.long ezaxi:0xfc4cf990++3 ezaxi:0xfc4cf998 "S12_PS_ZX_ADAPT_CTL (at 0x136aa)"
      tindex ezaxi:0xfc4cf980 %l 0x8136aa0 0x136aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (ZX_SAMPLE_DELAY_TIME_UNIT_ILLEGAL),1 (ZX_SAMPLE_DELAY_TIME_UNIT_10NS),2 (ZX_SAMPLE_DELAY_TIME_UNIT_20NS),3 (ZX_SAMPLE_DELAY_TIME_UNIT_30NS)"
      textline ""
