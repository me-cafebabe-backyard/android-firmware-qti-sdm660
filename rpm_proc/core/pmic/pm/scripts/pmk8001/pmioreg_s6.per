tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
      tindex a:0xfc4cfa00 %l 0x8510000 0x510000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
      tindex a:0xfc4cfa00 %l 0x8510010 0x510010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
      tindex a:0xfc4cfa00 %l 0x8510020 0x510020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
      tindex a:0xfc4cfa00 %l 0x8510030 0x510030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
      tindex a:0xfc4cfa00 %l 0x8510040 0x510040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
      tindex a:0xfc4cfa00 %l 0x8510050 0x510050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_STATUS (at 0x11008)"
      tindex a:0xfc4cfa00 %l 0x8510080 0x510080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
      tindex a:0xfc4cfa00 %l 0x8510100 0x510100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
      tindex a:0xfc4cfa00 %l 0x8510110 0x510110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
      tindex a:0xfc4cfa00 %l 0x8510120 0x510120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
      tindex a:0xfc4cfa00 %l 0x8510130 0x510130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
      tindex a:0xfc4cfa00 %l 0x8510140 0x510140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
      tindex a:0xfc4cfa00 %l 0x8510150 0x510150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
      tindex a:0xfc4cfa00 %l 0x8510160 0x510160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
      tindex a:0xfc4cfa00 %l 0x8510180 0x510180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
      tindex a:0xfc4cfa00 %l 0x8510190 0x510190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
      tindex a:0xfc4cfa00 %l 0x85101a0 0x5101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
      tindex a:0xfc4cfa00 %l 0x85101b0 0x5101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
      tindex a:0xfc4cfa00 %l 0x8510460 0x510460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
      tindex a:0xfc4cfa00 %l 0x8510500 0x510500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0, 1, 2, 3"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
      tindex a:0xfc4cfa00 %l 0x8510d00 0x510d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
      tindex a:0xfc4cfa00 %l 0x8510d90 0x510d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
      tindex a:0xfc4cfa00 %l 0x8510da0 0x510da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
      tindex a:0xfc4cfa00 %l 0x8510db0 0x510db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
      tindex a:0xfc4cfa00 %l 0x8510e00 0x510e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
      tindex a:0xfc4cfa00 %l 0x8510e10 0x510e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
      tindex a:0xfc4cfa00 %l 0x8510e20 0x510e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
      tindex a:0xfc4cfa00 %l 0x8510e30 0x510e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
      tindex a:0xfc4cfa00 %l 0x8510e40 0x510e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
      tindex a:0xfc4cfa00 %l 0x8510e50 0x510e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_REVISION1 (at 0x400)"
      tindex a:0xfc4cfa00 %l 0x8404000 0x404000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_REVISION2 (at 0x401)"
      tindex a:0xfc4cfa00 %l 0x8404010 0x404010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_TYPE (at 0x404)"
      tindex a:0xfc4cfa00 %l 0x8404040 0x404040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_SUBTYPE (at 0x405)"
      tindex a:0xfc4cfa00 %l 0x8404050 0x404050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_STATUS1 (at 0x408)"
      tindex a:0xfc4cfa00 %l 0x8404080 0x404080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_TIMEOUT (at 0x444)"
      tindex a:0xfc4cfa00 %l 0x8404440 0x404440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_SEC_ACCESS (at 0x4d0)"
      tindex a:0xfc4cfa00 %l 0x8404d00 0x404d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
      tindex a:0xfc4cfa00 %l 0x8404d90 0x404d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_RESET_CTL3 (at 0x4da)"
      tindex a:0xfc4cfa00 %l 0x8404da0 0x404da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_PERPH_RESET_CTL4 (at 0x4db)"
      tindex a:0xfc4cfa00 %l 0x8404db0 0x404db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUS_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "BUS_TEST1 (at 0x4e2)"
      tindex a:0xfc4cfa00 %l 0x8404e20 0x404e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION1 (at 0x5900)"
      tindex a:0xfc4cfa00 %l 0x8459000 0x459000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION2 (at 0x5901)"
      tindex a:0xfc4cfa00 %l 0x8459010 0x459010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION3 (at 0x5902)"
      tindex a:0xfc4cfa00 %l 0x8459020 0x459020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_REVISION4 (at 0x5903)"
      tindex a:0xfc4cfa00 %l 0x8459030 0x459030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_TYPE (at 0x5904)"
      tindex a:0xfc4cfa00 %l 0x8459040 0x459040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
      tindex a:0xfc4cfa00 %l 0x8459050 0x459050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_STATUS1 (at 0x5908)"
      tindex a:0xfc4cfa00 %l 0x8459080 0x459080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_RT_STS (at 0x5910)"
      tindex a:0xfc4cfa00 %l 0x8459100 0x459100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_SET_TYPE (at 0x5911)"
      tindex a:0xfc4cfa00 %l 0x8459110 0x459110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
      tindex a:0xfc4cfa00 %l 0x8459120 0x459120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
      tindex a:0xfc4cfa00 %l 0x8459130 0x459130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
      tindex a:0xfc4cfa00 %l 0x8459140 0x459140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_EN_SET (at 0x5915)"
      tindex a:0xfc4cfa00 %l 0x8459150 0x459150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_EN_CLR (at 0x5916)"
      tindex a:0xfc4cfa00 %l 0x8459160 0x459160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
      tindex a:0xfc4cfa00 %l 0x8459180 0x459180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_PENDING_STS (at 0x5919)"
      tindex a:0xfc4cfa00 %l 0x8459190 0x459190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_MID_SEL (at 0x591a)"
      tindex a:0xfc4cfa00 %l 0x84591a0 0x4591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_PRIORITY (at 0x591b)"
      tindex a:0xfc4cfa00 %l 0x84591b0 0x4591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL1 (at 0x5940)"
      tindex a:0xfc4cfa00 %l 0x8459400 0x459400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XORC19M2_CLK_SEL                         = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL2 (at 0x5941)"
      tindex a:0xfc4cfa00 %l 0x8459410 0x459410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL3 (at 0x5942)"
      tindex a:0xfc4cfa00 %l 0x8459420 0x459420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_CLK_CTL4 (at 0x5943)"
      tindex a:0xfc4cfa00 %l 0x8459430 0x459430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_32K_RC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0, 1"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_HALT_CTL (at 0x5945)"
      tindex a:0xfc4cfa00 %l 0x8459450 0x459450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0, 1"
    tree.end
    tree "CLK_DIST_RC_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_RC_CTL (at 0x5946)"
      tindex a:0xfc4cfa00 %l 0x8459460 0x459460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0, 1"
    tree.end
    tree "CLK_DIST_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PD_CTL (at 0x5948)"
      tindex a:0xfc4cfa00 %l 0x8459480 0x459480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_SEC_ACCESS (at 0x59d0)"
      tindex a:0xfc4cfa00 %l 0x8459d00 0x459d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
      tindex a:0xfc4cfa00 %l 0x8459d90 0x459d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
      tindex a:0xfc4cfa00 %l 0x8459da0 0x459da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
      tindex a:0xfc4cfa00 %l 0x8459db0 0x459db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_TEST1 (at 0x59e0)"
      tindex a:0xfc4cfa00 %l 0x8459e00 0x459e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
      tindex a:0xfc4cfa00 %l 0x8459e10 0x459e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0, 1"
    tree.end
    tree "CLK_DIST_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_TEST1 (at 0x59e2)"
      tindex a:0xfc4cfa00 %l 0x8459e20 0x459e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_TEST2 (at 0x59e4)"
      tindex a:0xfc4cfa00 %l 0x8459e40 0x459e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0, 1"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_TRIM_NUM (at 0x59f0)"
      tindex a:0xfc4cfa00 %l 0x8459f00 0x459f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
      tindex a:0xfc4cfa00 %l 0x8459f10 0x459f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "CLK_DIST_RCLF_TRIM (at 0x59f2)"
      tindex a:0xfc4cfa00 %l 0x8459f20 0x459f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_REVISION1 (at 0x500)"
      tindex a:0xfc4cfa00 %l 0x8405000 0x405000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_REVISION2 (at 0x501)"
      tindex a:0xfc4cfa00 %l 0x8405010 0x405010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_TYPE (at 0x504)"
      tindex a:0xfc4cfa00 %l 0x8405040 0x405040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_SUBTYPE (at 0x505)"
      tindex a:0xfc4cfa00 %l 0x8405050 0x405050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_STATUS1 (at 0x508)"
      tindex a:0xfc4cfa00 %l 0x8405080 0x405080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0, 1"
    tree.end
    tree "INT_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_STATUS2 (at 0x509)"
      tindex a:0xfc4cfa00 %l 0x8405090 0x405090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_INT_RESEND_ALL (at 0x540)"
      tindex a:0xfc4cfa00 %l 0x8405400 0x405400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0, 1"
    tree.end
    tree "INT_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_EN_CTL1 (at 0x546)"
      tindex a:0xfc4cfa00 %l 0x8405460 0x405460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0, 1"
    tree.end
    tree "INT_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_SEC_ACCESS (at 0x5d0)"
      tindex a:0xfc4cfa00 %l 0x8405d00 0x405d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL1 (at 0x5d8)"
      tindex a:0xfc4cfa00 %l 0x8405d80 0x405d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL2 (at 0x5d9)"
      tindex a:0xfc4cfa00 %l 0x8405d90 0x405d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL3 (at 0x5da)"
      tindex a:0xfc4cfa00 %l 0x8405da0 0x405da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_PERPH_RESET_CTL4 (at 0x5db)"
      tindex a:0xfc4cfa00 %l 0x8405db0 0x405db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "INT_TEST1 (at 0x5e0)"
      tindex a:0xfc4cfa00 %l 0x8405e00 0x405e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION1 (at 0x2c00)"
      tindex a:0xfc4cfa00 %l 0x842c000 0x42c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION2 (at 0x2c01)"
      tindex a:0xfc4cfa00 %l 0x842c010 0x42c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION3 (at 0x2c02)"
      tindex a:0xfc4cfa00 %l 0x842c020 0x42c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_REVISION4 (at 0x2c03)"
      tindex a:0xfc4cfa00 %l 0x842c030 0x42c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_TYPE (at 0x2c04)"
      tindex a:0xfc4cfa00 %l 0x842c040 0x42c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_SUBTYPE (at 0x2c05)"
      tindex a:0xfc4cfa00 %l 0x842c050 0x42c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_STATUS1 (at 0x2c08)"
      tindex a:0xfc4cfa00 %l 0x842c080 0x42c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "MBG1_MODE_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MODE_CTRL (at 0x2c44)"
      tindex a:0xfc4cfa00 %l 0x842c440 0x42c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0, 1"
    tree.end
    tree "MBG1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_EN_CTL (at 0x2c46)"
      tindex a:0xfc4cfa00 %l 0x842c460 0x42c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0, 1"
    tree.end
    tree "MBG1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_SEC_ACCESS (at 0x2cd0)"
      tindex a:0xfc4cfa00 %l 0x842cd00 0x42cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
      tindex a:0xfc4cfa00 %l 0x842cd80 0x42cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
      tindex a:0xfc4cfa00 %l 0x842cd90 0x42cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
      tindex a:0xfc4cfa00 %l 0x842cda0 0x42cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
      tindex a:0xfc4cfa00 %l 0x842cdb0 0x42cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "MBG1_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_TEST1 (at 0x2ce2)"
      tindex a:0xfc4cfa00 %l 0x842ce20 0x42ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_TEST2 (at 0x2ce3)"
      tindex a:0xfc4cfa00 %l 0x842ce30 0x42ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_TRIM_NUM (at 0x2cf0)"
      tindex a:0xfc4cfa00 %l 0x842cf00 0x42cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM1 (at 0x2cf1)"
      tindex a:0xfc4cfa00 %l 0x842cf10 0x42cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM2 (at 0x2cf2)"
      tindex a:0xfc4cfa00 %l 0x842cf20 0x42cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM3 (at 0x2cf3)"
      tindex a:0xfc4cfa00 %l 0x842cf30 0x42cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM4 (at 0x2cf4)"
      tindex a:0xfc4cfa00 %l 0x842cf40 0x42cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM5 (at 0x2cf5)"
      tindex a:0xfc4cfa00 %l 0x842cf50 0x42cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM6 (at 0x2cf6)"
      tindex a:0xfc4cfa00 %l 0x842cf60 0x42cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM7 (at 0x2cf7)"
      tindex a:0xfc4cfa00 %l 0x842cf70 0x42cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MBG1_MBG_TRIM8 (at 0x2cf8)"
      tindex a:0xfc4cfa00 %l 0x842cf80 0x42cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION1 (at 0x900)"
      tindex a:0xfc4cfa00 %l 0x8409000 0x409000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION2 (at 0x901)"
      tindex a:0xfc4cfa00 %l 0x8409010 0x409010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION3 (at 0x902)"
      tindex a:0xfc4cfa00 %l 0x8409020 0x409020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_REVISION4 (at 0x903)"
      tindex a:0xfc4cfa00 %l 0x8409030 0x409030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_TYPE (at 0x904)"
      tindex a:0xfc4cfa00 %l 0x8409040 0x409040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_SUBTYPE (at 0x905)"
      tindex a:0xfc4cfa00 %l 0x8409050 0x409050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_TEST_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_TEST_ACCESS (at 0x940)"
      tindex a:0xfc4cfa00 %l 0x8409400 0x409400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RFU                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_CONNECT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST_CONNECT_1                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_CONNECT_0                          = " "0, 1"
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
      tindex a:0xfc4cfa00 %l 0x8409420 0x409420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XVDD_DVDD_SRC_CTRL                       = " "0, 1, 2, 3"
    tree.end
    tree "MISC_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_SEC_ACCESS (at 0x9d0)"
      tindex a:0xfc4cfa00 %l 0x8409d00 0x409d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
      tindex a:0xfc4cfa00 %l 0x8409d90 0x409d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_RESET_CTL3 (at 0x9da)"
      tindex a:0xfc4cfa00 %l 0x8409da0 0x409da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MISC_PERPH_RESET_CTL4 (at 0x9db)"
      tindex a:0xfc4cfa00 %l 0x8409db0 0x409db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION1 (at 0xa000)"
      tindex a:0xfc4cfa00 %l 0x84a0000 0x4a0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION2 (at 0xa001)"
      tindex a:0xfc4cfa00 %l 0x84a0010 0x4a0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION3 (at 0xa002)"
      tindex a:0xfc4cfa00 %l 0x84a0020 0x4a0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_REVISION4 (at 0xa003)"
      tindex a:0xfc4cfa00 %l 0x84a0030 0x4a0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_TYPE (at 0xa004)"
      tindex a:0xfc4cfa00 %l 0x84a0040 0x4a0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_SUBTYPE (at 0xa005)"
      tindex a:0xfc4cfa00 %l 0x84a0050 0x4a0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_STATUS1 (at 0xa008)"
      tindex a:0xfc4cfa00 %l 0x84a0080 0x4a0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP1_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_RT_STS (at 0xa010)"
      tindex a:0xfc4cfa00 %l 0x84a0100 0x4a0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_SET_TYPE (at 0xa011)"
      tindex a:0xfc4cfa00 %l 0x84a0110 0x4a0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_POLARITY_HIGH (at 0xa012)"
      tindex a:0xfc4cfa00 %l 0x84a0120 0x4a0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_POLARITY_LOW (at 0xa013)"
      tindex a:0xfc4cfa00 %l 0x84a0130 0x4a0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_LATCHED_CLR (at 0xa014)"
      tindex a:0xfc4cfa00 %l 0x84a0140 0x4a0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_EN_SET (at 0xa015)"
      tindex a:0xfc4cfa00 %l 0x84a0150 0x4a0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_EN_CLR (at 0xa016)"
      tindex a:0xfc4cfa00 %l 0x84a0160 0x4a0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_LATCHED_STS (at 0xa018)"
      tindex a:0xfc4cfa00 %l 0x84a0180 0x4a0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_PENDING_STS (at 0xa019)"
      tindex a:0xfc4cfa00 %l 0x84a0190 0x4a0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP1_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_MID_SEL (at 0xa01a)"
      tindex a:0xfc4cfa00 %l 0x84a01a0 0x4a01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP1_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_INT_PRIORITY (at 0xa01b)"
      tindex a:0xfc4cfa00 %l 0x84a01b0 0x4a01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP1_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_MODE_CTL (at 0xa040)"
      tindex a:0xfc4cfa00 %l 0x84a0400 0x4a0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_DIG_VIN_CTL (at 0xa041)"
      tindex a:0xfc4cfa00 %l 0x84a0410 0x4a0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_DIG_PULL_CTL (at 0xa042)"
      tindex a:0xfc4cfa00 %l 0x84a0420 0x4a0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_DIG_IN_CTL (at 0xa043)"
      tindex a:0xfc4cfa00 %l 0x84a0430 0x4a0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_EN_CTL (at 0xa046)"
      tindex a:0xfc4cfa00 %l 0x84a0460 0x4a0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_ANA_OUT_CTL (at 0xa048)"
      tindex a:0xfc4cfa00 %l 0x84a0480 0x4a0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_ANA_IN_CTL (at 0xa04a)"
      tindex a:0xfc4cfa00 %l 0x84a04a0 0x4a04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_SINK_CTL (at 0xa04c)"
      tindex a:0xfc4cfa00 %l 0x84a04c0 0x4a04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_SEC_ACCESS (at 0xa0d0)"
      tindex a:0xfc4cfa00 %l 0x84a0d00 0x4a0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
      tindex a:0xfc4cfa00 %l 0x84a0d80 0x4a0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
      tindex a:0xfc4cfa00 %l 0x84a0d90 0x4a0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
      tindex a:0xfc4cfa00 %l 0x84a0da0 0x4a0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
      tindex a:0xfc4cfa00 %l 0x84a0db0 0x4a0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION1 (at 0xa100)"
      tindex a:0xfc4cfa00 %l 0x84a1000 0x4a1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION2 (at 0xa101)"
      tindex a:0xfc4cfa00 %l 0x84a1010 0x4a1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION3 (at 0xa102)"
      tindex a:0xfc4cfa00 %l 0x84a1020 0x4a1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_REVISION4 (at 0xa103)"
      tindex a:0xfc4cfa00 %l 0x84a1030 0x4a1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_TYPE (at 0xa104)"
      tindex a:0xfc4cfa00 %l 0x84a1040 0x4a1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_SUBTYPE (at 0xa105)"
      tindex a:0xfc4cfa00 %l 0x84a1050 0x4a1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_STATUS1 (at 0xa108)"
      tindex a:0xfc4cfa00 %l 0x84a1080 0x4a1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP2_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_RT_STS (at 0xa110)"
      tindex a:0xfc4cfa00 %l 0x84a1100 0x4a1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_SET_TYPE (at 0xa111)"
      tindex a:0xfc4cfa00 %l 0x84a1110 0x4a1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_POLARITY_HIGH (at 0xa112)"
      tindex a:0xfc4cfa00 %l 0x84a1120 0x4a1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_POLARITY_LOW (at 0xa113)"
      tindex a:0xfc4cfa00 %l 0x84a1130 0x4a1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_LATCHED_CLR (at 0xa114)"
      tindex a:0xfc4cfa00 %l 0x84a1140 0x4a1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_EN_SET (at 0xa115)"
      tindex a:0xfc4cfa00 %l 0x84a1150 0x4a1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_EN_CLR (at 0xa116)"
      tindex a:0xfc4cfa00 %l 0x84a1160 0x4a1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_LATCHED_STS (at 0xa118)"
      tindex a:0xfc4cfa00 %l 0x84a1180 0x4a1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_PENDING_STS (at 0xa119)"
      tindex a:0xfc4cfa00 %l 0x84a1190 0x4a1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP2_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_MID_SEL (at 0xa11a)"
      tindex a:0xfc4cfa00 %l 0x84a11a0 0x4a11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP2_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_INT_PRIORITY (at 0xa11b)"
      tindex a:0xfc4cfa00 %l 0x84a11b0 0x4a11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP2_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_MODE_CTL (at 0xa140)"
      tindex a:0xfc4cfa00 %l 0x84a1400 0x4a1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_DIG_VIN_CTL (at 0xa141)"
      tindex a:0xfc4cfa00 %l 0x84a1410 0x4a1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_DIG_PULL_CTL (at 0xa142)"
      tindex a:0xfc4cfa00 %l 0x84a1420 0x4a1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_DIG_IN_CTL (at 0xa143)"
      tindex a:0xfc4cfa00 %l 0x84a1430 0x4a1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_EN_CTL (at 0xa146)"
      tindex a:0xfc4cfa00 %l 0x84a1460 0x4a1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_ANA_OUT_CTL (at 0xa148)"
      tindex a:0xfc4cfa00 %l 0x84a1480 0x4a1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_ANA_IN_CTL (at 0xa14a)"
      tindex a:0xfc4cfa00 %l 0x84a14a0 0x4a14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_SINK_CTL (at 0xa14c)"
      tindex a:0xfc4cfa00 %l 0x84a14c0 0x4a14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_SEC_ACCESS (at 0xa1d0)"
      tindex a:0xfc4cfa00 %l 0x84a1d00 0x4a1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
      tindex a:0xfc4cfa00 %l 0x84a1d80 0x4a1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
      tindex a:0xfc4cfa00 %l 0x84a1d90 0x4a1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
      tindex a:0xfc4cfa00 %l 0x84a1da0 0x4a1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
      tindex a:0xfc4cfa00 %l 0x84a1db0 0x4a1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION1 (at 0xa200)"
      tindex a:0xfc4cfa00 %l 0x84a2000 0x4a2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION2 (at 0xa201)"
      tindex a:0xfc4cfa00 %l 0x84a2010 0x4a2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION3 (at 0xa202)"
      tindex a:0xfc4cfa00 %l 0x84a2020 0x4a2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_REVISION4 (at 0xa203)"
      tindex a:0xfc4cfa00 %l 0x84a2030 0x4a2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_TYPE (at 0xa204)"
      tindex a:0xfc4cfa00 %l 0x84a2040 0x4a2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_SUBTYPE (at 0xa205)"
      tindex a:0xfc4cfa00 %l 0x84a2050 0x4a2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_STATUS1 (at 0xa208)"
      tindex a:0xfc4cfa00 %l 0x84a2080 0x4a2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP3_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_RT_STS (at 0xa210)"
      tindex a:0xfc4cfa00 %l 0x84a2100 0x4a2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_SET_TYPE (at 0xa211)"
      tindex a:0xfc4cfa00 %l 0x84a2110 0x4a2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_POLARITY_HIGH (at 0xa212)"
      tindex a:0xfc4cfa00 %l 0x84a2120 0x4a2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_POLARITY_LOW (at 0xa213)"
      tindex a:0xfc4cfa00 %l 0x84a2130 0x4a2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_LATCHED_CLR (at 0xa214)"
      tindex a:0xfc4cfa00 %l 0x84a2140 0x4a2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_EN_SET (at 0xa215)"
      tindex a:0xfc4cfa00 %l 0x84a2150 0x4a2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_EN_CLR (at 0xa216)"
      tindex a:0xfc4cfa00 %l 0x84a2160 0x4a2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_LATCHED_STS (at 0xa218)"
      tindex a:0xfc4cfa00 %l 0x84a2180 0x4a2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_PENDING_STS (at 0xa219)"
      tindex a:0xfc4cfa00 %l 0x84a2190 0x4a2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP3_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_MID_SEL (at 0xa21a)"
      tindex a:0xfc4cfa00 %l 0x84a21a0 0x4a21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP3_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_INT_PRIORITY (at 0xa21b)"
      tindex a:0xfc4cfa00 %l 0x84a21b0 0x4a21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP3_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_MODE_CTL (at 0xa240)"
      tindex a:0xfc4cfa00 %l 0x84a2400 0x4a2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_DIG_VIN_CTL (at 0xa241)"
      tindex a:0xfc4cfa00 %l 0x84a2410 0x4a2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_DIG_PULL_CTL (at 0xa242)"
      tindex a:0xfc4cfa00 %l 0x84a2420 0x4a2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_DIG_IN_CTL (at 0xa243)"
      tindex a:0xfc4cfa00 %l 0x84a2430 0x4a2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP3_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_EN_CTL (at 0xa246)"
      tindex a:0xfc4cfa00 %l 0x84a2460 0x4a2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_ANA_OUT_CTL (at 0xa248)"
      tindex a:0xfc4cfa00 %l 0x84a2480 0x4a2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_ANA_IN_CTL (at 0xa24a)"
      tindex a:0xfc4cfa00 %l 0x84a24a0 0x4a24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_SINK_CTL (at 0xa24c)"
      tindex a:0xfc4cfa00 %l 0x84a24c0 0x4a24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_SEC_ACCESS (at 0xa2d0)"
      tindex a:0xfc4cfa00 %l 0x84a2d00 0x4a2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
      tindex a:0xfc4cfa00 %l 0x84a2d80 0x4a2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
      tindex a:0xfc4cfa00 %l 0x84a2d90 0x4a2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
      tindex a:0xfc4cfa00 %l 0x84a2da0 0x4a2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
      tindex a:0xfc4cfa00 %l 0x84a2db0 0x4a2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION1 (at 0xa300)"
      tindex a:0xfc4cfa00 %l 0x84a3000 0x4a3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION2 (at 0xa301)"
      tindex a:0xfc4cfa00 %l 0x84a3010 0x4a3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION3 (at 0xa302)"
      tindex a:0xfc4cfa00 %l 0x84a3020 0x4a3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_REVISION4 (at 0xa303)"
      tindex a:0xfc4cfa00 %l 0x84a3030 0x4a3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_TYPE (at 0xa304)"
      tindex a:0xfc4cfa00 %l 0x84a3040 0x4a3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_SUBTYPE (at 0xa305)"
      tindex a:0xfc4cfa00 %l 0x84a3050 0x4a3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_STATUS1 (at 0xa308)"
      tindex a:0xfc4cfa00 %l 0x84a3080 0x4a3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP4_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_RT_STS (at 0xa310)"
      tindex a:0xfc4cfa00 %l 0x84a3100 0x4a3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_SET_TYPE (at 0xa311)"
      tindex a:0xfc4cfa00 %l 0x84a3110 0x4a3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_POLARITY_HIGH (at 0xa312)"
      tindex a:0xfc4cfa00 %l 0x84a3120 0x4a3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_POLARITY_LOW (at 0xa313)"
      tindex a:0xfc4cfa00 %l 0x84a3130 0x4a3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_LATCHED_CLR (at 0xa314)"
      tindex a:0xfc4cfa00 %l 0x84a3140 0x4a3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_EN_SET (at 0xa315)"
      tindex a:0xfc4cfa00 %l 0x84a3150 0x4a3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_EN_CLR (at 0xa316)"
      tindex a:0xfc4cfa00 %l 0x84a3160 0x4a3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_LATCHED_STS (at 0xa318)"
      tindex a:0xfc4cfa00 %l 0x84a3180 0x4a3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_PENDING_STS (at 0xa319)"
      tindex a:0xfc4cfa00 %l 0x84a3190 0x4a3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP4_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_MID_SEL (at 0xa31a)"
      tindex a:0xfc4cfa00 %l 0x84a31a0 0x4a31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP4_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_INT_PRIORITY (at 0xa31b)"
      tindex a:0xfc4cfa00 %l 0x84a31b0 0x4a31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP4_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_MODE_CTL (at 0xa340)"
      tindex a:0xfc4cfa00 %l 0x84a3400 0x4a3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_DIG_VIN_CTL (at 0xa341)"
      tindex a:0xfc4cfa00 %l 0x84a3410 0x4a3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_DIG_PULL_CTL (at 0xa342)"
      tindex a:0xfc4cfa00 %l 0x84a3420 0x4a3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_DIG_IN_CTL (at 0xa343)"
      tindex a:0xfc4cfa00 %l 0x84a3430 0x4a3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP4_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_EN_CTL (at 0xa346)"
      tindex a:0xfc4cfa00 %l 0x84a3460 0x4a3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_ANA_OUT_CTL (at 0xa348)"
      tindex a:0xfc4cfa00 %l 0x84a3480 0x4a3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_ANA_IN_CTL (at 0xa34a)"
      tindex a:0xfc4cfa00 %l 0x84a34a0 0x4a34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_SINK_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_SINK_CTL (at 0xa34c)"
      tindex a:0xfc4cfa00 %l 0x84a34c0 0x4a34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_SEC_ACCESS (at 0xa3d0)"
      tindex a:0xfc4cfa00 %l 0x84a3d00 0x4a3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
      tindex a:0xfc4cfa00 %l 0x84a3d80 0x4a3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
      tindex a:0xfc4cfa00 %l 0x84a3d90 0x4a3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
      tindex a:0xfc4cfa00 %l 0x84a3da0 0x4a3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
      tindex a:0xfc4cfa00 %l 0x84a3db0 0x4a3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION1 (at 0x7100)"
      tindex a:0xfc4cfa00 %l 0x8471000 0x471000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION2 (at 0x7101)"
      tindex a:0xfc4cfa00 %l 0x8471010 0x471010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION3 (at 0x7102)"
      tindex a:0xfc4cfa00 %l 0x8471020 0x471020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_REVISION4 (at 0x7103)"
      tindex a:0xfc4cfa00 %l 0x8471030 0x471030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
      tindex a:0xfc4cfa00 %l 0x8471040 0x471040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
      tindex a:0xfc4cfa00 %l 0x8471050 0x471050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_STATUS0 (at 0x7108)"
      tindex a:0xfc4cfa00 %l 0x8471080 0x471080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
      tindex a:0xfc4cfa00 %l 0x8471100 0x471100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
      tindex a:0xfc4cfa00 %l 0x8471110 0x471110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
      tindex a:0xfc4cfa00 %l 0x8471120 0x471120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
      tindex a:0xfc4cfa00 %l 0x8471130 0x471130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
      tindex a:0xfc4cfa00 %l 0x8471140 0x471140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
      tindex a:0xfc4cfa00 %l 0x8471150 0x471150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
      tindex a:0xfc4cfa00 %l 0x8471160 0x471160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
      tindex a:0xfc4cfa00 %l 0x8471180 0x471180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
      tindex a:0xfc4cfa00 %l 0x8471190 0x471190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
      tindex a:0xfc4cfa00 %l 0x84711a0 0x4711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
      tindex a:0xfc4cfa00 %l 0x84711b0 0x4711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
      tindex a:0xfc4cfa00 %l 0x8471400 0x471400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
      tindex a:0xfc4cfa00 %l 0x8471420 0x471420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_EN_CTL (at 0x7146)"
      tindex a:0xfc4cfa00 %l 0x8471460 0x471460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
      tindex a:0xfc4cfa00 %l 0x8471d00 0x471d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
      tindex a:0xfc4cfa00 %l 0x8471d80 0x471d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
      tindex a:0xfc4cfa00 %l 0x8471d90 0x471d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
      tindex a:0xfc4cfa00 %l 0x8471da0 0x471da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
      tindex a:0xfc4cfa00 %l 0x8471db0 0x471db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
      tindex a:0xfc4cfa00 %l 0x8471e00 0x471e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
      tindex a:0xfc4cfa00 %l 0x8471e10 0x471e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION1 (at 0x7200)"
      tindex a:0xfc4cfa00 %l 0x8472000 0x472000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION2 (at 0x7201)"
      tindex a:0xfc4cfa00 %l 0x8472010 0x472010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION3 (at 0x7202)"
      tindex a:0xfc4cfa00 %l 0x8472020 0x472020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_REVISION4 (at 0x7203)"
      tindex a:0xfc4cfa00 %l 0x8472030 0x472030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
      tindex a:0xfc4cfa00 %l 0x8472040 0x472040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
      tindex a:0xfc4cfa00 %l 0x8472050 0x472050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_STATUS0 (at 0x7208)"
      tindex a:0xfc4cfa00 %l 0x8472080 0x472080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
      tindex a:0xfc4cfa00 %l 0x8472100 0x472100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
      tindex a:0xfc4cfa00 %l 0x8472110 0x472110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
      tindex a:0xfc4cfa00 %l 0x8472120 0x472120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
      tindex a:0xfc4cfa00 %l 0x8472130 0x472130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
      tindex a:0xfc4cfa00 %l 0x8472140 0x472140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
      tindex a:0xfc4cfa00 %l 0x8472150 0x472150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
      tindex a:0xfc4cfa00 %l 0x8472160 0x472160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
      tindex a:0xfc4cfa00 %l 0x8472180 0x472180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
      tindex a:0xfc4cfa00 %l 0x8472190 0x472190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
      tindex a:0xfc4cfa00 %l 0x84721a0 0x4721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
      tindex a:0xfc4cfa00 %l 0x84721b0 0x4721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
      tindex a:0xfc4cfa00 %l 0x8472400 0x472400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
      tindex a:0xfc4cfa00 %l 0x8472420 0x472420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_EN_CTL (at 0x7246)"
      tindex a:0xfc4cfa00 %l 0x8472460 0x472460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
      tindex a:0xfc4cfa00 %l 0x8472d00 0x472d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
      tindex a:0xfc4cfa00 %l 0x8472d80 0x472d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
      tindex a:0xfc4cfa00 %l 0x8472d90 0x472d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
      tindex a:0xfc4cfa00 %l 0x8472da0 0x472da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
      tindex a:0xfc4cfa00 %l 0x8472db0 0x472db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
      tindex a:0xfc4cfa00 %l 0x8472e00 0x472e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
      tindex a:0xfc4cfa00 %l 0x8472e10 0x472e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION1 (at 0x7300)"
      tindex a:0xfc4cfa00 %l 0x8473000 0x473000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION2 (at 0x7301)"
      tindex a:0xfc4cfa00 %l 0x8473010 0x473010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION3 (at 0x7302)"
      tindex a:0xfc4cfa00 %l 0x8473020 0x473020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_REVISION4 (at 0x7303)"
      tindex a:0xfc4cfa00 %l 0x8473030 0x473030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
      tindex a:0xfc4cfa00 %l 0x8473040 0x473040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
      tindex a:0xfc4cfa00 %l 0x8473050 0x473050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_STATUS0 (at 0x7308)"
      tindex a:0xfc4cfa00 %l 0x8473080 0x473080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
      tindex a:0xfc4cfa00 %l 0x8473100 0x473100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
      tindex a:0xfc4cfa00 %l 0x8473110 0x473110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
      tindex a:0xfc4cfa00 %l 0x8473120 0x473120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
      tindex a:0xfc4cfa00 %l 0x8473130 0x473130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
      tindex a:0xfc4cfa00 %l 0x8473140 0x473140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
      tindex a:0xfc4cfa00 %l 0x8473150 0x473150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
      tindex a:0xfc4cfa00 %l 0x8473160 0x473160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
      tindex a:0xfc4cfa00 %l 0x8473180 0x473180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
      tindex a:0xfc4cfa00 %l 0x8473190 0x473190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
      tindex a:0xfc4cfa00 %l 0x84731a0 0x4731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
      tindex a:0xfc4cfa00 %l 0x84731b0 0x4731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
      tindex a:0xfc4cfa00 %l 0x8473400 0x473400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
      tindex a:0xfc4cfa00 %l 0x8473420 0x473420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_EN_CTL (at 0x7346)"
      tindex a:0xfc4cfa00 %l 0x8473460 0x473460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
      tindex a:0xfc4cfa00 %l 0x8473d00 0x473d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
      tindex a:0xfc4cfa00 %l 0x8473d80 0x473d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
      tindex a:0xfc4cfa00 %l 0x8473d90 0x473d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
      tindex a:0xfc4cfa00 %l 0x8473da0 0x473da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
      tindex a:0xfc4cfa00 %l 0x8473db0 0x473db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
      tindex a:0xfc4cfa00 %l 0x8473e00 0x473e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
      tindex a:0xfc4cfa00 %l 0x8473e10 0x473e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION1 (at 0x7400)"
      tindex a:0xfc4cfa00 %l 0x8474000 0x474000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION2 (at 0x7401)"
      tindex a:0xfc4cfa00 %l 0x8474010 0x474010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION3 (at 0x7402)"
      tindex a:0xfc4cfa00 %l 0x8474020 0x474020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_REVISION4 (at 0x7403)"
      tindex a:0xfc4cfa00 %l 0x8474030 0x474030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
      tindex a:0xfc4cfa00 %l 0x8474040 0x474040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
      tindex a:0xfc4cfa00 %l 0x8474050 0x474050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_STATUS0 (at 0x7408)"
      tindex a:0xfc4cfa00 %l 0x8474080 0x474080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
      tindex a:0xfc4cfa00 %l 0x8474100 0x474100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
      tindex a:0xfc4cfa00 %l 0x8474110 0x474110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
      tindex a:0xfc4cfa00 %l 0x8474120 0x474120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
      tindex a:0xfc4cfa00 %l 0x8474130 0x474130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
      tindex a:0xfc4cfa00 %l 0x8474140 0x474140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
      tindex a:0xfc4cfa00 %l 0x8474150 0x474150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
      tindex a:0xfc4cfa00 %l 0x8474160 0x474160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
      tindex a:0xfc4cfa00 %l 0x8474180 0x474180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
      tindex a:0xfc4cfa00 %l 0x8474190 0x474190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
      tindex a:0xfc4cfa00 %l 0x84741a0 0x4741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
      tindex a:0xfc4cfa00 %l 0x84741b0 0x4741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
      tindex a:0xfc4cfa00 %l 0x8474400 0x474400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
      tindex a:0xfc4cfa00 %l 0x8474420 0x474420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_EN_CTL (at 0x7446)"
      tindex a:0xfc4cfa00 %l 0x8474460 0x474460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
      tindex a:0xfc4cfa00 %l 0x8474d00 0x474d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
      tindex a:0xfc4cfa00 %l 0x8474d80 0x474d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
      tindex a:0xfc4cfa00 %l 0x8474d90 0x474d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
      tindex a:0xfc4cfa00 %l 0x8474da0 0x474da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
      tindex a:0xfc4cfa00 %l 0x8474db0 0x474db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
      tindex a:0xfc4cfa00 %l 0x8474e00 0x474e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
      tindex a:0xfc4cfa00 %l 0x8474e10 0x474e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION1 (at 0x7500)"
      tindex a:0xfc4cfa00 %l 0x8475000 0x475000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION2 (at 0x7501)"
      tindex a:0xfc4cfa00 %l 0x8475010 0x475010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION3 (at 0x7502)"
      tindex a:0xfc4cfa00 %l 0x8475020 0x475020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_REVISION4 (at 0x7503)"
      tindex a:0xfc4cfa00 %l 0x8475030 0x475030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
      tindex a:0xfc4cfa00 %l 0x8475040 0x475040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
      tindex a:0xfc4cfa00 %l 0x8475050 0x475050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_STATUS0 (at 0x7508)"
      tindex a:0xfc4cfa00 %l 0x8475080 0x475080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
      tindex a:0xfc4cfa00 %l 0x8475100 0x475100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
      tindex a:0xfc4cfa00 %l 0x8475110 0x475110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
      tindex a:0xfc4cfa00 %l 0x8475120 0x475120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
      tindex a:0xfc4cfa00 %l 0x8475130 0x475130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
      tindex a:0xfc4cfa00 %l 0x8475140 0x475140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
      tindex a:0xfc4cfa00 %l 0x8475150 0x475150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
      tindex a:0xfc4cfa00 %l 0x8475160 0x475160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
      tindex a:0xfc4cfa00 %l 0x8475180 0x475180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
      tindex a:0xfc4cfa00 %l 0x8475190 0x475190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
      tindex a:0xfc4cfa00 %l 0x84751a0 0x4751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
      tindex a:0xfc4cfa00 %l 0x84751b0 0x4751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
      tindex a:0xfc4cfa00 %l 0x8475400 0x475400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
      tindex a:0xfc4cfa00 %l 0x8475420 0x475420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_EN_CTL (at 0x7546)"
      tindex a:0xfc4cfa00 %l 0x8475460 0x475460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
      tindex a:0xfc4cfa00 %l 0x8475d00 0x475d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
      tindex a:0xfc4cfa00 %l 0x8475d80 0x475d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
      tindex a:0xfc4cfa00 %l 0x8475d90 0x475d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
      tindex a:0xfc4cfa00 %l 0x8475da0 0x475da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
      tindex a:0xfc4cfa00 %l 0x8475db0 0x475db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
      tindex a:0xfc4cfa00 %l 0x8475e00 0x475e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
      tindex a:0xfc4cfa00 %l 0x8475e10 0x475e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION1 (at 0x7600)"
      tindex a:0xfc4cfa00 %l 0x8476000 0x476000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION2 (at 0x7601)"
      tindex a:0xfc4cfa00 %l 0x8476010 0x476010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION3 (at 0x7602)"
      tindex a:0xfc4cfa00 %l 0x8476020 0x476020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_REVISION4 (at 0x7603)"
      tindex a:0xfc4cfa00 %l 0x8476030 0x476030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
      tindex a:0xfc4cfa00 %l 0x8476040 0x476040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
      tindex a:0xfc4cfa00 %l 0x8476050 0x476050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_STATUS0 (at 0x7608)"
      tindex a:0xfc4cfa00 %l 0x8476080 0x476080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
      tindex a:0xfc4cfa00 %l 0x8476100 0x476100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
      tindex a:0xfc4cfa00 %l 0x8476110 0x476110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
      tindex a:0xfc4cfa00 %l 0x8476120 0x476120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
      tindex a:0xfc4cfa00 %l 0x8476130 0x476130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
      tindex a:0xfc4cfa00 %l 0x8476140 0x476140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
      tindex a:0xfc4cfa00 %l 0x8476150 0x476150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
      tindex a:0xfc4cfa00 %l 0x8476160 0x476160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
      tindex a:0xfc4cfa00 %l 0x8476180 0x476180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
      tindex a:0xfc4cfa00 %l 0x8476190 0x476190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
      tindex a:0xfc4cfa00 %l 0x84761a0 0x4761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
      tindex a:0xfc4cfa00 %l 0x84761b0 0x4761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
      tindex a:0xfc4cfa00 %l 0x8476400 0x476400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
      tindex a:0xfc4cfa00 %l 0x8476420 0x476420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_EN_CTL (at 0x7646)"
      tindex a:0xfc4cfa00 %l 0x8476460 0x476460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
      tindex a:0xfc4cfa00 %l 0x8476d00 0x476d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
      tindex a:0xfc4cfa00 %l 0x8476d80 0x476d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
      tindex a:0xfc4cfa00 %l 0x8476d90 0x476d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
      tindex a:0xfc4cfa00 %l 0x8476da0 0x476da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
      tindex a:0xfc4cfa00 %l 0x8476db0 0x476db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
      tindex a:0xfc4cfa00 %l 0x8476e00 0x476e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
      tindex a:0xfc4cfa00 %l 0x8476e10 0x476e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION1 (at 0x7700)"
      tindex a:0xfc4cfa00 %l 0x8477000 0x477000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION2 (at 0x7701)"
      tindex a:0xfc4cfa00 %l 0x8477010 0x477010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION3 (at 0x7702)"
      tindex a:0xfc4cfa00 %l 0x8477020 0x477020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_REVISION4 (at 0x7703)"
      tindex a:0xfc4cfa00 %l 0x8477030 0x477030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
      tindex a:0xfc4cfa00 %l 0x8477040 0x477040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
      tindex a:0xfc4cfa00 %l 0x8477050 0x477050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_STATUS0 (at 0x7708)"
      tindex a:0xfc4cfa00 %l 0x8477080 0x477080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
      tindex a:0xfc4cfa00 %l 0x8477100 0x477100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
      tindex a:0xfc4cfa00 %l 0x8477110 0x477110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
      tindex a:0xfc4cfa00 %l 0x8477120 0x477120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
      tindex a:0xfc4cfa00 %l 0x8477130 0x477130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
      tindex a:0xfc4cfa00 %l 0x8477140 0x477140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
      tindex a:0xfc4cfa00 %l 0x8477150 0x477150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
      tindex a:0xfc4cfa00 %l 0x8477160 0x477160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
      tindex a:0xfc4cfa00 %l 0x8477180 0x477180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
      tindex a:0xfc4cfa00 %l 0x8477190 0x477190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
      tindex a:0xfc4cfa00 %l 0x84771a0 0x4771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
      tindex a:0xfc4cfa00 %l 0x84771b0 0x4771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
      tindex a:0xfc4cfa00 %l 0x8477400 0x477400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
      tindex a:0xfc4cfa00 %l 0x8477420 0x477420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_EN_CTL (at 0x7746)"
      tindex a:0xfc4cfa00 %l 0x8477460 0x477460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
      tindex a:0xfc4cfa00 %l 0x8477d00 0x477d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
      tindex a:0xfc4cfa00 %l 0x8477d80 0x477d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
      tindex a:0xfc4cfa00 %l 0x8477d90 0x477d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
      tindex a:0xfc4cfa00 %l 0x8477da0 0x477da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
      tindex a:0xfc4cfa00 %l 0x8477db0 0x477db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
      tindex a:0xfc4cfa00 %l 0x8477e00 0x477e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
      tindex a:0xfc4cfa00 %l 0x8477e10 0x477e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION1 (at 0x7800)"
      tindex a:0xfc4cfa00 %l 0x8478000 0x478000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION2 (at 0x7801)"
      tindex a:0xfc4cfa00 %l 0x8478010 0x478010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION3 (at 0x7802)"
      tindex a:0xfc4cfa00 %l 0x8478020 0x478020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_REVISION4 (at 0x7803)"
      tindex a:0xfc4cfa00 %l 0x8478030 0x478030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
      tindex a:0xfc4cfa00 %l 0x8478040 0x478040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
      tindex a:0xfc4cfa00 %l 0x8478050 0x478050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_STATUS0 (at 0x7808)"
      tindex a:0xfc4cfa00 %l 0x8478080 0x478080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
      tindex a:0xfc4cfa00 %l 0x8478100 0x478100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
      tindex a:0xfc4cfa00 %l 0x8478110 0x478110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
      tindex a:0xfc4cfa00 %l 0x8478120 0x478120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
      tindex a:0xfc4cfa00 %l 0x8478130 0x478130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
      tindex a:0xfc4cfa00 %l 0x8478140 0x478140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
      tindex a:0xfc4cfa00 %l 0x8478150 0x478150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
      tindex a:0xfc4cfa00 %l 0x8478160 0x478160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
      tindex a:0xfc4cfa00 %l 0x8478180 0x478180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
      tindex a:0xfc4cfa00 %l 0x8478190 0x478190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
      tindex a:0xfc4cfa00 %l 0x84781a0 0x4781a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
      tindex a:0xfc4cfa00 %l 0x84781b0 0x4781b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
      tindex a:0xfc4cfa00 %l 0x8478400 0x478400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
      tindex a:0xfc4cfa00 %l 0x8478420 0x478420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_EN_CTL (at 0x7846)"
      tindex a:0xfc4cfa00 %l 0x8478460 0x478460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
      tindex a:0xfc4cfa00 %l 0x8478d00 0x478d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
      tindex a:0xfc4cfa00 %l 0x8478d80 0x478d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
      tindex a:0xfc4cfa00 %l 0x8478d90 0x478d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
      tindex a:0xfc4cfa00 %l 0x8478da0 0x478da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
      tindex a:0xfc4cfa00 %l 0x8478db0 0x478db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
      tindex a:0xfc4cfa00 %l 0x8478e00 0x478e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
      tindex a:0xfc4cfa00 %l 0x8478e10 0x478e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION1 (at 0x7000)"
      tindex a:0xfc4cfa00 %l 0x8470000 0x470000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION2 (at 0x7001)"
      tindex a:0xfc4cfa00 %l 0x8470010 0x470010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION3 (at 0x7002)"
      tindex a:0xfc4cfa00 %l 0x8470020 0x470020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_REVISION4 (at 0x7003)"
      tindex a:0xfc4cfa00 %l 0x8470030 0x470030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_TYPE (at 0x7004)"
      tindex a:0xfc4cfa00 %l 0x8470040 0x470040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
      tindex a:0xfc4cfa00 %l 0x8470050 0x470050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
      tindex a:0xfc4cfa00 %l 0x8470080 0x470080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
      tindex a:0xfc4cfa00 %l 0x84700a0 0x4700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
      tindex a:0xfc4cfa00 %l 0x84700b0 0x4700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
      tindex a:0xfc4cfa00 %l 0x84700c0 0x4700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
      tindex a:0xfc4cfa00 %l 0x84700d0 0x4700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
      tindex a:0xfc4cfa00 %l 0x84700e0 0x4700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
      tindex a:0xfc4cfa00 %l 0x84700f0 0x4700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
      tindex a:0xfc4cfa00 %l 0x8470400 0x470400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0, 1"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
      tindex a:0xfc4cfa00 %l 0x8470410 0x470410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0, 1"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
      tindex a:0xfc4cfa00 %l 0x8470420 0x470420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
      tindex a:0xfc4cfa00 %l 0x8470430 0x470430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
      tindex a:0xfc4cfa00 %l 0x8470480 0x470480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
      tindex a:0xfc4cfa00 %l 0x8470490 0x470490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
      tindex a:0xfc4cfa00 %l 0x84704a0 0x4704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
      tindex a:0xfc4cfa00 %l 0x84704b0 0x4704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
      tindex a:0xfc4cfa00 %l 0x84704c0 0x4704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
      tindex a:0xfc4cfa00 %l 0x84704d0 0x4704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
      tindex a:0xfc4cfa00 %l 0x84704e0 0x4704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
      tindex a:0xfc4cfa00 %l 0x84704f0 0x4704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
      tindex a:0xfc4cfa00 %l 0x8470500 0x470500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
      tindex a:0xfc4cfa00 %l 0x8470510 0x470510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
      tindex a:0xfc4cfa00 %l 0x8470540 0x470540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
      tindex a:0xfc4cfa00 %l 0x8470550 0x470550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
      tindex a:0xfc4cfa00 %l 0x8470580 0x470580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
      tindex a:0xfc4cfa00 %l 0x8470590 0x470590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
      tindex a:0xfc4cfa00 %l 0x84705c0 0x4705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
      tindex a:0xfc4cfa00 %l 0x84705d0 0x4705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
      tindex a:0xfc4cfa00 %l 0x8470600 0x470600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
      tindex a:0xfc4cfa00 %l 0x8470610 0x470610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
      tindex a:0xfc4cfa00 %l 0x8470640 0x470640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
      tindex a:0xfc4cfa00 %l 0x8470650 0x470650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
      tindex a:0xfc4cfa00 %l 0x8470680 0x470680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
      tindex a:0xfc4cfa00 %l 0x8470690 0x470690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
      tindex a:0xfc4cfa00 %l 0x84706c0 0x4706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
      tindex a:0xfc4cfa00 %l 0x84706d0 0x4706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
      tindex a:0xfc4cfa00 %l 0x8470700 0x470700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
      tindex a:0xfc4cfa00 %l 0x8470710 0x470710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
      tindex a:0xfc4cfa00 %l 0x8470740 0x470740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
      tindex a:0xfc4cfa00 %l 0x8470750 0x470750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
      tindex a:0xfc4cfa00 %l 0x8470780 0x470780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
      tindex a:0xfc4cfa00 %l 0x8470790 0x470790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
      tindex a:0xfc4cfa00 %l 0x84707c0 0x4707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
      tindex a:0xfc4cfa00 %l 0x84707d0 0x4707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
      tindex a:0xfc4cfa00 %l 0x8470800 0x470800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
      tindex a:0xfc4cfa00 %l 0x8470810 0x470810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
      tindex a:0xfc4cfa00 %l 0x8470840 0x470840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
      tindex a:0xfc4cfa00 %l 0x8470850 0x470850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
      tindex a:0xfc4cfa00 %l 0x8470880 0x470880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
      tindex a:0xfc4cfa00 %l 0x8470890 0x470890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
      tindex a:0xfc4cfa00 %l 0x84708c0 0x4708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
      tindex a:0xfc4cfa00 %l 0x84708d0 0x4708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
      tindex a:0xfc4cfa00 %l 0x8470900 0x470900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
      tindex a:0xfc4cfa00 %l 0x8470910 0x470910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
      tindex a:0xfc4cfa00 %l 0x8470920 0x470920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
      tindex a:0xfc4cfa00 %l 0x8470930 0x470930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
      tindex a:0xfc4cfa00 %l 0x8470940 0x470940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
      tindex a:0xfc4cfa00 %l 0x8470950 0x470950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
      tindex a:0xfc4cfa00 %l 0x8470960 0x470960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
      tindex a:0xfc4cfa00 %l 0x8470970 0x470970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEC_ACCESS (at 0x70d0)"
      tindex a:0xfc4cfa00 %l 0x8470d00 0x470d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_RESET_CTL1 (at 0x70d8)"
      tindex a:0xfc4cfa00 %l 0x8470d80 0x470d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
      tindex a:0xfc4cfa00 %l 0x8470d90 0x470d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
      tindex a:0xfc4cfa00 %l 0x8470da0 0x470da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
      tindex a:0xfc4cfa00 %l 0x8470db0 0x470db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
      tindex a:0xfc4cfa00 %l 0x8470e00 0x470e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
      tindex a:0xfc4cfa00 %l 0x8470e10 0x470e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_OTP_CFG1 (at 0x70e2)"
      tindex a:0xfc4cfa00 %l 0x8470e20 0x470e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_OTP_CFG2 (at 0x70e3)"
      tindex a:0xfc4cfa00 %l 0x8470e30 0x470e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PBS_CORE_TEST1 (at 0x70e4)"
      tindex a:0xfc4cfa00 %l 0x8470e40 0x470e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION1 (at 0x800)"
      tindex a:0xfc4cfa00 %l 0x8408000 0x408000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION2 (at 0x801)"
      tindex a:0xfc4cfa00 %l 0x8408010 0x408010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION3 (at 0x802)"
      tindex a:0xfc4cfa00 %l 0x8408020 0x408020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_REVISION4 (at 0x803)"
      tindex a:0xfc4cfa00 %l 0x8408030 0x408030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_TYPE (at 0x804)"
      tindex a:0xfc4cfa00 %l 0x8408040 0x408040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_SUBTYPE (at 0x805)"
      tindex a:0xfc4cfa00 %l 0x8408050 0x408050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_PBL_STATUS (at 0x807)"
      tindex a:0xfc4cfa00 %l 0x8408070 0x408070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REG_WRITE_ERROR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_RESET_ERROR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REG_SYNC_ERROR                           = " "0, 1"
    tree.end
    tree "PON_PON_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_REASON1 (at 0x808)"
      tindex a:0xfc4cfa00 %l 0x8408080 0x408080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0, 1"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_WARM_RESET_REASON1 (at 0x80a)"
      tindex a:0xfc4cfa00 %l 0x84080a0 0x4080a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0, 1"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_WARM_RESET_REASON2 (at 0x80b)"
      tindex a:0xfc4cfa00 %l 0x84080b0 0x4080b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0, 1"
    tree.end
    tree "PON_POFF_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_POFF_REASON1 (at 0x80c)"
      tindex a:0xfc4cfa00 %l 0x84080c0 0x4080c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0, 1"
    tree.end
    tree "PON_POFF_REASON2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_POFF_REASON2 (at 0x80d)"
      tindex a:0xfc4cfa00 %l 0x84080d0 0x4080d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0, 1"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SOFT_RESET_REASON1 (at 0x80e)"
      tindex a:0xfc4cfa00 %l 0x84080e0 0x4080e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0, 1"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SOFT_RESET_REASON2 (at 0x80f)"
      tindex a:0xfc4cfa00 %l 0x84080f0 0x4080f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0, 1"
    tree.end
    tree "PON_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_RT_STS (at 0x810)"
      tindex a:0xfc4cfa00 %l 0x8408100 0x408100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_SET_TYPE (at 0x811)"
      tindex a:0xfc4cfa00 %l 0x8408110 0x408110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_POLARITY_HIGH (at 0x812)"
      tindex a:0xfc4cfa00 %l 0x8408120 0x408120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_POLARITY_LOW (at 0x813)"
      tindex a:0xfc4cfa00 %l 0x8408130 0x408130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_LATCHED_CLR (at 0x814)"
      tindex a:0xfc4cfa00 %l 0x8408140 0x408140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_EN_SET (at 0x815)"
      tindex a:0xfc4cfa00 %l 0x8408150 0x408150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_EN_CLR (at 0x816)"
      tindex a:0xfc4cfa00 %l 0x8408160 0x408160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_LATCHED_STS (at 0x818)"
      tindex a:0xfc4cfa00 %l 0x8408180 0x408180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_PENDING_STS (at 0x819)"
      tindex a:0xfc4cfa00 %l 0x8408190 0x408190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_MID_SEL (at 0x81a)"
      tindex a:0xfc4cfa00 %l 0x84081a0 0x4081a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PON_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_PRIORITY (at 0x81b)"
      tindex a:0xfc4cfa00 %l 0x84081b0 0x4081b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
      tindex a:0xfc4cfa00 %l 0x8408400 0x408400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
      tindex a:0xfc4cfa00 %l 0x8408410 0x408410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
      tindex a:0xfc4cfa00 %l 0x8408420 0x408420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
      tindex a:0xfc4cfa00 %l 0x8408440 0x408440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
      tindex a:0xfc4cfa00 %l 0x8408450 0x408450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
      tindex a:0xfc4cfa00 %l 0x8408460 0x408460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
      tindex a:0xfc4cfa00 %l 0x8408480 0x408480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
      tindex a:0xfc4cfa00 %l 0x8408490 0x408490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
      tindex a:0xfc4cfa00 %l 0x84084a0 0x4084a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP2_RESET_S1_TIMER (at 0x84c)"
      tindex a:0xfc4cfa00 %l 0x84084c0 0x4084c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP2_RESET_S2_TIMER (at 0x84d)"
      tindex a:0xfc4cfa00 %l 0x84084d0 0x4084d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP2_RESET_S2_CTL (at 0x84e)"
      tindex a:0xfc4cfa00 %l 0x84084e0 0x4084e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP1_RESET_S1_TIMER (at 0x850)"
      tindex a:0xfc4cfa00 %l 0x8408500 0x408500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP1_RESET_S2_TIMER (at 0x851)"
      tindex a:0xfc4cfa00 %l 0x8408510 0x408510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_GP1_RESET_S2_CTL (at 0x852)"
      tindex a:0xfc4cfa00 %l 0x8408520 0x408520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
      tindex a:0xfc4cfa00 %l 0x8408540 0x408540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
      tindex a:0xfc4cfa00 %l 0x8408550 0x408550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
      tindex a:0xfc4cfa00 %l 0x8408560 0x408560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PMIC_WD_RESET_PET (at 0x857)"
      tindex a:0xfc4cfa00 %l 0x8408570 0x408570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0, 1"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PS_HOLD_RESET_CTL (at 0x85a)"
      tindex a:0xfc4cfa00 %l 0x84085a0 0x4085a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SW_RESET_S2_CTL (at 0x862)"
      tindex a:0xfc4cfa00 %l 0x8408620 0x408620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_GO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SW_RESET_GO (at 0x863)"
      tindex a:0xfc4cfa00 %l 0x8408630 0x408630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_OVERTEMP_RESET_CTL (at 0x866)"
      tindex a:0xfc4cfa00 %l 0x8408660 0x408660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TFT_RESET_CTL (at 0x86a)"
      tindex a:0xfc4cfa00 %l 0x84086a0 0x4086a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PULL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PULL_CTL (at 0x870)"
      tindex a:0xfc4cfa00 %l 0x8408700 0x408700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0, 1"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_DEBOUNCE_CTL (at 0x871)"
      tindex a:0xfc4cfa00 %l 0x8408710 0x408710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_RESET_S3_SRC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESET_S3_SRC (at 0x874)"
      tindex a:0xfc4cfa00 %l 0x8408740 0x408740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_RESET_S3_TIMER"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_RESET_S3_TIMER (at 0x875)"
      tindex a:0xfc4cfa00 %l 0x8408750 0x408750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_TRIGGER_EN (at 0x880)"
      tindex a:0xfc4cfa00 %l 0x8408800 0x408800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0, 1"
    tree.end
    tree "PON_OPTION_BITS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_OPTION_BITS (at 0x882)"
      tindex a:0xfc4cfa00 %l 0x8408820 0x408820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLOCK_32K_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBG_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_PWR_EN                               = " "0, 1"
    tree.end
    tree "PON_UVLO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_UVLO (at 0x888)"
      tindex a:0xfc4cfa00 %l 0x8408880 0x408880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_AVDD_VPH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_AVDD_VPH (at 0x88a)"
      tindex a:0xfc4cfa00 %l 0x84088a0 0x4088a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_HPM_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0, 1"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RB_SPARE (at 0x88c)"
      tindex a:0xfc4cfa00 %l 0x84088c0 0x4088c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_DVDD_RB_SPARE (at 0x88d)"
      tindex a:0xfc4cfa00 %l 0x84088d0 0x4088d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_XVDD_RB_SPARE (at 0x88e)"
      tindex a:0xfc4cfa00 %l 0x84088e0 0x4088e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SOFT_RB_SPARE (at 0x88f)"
      tindex a:0xfc4cfa00 %l 0x84088f0 0x4088f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON1_INTERFACE (at 0x890)"
      tindex a:0xfc4cfa00 %l 0x8408900 0x408900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0, 1"
    tree.end
    tree "PON_PBS_INTERFACE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PBS_INTERFACE (at 0x891)"
      tindex a:0xfc4cfa00 %l 0x8408910 0x408910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0, 1"
    tree.end
    tree "PON_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_SEC_ACCESS (at 0x8d0)"
      tindex a:0xfc4cfa00 %l 0x8408d00 0x408d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RESET_CTL2 (at 0x8d9)"
      tindex a:0xfc4cfa00 %l 0x8408d90 0x408d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RESET_CTL3 (at 0x8da)"
      tindex a:0xfc4cfa00 %l 0x8408da0 0x408da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PERPH_RESET_CTL4 (at 0x8db)"
      tindex a:0xfc4cfa00 %l 0x8408db0 0x408db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PON_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_TEST1 (at 0x8e0)"
      tindex a:0xfc4cfa00 %l 0x8408e00 0x408e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PON_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_INT_TEST_VAL (at 0x8e1)"
      tindex a:0xfc4cfa00 %l 0x8408e10 0x408e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST1 (at 0x8e2)"
      tindex a:0xfc4cfa00 %l 0x8408e20 0x408e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST2 (at 0x8e3)"
      tindex a:0xfc4cfa00 %l 0x8408e30 0x408e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_EN                                 = "
    tree.end
    tree "PON_TEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST3 (at 0x8e4)"
      tindex a:0xfc4cfa00 %l 0x8408e40 0x408e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEL_FSM                                  = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON_WARM_REASON_CLEAR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USE_MSME_FOR_DVDD                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST4 (at 0x8e5)"
      tindex a:0xfc4cfa00 %l 0x8408e50 0x408e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   FSM_STATE                                = "
    tree.end
    tree "PON_TEST5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TEST5 (at 0x8e6)"
      tindex a:0xfc4cfa00 %l 0x8408e60 0x408e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MASK_XVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_VMAX_SEL (at 0x8e7)"
      tindex a:0xfc4cfa00 %l 0x8408e70 0x408e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_TRIM_NUM (at 0x8f0)"
      tindex a:0xfc4cfa00 %l 0x8408f00 0x408f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_TRIM (at 0x8f1)"
      tindex a:0xfc4cfa00 %l 0x8408f10 0x408f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "PON_PON_CNTL_2_TRIM (at 0x8f2)"
      tindex a:0xfc4cfa00 %l 0x8408f20 0x408f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION1 (at 0x100)"
      tindex a:0xfc4cfa00 %l 0x8401000 0x401000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION2 (at 0x101)"
      tindex a:0xfc4cfa00 %l 0x8401010 0x401010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION3 (at 0x102)"
      tindex a:0xfc4cfa00 %l 0x8401020 0x401020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_REVISION4 (at 0x103)"
      tindex a:0xfc4cfa00 %l 0x8401030 0x401030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_PERPH_TYPE (at 0x104)"
      tindex a:0xfc4cfa00 %l 0x8401040 0x401040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_PERPH_SUBTYPE (at 0x105)"
      tindex a:0xfc4cfa00 %l 0x8401050 0x401050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_STATUS1 (at 0x108)"
      tindex a:0xfc4cfa00 %l 0x8401080 0x401080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OP4                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OP3                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OP2                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OP1                                      = " "0, 1, 2, 3"
    tree.end
    tree "REVID_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_SEC_ACCESS (at 0x1d0)"
      tindex a:0xfc4cfa00 %l 0x8401d00 0x401d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "REVID_TEST1 (at 0x1e0)"
      tindex a:0xfc4cfa00 %l 0x8401e00 0x401e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION1 (at 0x11400)"
      tindex a:0xfc4cfa00 %l 0x8514000 0x514000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION2 (at 0x11401)"
      tindex a:0xfc4cfa00 %l 0x8514010 0x514010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION3 (at 0x11402)"
      tindex a:0xfc4cfa00 %l 0x8514020 0x514020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_REVISION4 (at 0x11403)"
      tindex a:0xfc4cfa00 %l 0x8514030 0x514030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_TYPE (at 0x11404)"
      tindex a:0xfc4cfa00 %l 0x8514040 0x514040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
      tindex a:0xfc4cfa00 %l 0x8514050 0x514050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_STATUS (at 0x11408)"
      tindex a:0xfc4cfa00 %l 0x8514080 0x514080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_RT_STS (at 0x11410)"
      tindex a:0xfc4cfa00 %l 0x8514100 0x514100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_SET_TYPE (at 0x11411)"
      tindex a:0xfc4cfa00 %l 0x8514110 0x514110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
      tindex a:0xfc4cfa00 %l 0x8514120 0x514120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
      tindex a:0xfc4cfa00 %l 0x8514130 0x514130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
      tindex a:0xfc4cfa00 %l 0x8514140 0x514140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_EN_SET (at 0x11415)"
      tindex a:0xfc4cfa00 %l 0x8514150 0x514150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_EN_CLR (at 0x11416)"
      tindex a:0xfc4cfa00 %l 0x8514160 0x514160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
      tindex a:0xfc4cfa00 %l 0x8514180 0x514180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_PENDING_STS (at 0x11419)"
      tindex a:0xfc4cfa00 %l 0x8514190 0x514190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_MID_SEL (at 0x1141a)"
      tindex a:0xfc4cfa00 %l 0x85141a0 0x5141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_PRIORITY (at 0x1141b)"
      tindex a:0xfc4cfa00 %l 0x85141b0 0x5141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_VOLTAGE_CTL1 (at 0x11440)"
      tindex a:0xfc4cfa00 %l 0x8514400 0x514400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
      tindex a:0xfc4cfa00 %l 0x8514410 0x514410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_PFM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PFM_CTL (at 0x11444)"
      tindex a:0xfc4cfa00 %l 0x8514440 0x514440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_MODE_CTL (at 0x11445)"
      tindex a:0xfc4cfa00 %l 0x8514450 0x514450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S1_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_EN_CTL (at 0x11446)"
      tindex a:0xfc4cfa00 %l 0x8514460 0x514460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S1_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PD_CTL (at 0x11448)"
      tindex a:0xfc4cfa00 %l 0x8514480 0x514480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_COMP_CAP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_COMP_CAP_CTL (at 0x11451)"
      tindex a:0xfc4cfa00 %l 0x8514510 0x514510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_GM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_GM_CTL (at 0x11452)"
      tindex a:0xfc4cfa00 %l 0x8514520 0x514520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S1_CTRL_RZ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_RZ_CTL (at 0x11453)"
      tindex a:0xfc4cfa00 %l 0x8514530 0x514530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S1_CTRL_ISNS_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_ISNS_CTRL (at 0x11455)"
      tindex a:0xfc4cfa00 %l 0x8514550 0x514550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0, 1"
    tree.end
    tree "S1_CTRL_SAW_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_SAW_CTL (at 0x11456)"
      tindex a:0xfc4cfa00 %l 0x8514560 0x514560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CURRENT_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   NSAW_CTRL                                = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_DMAX_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_DMAX_CTL (at 0x11458)"
      tindex a:0xfc4cfa00 %l 0x8514580 0x514580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0, 1"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PULSE_SKIP_CTL (at 0x11459)"
      tindex a:0xfc4cfa00 %l 0x8514590 0x514590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0, 1"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_THRES"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PULSE_SKIP_THRES (at 0x1145a)"
      tindex a:0xfc4cfa00 %l 0x85145a0 0x5145a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_AUTO_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_AUTO_MODE_CTL (at 0x1145b)"
      tindex a:0xfc4cfa00 %l 0x85145b0 0x5145b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_INZERO_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INZERO_COUNT_CTL (at 0x1145c)"
      tindex a:0xfc4cfa00 %l 0x85145c0 0x5145c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PFM_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PFM_COUNT_CTL (at 0x1145d)"
      tindex a:0xfc4cfa00 %l 0x85145d0 0x5145d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PS_VGA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PS_VGA_CTL (at 0x1145e)"
      tindex a:0xfc4cfa00 %l 0x85145e0 0x5145e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
      tindex a:0xfc4cfa00 %l 0x8514600 0x514600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
      tindex a:0xfc4cfa00 %l 0x8514610 0x514610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_FT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_FT_CTL (at 0x11462)"
      tindex a:0xfc4cfa00 %l 0x8514620 0x514620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_QMODE_SHADOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_QMODE_SHADOW (at 0x11463)"
      tindex a:0xfc4cfa00 %l 0x8514630 0x514630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S1_CTRL_UL_LL_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_UL_LL_CTRL (at 0x11468)"
      tindex a:0xfc4cfa00 %l 0x8514680 0x514680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UL_INT_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LL_INT_EN                                = " "0, 1"
    tree.end
    tree "S1_CTRL_UL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_UL_VOLTAGE (at 0x11469)"
      tindex a:0xfc4cfa00 %l 0x8514690 0x514690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_LL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_LL_VOLTAGE (at 0x1146b)"
      tindex a:0xfc4cfa00 %l 0x85146b0 0x5146b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_UL_RANGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_UL_RANGE (at 0x1146d)"
      tindex a:0xfc4cfa00 %l 0x85146d0 0x5146d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_LL_RANGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_LL_RANGE (at 0x1146e)"
      tindex a:0xfc4cfa00 %l 0x85146e0 0x5146e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_CTLR_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTLR_MISC (at 0x1147a)"
      tindex a:0xfc4cfa00 %l 0x85147a0 0x5147a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_SEC_ACCESS (at 0x114d0)"
      tindex a:0xfc4cfa00 %l 0x8514d00 0x514d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
      tindex a:0xfc4cfa00 %l 0x8514d80 0x514d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
      tindex a:0xfc4cfa00 %l 0x8514d90 0x514d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
      tindex a:0xfc4cfa00 %l 0x8514da0 0x514da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
      tindex a:0xfc4cfa00 %l 0x8514db0 0x514db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_TEST1 (at 0x114e0)"
      tindex a:0xfc4cfa00 %l 0x8514e00 0x514e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
      tindex a:0xfc4cfa00 %l 0x8514e10 0x514e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S1_CTRL_CTLR_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTLR_TEST (at 0x114e2)"
      tindex a:0xfc4cfa00 %l 0x8514e20 0x514e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_TRIM_NUM (at 0x114f0)"
      tindex a:0xfc4cfa00 %l 0x8514f00 0x514f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM1 (at 0x114f1)"
      tindex a:0xfc4cfa00 %l 0x8514f10 0x514f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S1_CTRL_CTL_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM2 (at 0x114f2)"
      tindex a:0xfc4cfa00 %l 0x8514f20 0x514f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S1_CTRL_CTL_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM3 (at 0x114f3)"
      tindex a:0xfc4cfa00 %l 0x8514f30 0x514f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S1_CTRL_CTL_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_CTRL_CTL_TRIM4 (at 0x114f4)"
      tindex a:0xfc4cfa00 %l 0x8514f40 0x514f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0, 1"
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_REVISION1 (at 0x11600)"
      tindex a:0xfc4cfa00 %l 0x8516000 0x516000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_REVISION2 (at 0x11601)"
      tindex a:0xfc4cfa00 %l 0x8516010 0x516010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_REVISION3 (at 0x11602)"
      tindex a:0xfc4cfa00 %l 0x8516020 0x516020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_REVISION4 (at 0x11603)"
      tindex a:0xfc4cfa00 %l 0x8516030 0x516030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_TYPE (at 0x11604)"
      tindex a:0xfc4cfa00 %l 0x8516040 0x516040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
      tindex a:0xfc4cfa00 %l 0x8516050 0x516050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_CLK_ENABLE (at 0x11646)"
      tindex a:0xfc4cfa00 %l 0x8516460 0x516460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_CLK_DIV (at 0x11650)"
      tindex a:0xfc4cfa00 %l 0x8516500 0x516500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_CLK_PHASE (at 0x11651)"
      tindex a:0xfc4cfa00 %l 0x8516510 0x516510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_GANG_CTL1 (at 0x116c0)"
      tindex a:0xfc4cfa00 %l 0x8516c00 0x516c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_GANG_CTL2 (at 0x116c1)"
      tindex a:0xfc4cfa00 %l 0x8516c10 0x516c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_SEC_ACCESS (at 0x116d0)"
      tindex a:0xfc4cfa00 %l 0x8516d00 0x516d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
      tindex a:0xfc4cfa00 %l 0x8516d90 0x516d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
      tindex a:0xfc4cfa00 %l 0x8516da0 0x516da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
      tindex a:0xfc4cfa00 %l 0x8516db0 0x516db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_FREQ_TEST1 (at 0x116e2)"
      tindex a:0xfc4cfa00 %l 0x8516e20 0x516e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION1 (at 0x11500)"
      tindex a:0xfc4cfa00 %l 0x8515000 0x515000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION2 (at 0x11501)"
      tindex a:0xfc4cfa00 %l 0x8515010 0x515010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION3 (at 0x11502)"
      tindex a:0xfc4cfa00 %l 0x8515020 0x515020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_REVISION4 (at 0x11503)"
      tindex a:0xfc4cfa00 %l 0x8515030 0x515030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_TYPE (at 0x11504)"
      tindex a:0xfc4cfa00 %l 0x8515040 0x515040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_SUBTYPE (at 0x11505)"
      tindex a:0xfc4cfa00 %l 0x8515050 0x515050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PWM_CURRENT_LIM_CTL (at 0x1154a)"
      tindex a:0xfc4cfa00 %l 0x85154a0 0x5154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PFM_CURRENT_LIM_CTL (at 0x1154b)"
      tindex a:0xfc4cfa00 %l 0x85154b0 0x5154b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_PS_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_SOFT_START_CTL (at 0x1154c)"
      tindex a:0xfc4cfa00 %l 0x85154c0 0x5154c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0, 1"
    tree.end
    tree "S1_PS_SWITCH_SIZE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_SWITCH_SIZE_CTL (at 0x11570)"
      tindex a:0xfc4cfa00 %l 0x8515700 0x515700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   P_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   N_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   P_DRIVER_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_DRIVER_SIZE                            = " "0, 1"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_DEAD_TIME_CTRL1 (at 0x11571)"
      tindex a:0xfc4cfa00 %l 0x8515710 0x515710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0, 1"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_DEAD_TIME_CTRL2 (at 0x11572)"
      tindex a:0xfc4cfa00 %l 0x8515720 0x515720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_BLNK_TIME_CTL (at 0x11573)"
      tindex a:0xfc4cfa00 %l 0x8515730 0x515730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0, 1"
    tree.end
    tree "S1_PS_INZERO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_INZERO_CTL (at 0x11574)"
      tindex a:0xfc4cfa00 %l 0x8515740 0x515740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0, 1"
    tree.end
    tree "S1_PS_DIG_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_DIG_FSM_CTL (at 0x11575)"
      tindex a:0xfc4cfa00 %l 0x8515750 0x515750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0, 1"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PWR_STG_MISC (at 0x11579)"
      tindex a:0xfc4cfa00 %l 0x8515790 0x515790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0, 1"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_SEC_ACCESS (at 0x115d0)"
      tindex a:0xfc4cfa00 %l 0x8515d00 0x515d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_RESET_CTL1 (at 0x115d8)"
      tindex a:0xfc4cfa00 %l 0x8515d80 0x515d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
      tindex a:0xfc4cfa00 %l 0x8515d90 0x515d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
      tindex a:0xfc4cfa00 %l 0x8515da0 0x515da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
      tindex a:0xfc4cfa00 %l 0x8515db0 0x515db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_PS_FORCE_FET_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_FORCE_FET_TEST (at 0x115e3)"
      tindex a:0xfc4cfa00 %l 0x8515e30 0x515e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0, 1, 2, 3"
    tree.end
    tree "S1_PS_PWR_STG_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PWR_STG_TEST (at 0x115e4)"
      tindex a:0xfc4cfa00 %l 0x8515e40 0x515e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S1_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_TRIM_NUM (at 0x115f0)"
      tindex a:0xfc4cfa00 %l 0x8515f00 0x515f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PS_TRIM1 (at 0x115f1)"
      tindex a:0xfc4cfa00 %l 0x8515f10 0x515f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S1_PS_PS_TRIM2 (at 0x115f2)"
      tindex a:0xfc4cfa00 %l 0x8515f20 0x515f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION1 (at 0x11700)"
      tindex a:0xfc4cfa00 %l 0x8517000 0x517000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION2 (at 0x11701)"
      tindex a:0xfc4cfa00 %l 0x8517010 0x517010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION3 (at 0x11702)"
      tindex a:0xfc4cfa00 %l 0x8517020 0x517020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REVISION4 (at 0x11703)"
      tindex a:0xfc4cfa00 %l 0x8517030 0x517030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_TYPE (at 0x11704)"
      tindex a:0xfc4cfa00 %l 0x8517040 0x517040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
      tindex a:0xfc4cfa00 %l 0x8517050 0x517050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS_1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_STATUS_1 (at 0x11708)"
      tindex a:0xfc4cfa00 %l 0x8517080 0x517080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S2_CTRL_STATUS_2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_STATUS_2 (at 0x11709)"
      tindex a:0xfc4cfa00 %l 0x8517090 0x517090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S2_CTRL_STATUS_3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_STATUS_3 (at 0x1170a)"
      tindex a:0xfc4cfa00 %l 0x85170a0 0x5170a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S2_CTRL_STATUS_4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_STATUS_4 (at 0x1170b)"
      tindex a:0xfc4cfa00 %l 0x85170b0 0x5170b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_RT_STS (at 0x11710)"
      tindex a:0xfc4cfa00 %l 0x8517100 0x517100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_SET_TYPE (at 0x11711)"
      tindex a:0xfc4cfa00 %l 0x8517110 0x517110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
      tindex a:0xfc4cfa00 %l 0x8517120 0x517120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
      tindex a:0xfc4cfa00 %l 0x8517130 0x517130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
      tindex a:0xfc4cfa00 %l 0x8517140 0x517140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_EN_SET (at 0x11715)"
      tindex a:0xfc4cfa00 %l 0x8517150 0x517150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_EN_CLR (at 0x11716)"
      tindex a:0xfc4cfa00 %l 0x8517160 0x517160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
      tindex a:0xfc4cfa00 %l 0x8517180 0x517180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_PENDING_STS (at 0x11719)"
      tindex a:0xfc4cfa00 %l 0x8517190 0x517190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_MID_SEL (at 0x1171a)"
      tindex a:0xfc4cfa00 %l 0x85171a0 0x5171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_PRIORITY (at 0x1171b)"
      tindex a:0xfc4cfa00 %l 0x85171b0 0x5171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VOLTAGE_CTL1 (at 0x11740)"
      tindex a:0xfc4cfa00 %l 0x8517400 0x517400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
      tindex a:0xfc4cfa00 %l 0x8517410 0x517410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_CTRL_VSET_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VSET_VALID (at 0x11742)"
      tindex a:0xfc4cfa00 %l 0x8517420 0x517420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VOLTAGE_CTL3 (at 0x11744)"
      tindex a:0xfc4cfa00 %l 0x8517440 0x517440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_MODE_CTL (at 0x11745)"
      tindex a:0xfc4cfa00 %l 0x8517450 0x517450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S2_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_EN_CTL (at 0x11746)"
      tindex a:0xfc4cfa00 %l 0x8517460 0x517460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S2_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PD_CTL (at 0x11748)"
      tindex a:0xfc4cfa00 %l 0x8517480 0x517480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S2_CTRL_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_FREQ_CTL (at 0x11750)"
      tindex a:0xfc4cfa00 %l 0x8517500 0x517500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_CTRL_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_MULTIPHASE_CTL (at 0x11751)"
      tindex a:0xfc4cfa00 %l 0x8517510 0x517510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S2_CTRL_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PHASE_CTL (at 0x11752)"
      tindex a:0xfc4cfa00 %l 0x8517520 0x517520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PHASE_ID (at 0x11753)"
      tindex a:0xfc4cfa00 %l 0x8517530 0x517530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PHASE_CNT (at 0x11754)"
      tindex a:0xfc4cfa00 %l 0x8517540 0x517540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_SS_CTL (at 0x11760)"
      tindex a:0xfc4cfa00 %l 0x8517600 0x517600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VS_CTL (at 0x11761)"
      tindex a:0xfc4cfa00 %l 0x8517610 0x517610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CORR_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CORR_CFG (at 0x11762)"
      tindex a:0xfc4cfa00 %l 0x8517620 0x517620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S2_CTRL_RAMP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_RAMP_CFG (at 0x11763)"
      tindex a:0xfc4cfa00 %l 0x8517630 0x517630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_COMPENS_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_COMPENS_CFG (at 0x11764)"
      tindex a:0xfc4cfa00 %l 0x8517640 0x517640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_VREG_OK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_VREG_OK (at 0x11765)"
      tindex a:0xfc4cfa00 %l 0x8517650 0x517650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_VREG_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_VREG_FAULT (at 0x11766)"
      tindex a:0xfc4cfa00 %l 0x8517660 0x517660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_PFM_COMP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_PFM_COMP (at 0x11767)"
      tindex a:0xfc4cfa00 %l 0x8517670 0x517670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_UL_LL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_UL_LL_CTL (at 0x11768)"
      tindex a:0xfc4cfa00 %l 0x8517680 0x517680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S2_CTRL_VSET_ULS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VSET_ULS (at 0x11769)"
      tindex a:0xfc4cfa00 %l 0x8517690 0x517690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S2_CTRL_ULS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_ULS_VALID (at 0x1176a)"
      tindex a:0xfc4cfa00 %l 0x85176a0 0x5176a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S2_CTRL_VSET_LLS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_VSET_LLS (at 0x1176b)"
      tindex a:0xfc4cfa00 %l 0x85176b0 0x5176b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S2_CTRL_LLS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_LLS_VALID (at 0x1176c)"
      tindex a:0xfc4cfa00 %l 0x85176c0 0x5176c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S2_CTRL_GPL_HI"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_GPL_HI (at 0x1176d)"
      tindex a:0xfc4cfa00 %l 0x85176d0 0x5176d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S2_CTRL_GPL_LO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_GPL_LO (at 0x1176e)"
      tindex a:0xfc4cfa00 %l 0x85176e0 0x5176e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S2_CTRL_CFG_ATEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_ATEST1 (at 0x117b0)"
      tindex a:0xfc4cfa00 %l 0x8517b00 0x517b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_ATEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_ATEST2 (at 0x117b1)"
      tindex a:0xfc4cfa00 %l 0x8517b10 0x517b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_ATEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_ATEST3 (at 0x117b2)"
      tindex a:0xfc4cfa00 %l 0x8517b20 0x517b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_ATEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_ATEST4 (at 0x117b3)"
      tindex a:0xfc4cfa00 %l 0x8517b30 0x517b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_DTEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_DTEST1 (at 0x117b4)"
      tindex a:0xfc4cfa00 %l 0x8517b40 0x517b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_DTEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_DTEST2 (at 0x117b5)"
      tindex a:0xfc4cfa00 %l 0x8517b50 0x517b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_DTEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_DTEST3 (at 0x117b6)"
      tindex a:0xfc4cfa00 %l 0x8517b60 0x517b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_DTEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CFG_DTEST4 (at 0x117b7)"
      tindex a:0xfc4cfa00 %l 0x8517b70 0x517b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_GANG_CTL1 (at 0x117c0)"
      tindex a:0xfc4cfa00 %l 0x8517c00 0x517c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_CTRL_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_GANG_CTL2 (at 0x117c1)"
      tindex a:0xfc4cfa00 %l 0x8517c10 0x517c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_SEC_ACCESS (at 0x117d0)"
      tindex a:0xfc4cfa00 %l 0x8517d00 0x517d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
      tindex a:0xfc4cfa00 %l 0x8517d80 0x517d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
      tindex a:0xfc4cfa00 %l 0x8517d90 0x517d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
      tindex a:0xfc4cfa00 %l 0x8517da0 0x517da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
      tindex a:0xfc4cfa00 %l 0x8517db0 0x517db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_TEST1 (at 0x117e0)"
      tindex a:0xfc4cfa00 %l 0x8517e00 0x517e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
      tindex a:0xfc4cfa00 %l 0x8517e10 0x517e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S2_CTRL_MODE_FSM_MASK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_MODE_FSM_MASK (at 0x117e2)"
      tindex a:0xfc4cfa00 %l 0x8517e20 0x517e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S2_CTRL_GATE_DRV_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_GATE_DRV_MUX (at 0x117e3)"
      tindex a:0xfc4cfa00 %l 0x8517e30 0x517e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CORR_DUTY_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CORR_DUTY_MUX (at 0x117e4)"
      tindex a:0xfc4cfa00 %l 0x8517e40 0x517e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_EN_OPTIONS_DFT (at 0x117e5)"
      tindex a:0xfc4cfa00 %l 0x8517e50 0x517e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_CAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CAL_CTL (at 0x117e8)"
      tindex a:0xfc4cfa00 %l 0x8517e80 0x517e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S2_CTRL_IDAC_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_IDAC_CAL_VAL (at 0x117e9)"
      tindex a:0xfc4cfa00 %l 0x8517e90 0x517e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_CORR_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CORR_CAL_VAL (at 0x117ea)"
      tindex a:0xfc4cfa00 %l 0x8517ea0 0x517ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_PWM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PWM_CAL_VAL (at 0x117eb)"
      tindex a:0xfc4cfa00 %l 0x8517eb0 0x517eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_PFM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PFM_CAL_VAL (at 0x117ec)"
      tindex a:0xfc4cfa00 %l 0x8517ec0 0x517ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_MPHASE_IDAC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_MPHASE_IDAC (at 0x117ed)"
      tindex a:0xfc4cfa00 %l 0x8517ed0 0x517ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_TRIM_NUM (at 0x117f0)"
      tindex a:0xfc4cfa00 %l 0x8517f00 0x517f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_CAL_EN_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CAL_EN_TRIM (at 0x117f1)"
      tindex a:0xfc4cfa00 %l 0x8517f10 0x517f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S2_CTRL_REFDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_REFDAC_TRIM (at 0x117f2)"
      tindex a:0xfc4cfa00 %l 0x8517f20 0x517f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S2_CTRL_IDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_IDAC_TRIM (at 0x117f3)"
      tindex a:0xfc4cfa00 %l 0x8517f30 0x517f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S2_CTRL_CORR_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_CORR_TRIM (at 0x117f4)"
      tindex a:0xfc4cfa00 %l 0x8517f40 0x517f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S2_CTRL_PWM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PWM_TRIM (at 0x117f5)"
      tindex a:0xfc4cfa00 %l 0x8517f50 0x517f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S2_CTRL_PFM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_PFM_TRIM (at 0x117f6)"
      tindex a:0xfc4cfa00 %l 0x8517f60 0x517f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_RAMP_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_CTRL_RAMP_TRIM (at 0x117f7)"
      tindex a:0xfc4cfa00 %l 0x8517f70 0x517f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_REVISION1 (at 0x11900)"
      tindex a:0xfc4cfa00 %l 0x8519000 0x519000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_REVISION2 (at 0x11901)"
      tindex a:0xfc4cfa00 %l 0x8519010 0x519010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_REVISION3 (at 0x11902)"
      tindex a:0xfc4cfa00 %l 0x8519020 0x519020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_REVISION4 (at 0x11903)"
      tindex a:0xfc4cfa00 %l 0x8519030 0x519030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_TYPE (at 0x11904)"
      tindex a:0xfc4cfa00 %l 0x8519040 0x519040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
      tindex a:0xfc4cfa00 %l 0x8519050 0x519050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_CLK_ENABLE (at 0x11946)"
      tindex a:0xfc4cfa00 %l 0x8519460 0x519460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_CLK_DIV (at 0x11950)"
      tindex a:0xfc4cfa00 %l 0x8519500 0x519500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_CLK_PHASE (at 0x11951)"
      tindex a:0xfc4cfa00 %l 0x8519510 0x519510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_GANG_CTL1 (at 0x119c0)"
      tindex a:0xfc4cfa00 %l 0x8519c00 0x519c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_GANG_CTL2 (at 0x119c1)"
      tindex a:0xfc4cfa00 %l 0x8519c10 0x519c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_SEC_ACCESS (at 0x119d0)"
      tindex a:0xfc4cfa00 %l 0x8519d00 0x519d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
      tindex a:0xfc4cfa00 %l 0x8519d90 0x519d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
      tindex a:0xfc4cfa00 %l 0x8519da0 0x519da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
      tindex a:0xfc4cfa00 %l 0x8519db0 0x519db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_FREQ_TEST1 (at 0x119e2)"
      tindex a:0xfc4cfa00 %l 0x8519e20 0x519e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION1 (at 0x11800)"
      tindex a:0xfc4cfa00 %l 0x8518000 0x518000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION2 (at 0x11801)"
      tindex a:0xfc4cfa00 %l 0x8518010 0x518010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION3 (at 0x11802)"
      tindex a:0xfc4cfa00 %l 0x8518020 0x518020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_REVISION4 (at 0x11803)"
      tindex a:0xfc4cfa00 %l 0x8518030 0x518030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_TYPE (at 0x11804)"
      tindex a:0xfc4cfa00 %l 0x8518040 0x518040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_SUBTYPE (at 0x11805)"
      tindex a:0xfc4cfa00 %l 0x8518050 0x518050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_VOLTAGE_CTL1 (at 0x11840)"
      tindex a:0xfc4cfa00 %l 0x8518400 0x518400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S2_PS_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_VOLTAGE_CTL2 (at 0x11841)"
      tindex a:0xfc4cfa00 %l 0x8518410 0x518410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_PS_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_FREQ_CTL (at 0x11850)"
      tindex a:0xfc4cfa00 %l 0x8518500 0x518500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_PS_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MULTIPHASE_CTL (at 0x11851)"
      tindex a:0xfc4cfa00 %l 0x8518510 0x518510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S2_PS_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PHASE_CTL (at 0x11852)"
      tindex a:0xfc4cfa00 %l 0x8518520 0x518520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PHASE_ID (at 0x11853)"
      tindex a:0xfc4cfa00 %l 0x8518530 0x518530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PHASE_CNT (at 0x11854)"
      tindex a:0xfc4cfa00 %l 0x8518540 0x518540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_PWM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PWM_CL_CTL (at 0x11860)"
      tindex a:0xfc4cfa00 %l 0x8518600 0x518600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_LPM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_LPM_CL_CTL (at 0x11861)"
      tindex a:0xfc4cfa00 %l 0x8518610 0x518610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_AUTO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_AUTO_CTL (at 0x11862)"
      tindex a:0xfc4cfa00 %l 0x8518620 0x518620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_FSM_MINON_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_FSM_MINON_CFG (at 0x11870)"
      tindex a:0xfc4cfa00 %l 0x8518700 0x518700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ICOMP_EN_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_ICOMP_EN_CFG (at 0x11871)"
      tindex a:0xfc4cfa00 %l 0x8518710 0x518710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ZX_CAL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_ZX_CAL_CFG (at 0x11872)"
      tindex a:0xfc4cfa00 %l 0x8518720 0x518720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_NONOVLAP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_NONOVLAP_CFG (at 0x11873)"
      tindex a:0xfc4cfa00 %l 0x8518730 0x518730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_MPHASE_PI_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MPHASE_PI_CFG1 (at 0x11874)"
      tindex a:0xfc4cfa00 %l 0x8518740 0x518740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MPHASE_PI_CFG2 (at 0x11875)"
      tindex a:0xfc4cfa00 %l 0x8518750 0x518750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MPHASE_PI_CFG3 (at 0x11876)"
      tindex a:0xfc4cfa00 %l 0x8518760 0x518760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MPHASE_PI_CFG4 (at 0x11877)"
      tindex a:0xfc4cfa00 %l 0x8518770 0x518770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MPHASE_PI_CFG5 (at 0x11878)"
      tindex a:0xfc4cfa00 %l 0x8518780 0x518780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MPHASE_PI_CFG6 (at 0x11879)"
      tindex a:0xfc4cfa00 %l 0x8518790 0x518790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S2_PS_CAL_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_CAL_FAULT (at 0x1187a)"
      tindex a:0xfc4cfa00 %l 0x85187a0 0x5187a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S2_PS_ADC_OUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_ADC_OUT (at 0x1187b)"
      tindex a:0xfc4cfa00 %l 0x85187b0 0x5187b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S2_PS_MP_IAVG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MP_IAVG2 (at 0x1187c)"
      tindex a:0xfc4cfa00 %l 0x85187c0 0x5187c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S2_PS_MP_IAVG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MP_IAVG1 (at 0x1187d)"
      tindex a:0xfc4cfa00 %l 0x85187d0 0x5187d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S2_PS_MP_DAC_DATA"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_MP_DAC_DATA (at 0x1187e)"
      tindex a:0xfc4cfa00 %l 0x85187e0 0x5187e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S2_PS_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_GANG_CTL1 (at 0x118c0)"
      tindex a:0xfc4cfa00 %l 0x8518c00 0x518c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_PS_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_GANG_CTL2 (at 0x118c1)"
      tindex a:0xfc4cfa00 %l 0x8518c10 0x518c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S2_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_SEC_ACCESS (at 0x118d0)"
      tindex a:0xfc4cfa00 %l 0x8518d00 0x518d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_RESET_CTL1 (at 0x118d8)"
      tindex a:0xfc4cfa00 %l 0x8518d80 0x518d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
      tindex a:0xfc4cfa00 %l 0x8518d90 0x518d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
      tindex a:0xfc4cfa00 %l 0x8518da0 0x518da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
      tindex a:0xfc4cfa00 %l 0x8518db0 0x518db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_PS_ATEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_ATEST12 (at 0x118e2)"
      tindex a:0xfc4cfa00 %l 0x8518e20 0x518e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ATEST34"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_ATEST34 (at 0x118e3)"
      tindex a:0xfc4cfa00 %l 0x8518e30 0x518e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_DTEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_DTEST12 (at 0x118e4)"
      tindex a:0xfc4cfa00 %l 0x8518e40 0x518e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S2_PS_DTEST43"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_DTEST43 (at 0x118e5)"
      tindex a:0xfc4cfa00 %l 0x8518e50 0x518e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S2_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_TRIM_NUM (at 0x118f0)"
      tindex a:0xfc4cfa00 %l 0x8518f00 0x518f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_PS_ZX_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_ZX_TRIM (at 0x118f1)"
      tindex a:0xfc4cfa00 %l 0x8518f10 0x518f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S2_PS_CL_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S2_PS_CL_TRIM (at 0x118f2)"
      tindex a:0xfc4cfa00 %l 0x8518f20 0x518f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION1 (at 0x11a00)"
      tindex a:0xfc4cfa00 %l 0x851a000 0x51a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION2 (at 0x11a01)"
      tindex a:0xfc4cfa00 %l 0x851a010 0x51a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION3 (at 0x11a02)"
      tindex a:0xfc4cfa00 %l 0x851a020 0x51a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_REVISION4 (at 0x11a03)"
      tindex a:0xfc4cfa00 %l 0x851a030 0x51a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_TYPE (at 0x11a04)"
      tindex a:0xfc4cfa00 %l 0x851a040 0x51a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
      tindex a:0xfc4cfa00 %l 0x851a050 0x51a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_STATUS (at 0x11a08)"
      tindex a:0xfc4cfa00 %l 0x851a080 0x51a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_RT_STS (at 0x11a10)"
      tindex a:0xfc4cfa00 %l 0x851a100 0x51a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
      tindex a:0xfc4cfa00 %l 0x851a110 0x51a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
      tindex a:0xfc4cfa00 %l 0x851a120 0x51a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
      tindex a:0xfc4cfa00 %l 0x851a130 0x51a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
      tindex a:0xfc4cfa00 %l 0x851a140 0x51a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_EN_SET (at 0x11a15)"
      tindex a:0xfc4cfa00 %l 0x851a150 0x51a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_EN_CLR (at 0x11a16)"
      tindex a:0xfc4cfa00 %l 0x851a160 0x51a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
      tindex a:0xfc4cfa00 %l 0x851a180 0x51a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
      tindex a:0xfc4cfa00 %l 0x851a190 0x51a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
      tindex a:0xfc4cfa00 %l 0x851a1a0 0x51a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
      tindex a:0xfc4cfa00 %l 0x851a1b0 0x51a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_VOLTAGE_CTL1 (at 0x11a40)"
      tindex a:0xfc4cfa00 %l 0x851a400 0x51a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_VOLTAGE_CTL2 (at 0x11a41)"
      tindex a:0xfc4cfa00 %l 0x851a410 0x51a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_PFM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PFM_CTL (at 0x11a44)"
      tindex a:0xfc4cfa00 %l 0x851a440 0x51a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_MODE_CTL (at 0x11a45)"
      tindex a:0xfc4cfa00 %l 0x851a450 0x51a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S3_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_EN_CTL (at 0x11a46)"
      tindex a:0xfc4cfa00 %l 0x851a460 0x51a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S3_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PD_CTL (at 0x11a48)"
      tindex a:0xfc4cfa00 %l 0x851a480 0x51a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_COMP_CAP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_COMP_CAP_CTL (at 0x11a51)"
      tindex a:0xfc4cfa00 %l 0x851a510 0x51a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_GM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_GM_CTL (at 0x11a52)"
      tindex a:0xfc4cfa00 %l 0x851a520 0x51a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S3_CTRL_RZ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_RZ_CTL (at 0x11a53)"
      tindex a:0xfc4cfa00 %l 0x851a530 0x51a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S3_CTRL_ISNS_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_ISNS_CTRL (at 0x11a55)"
      tindex a:0xfc4cfa00 %l 0x851a550 0x51a550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0, 1"
    tree.end
    tree "S3_CTRL_SAW_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_SAW_CTL (at 0x11a56)"
      tindex a:0xfc4cfa00 %l 0x851a560 0x51a560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CURRENT_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   NSAW_CTRL                                = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_DMAX_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_DMAX_CTL (at 0x11a58)"
      tindex a:0xfc4cfa00 %l 0x851a580 0x51a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0, 1"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PULSE_SKIP_CTL (at 0x11a59)"
      tindex a:0xfc4cfa00 %l 0x851a590 0x51a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0, 1"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_THRES"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PULSE_SKIP_THRES (at 0x11a5a)"
      tindex a:0xfc4cfa00 %l 0x851a5a0 0x51a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_AUTO_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_AUTO_MODE_CTL (at 0x11a5b)"
      tindex a:0xfc4cfa00 %l 0x851a5b0 0x51a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_INZERO_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INZERO_COUNT_CTL (at 0x11a5c)"
      tindex a:0xfc4cfa00 %l 0x851a5c0 0x51a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PFM_COUNT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PFM_COUNT_CTL (at 0x11a5d)"
      tindex a:0xfc4cfa00 %l 0x851a5d0 0x51a5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PS_VGA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PS_VGA_CTL (at 0x11a5e)"
      tindex a:0xfc4cfa00 %l 0x851a5e0 0x51a5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S3_CTRL_STEPPER_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_STEPPER_SS_CTL (at 0x11a60)"
      tindex a:0xfc4cfa00 %l 0x851a600 0x51a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_STEPPER_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_STEPPER_VS_CTL (at 0x11a61)"
      tindex a:0xfc4cfa00 %l 0x851a610 0x51a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_FT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_FT_CTL (at 0x11a62)"
      tindex a:0xfc4cfa00 %l 0x851a620 0x51a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_QMODE_SHADOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_QMODE_SHADOW (at 0x11a63)"
      tindex a:0xfc4cfa00 %l 0x851a630 0x51a630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S3_CTRL_UL_LL_CTRL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_UL_LL_CTRL (at 0x11a68)"
      tindex a:0xfc4cfa00 %l 0x851a680 0x51a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UL_INT_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LL_INT_EN                                = " "0, 1"
    tree.end
    tree "S3_CTRL_UL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_UL_VOLTAGE (at 0x11a69)"
      tindex a:0xfc4cfa00 %l 0x851a690 0x51a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_LL_VOLTAGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_LL_VOLTAGE (at 0x11a6b)"
      tindex a:0xfc4cfa00 %l 0x851a6b0 0x51a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_UL_RANGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_UL_RANGE (at 0x11a6d)"
      tindex a:0xfc4cfa00 %l 0x851a6d0 0x51a6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_LL_RANGE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_LL_RANGE (at 0x11a6e)"
      tindex a:0xfc4cfa00 %l 0x851a6e0 0x51a6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_CTLR_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTLR_MISC (at 0x11a7a)"
      tindex a:0xfc4cfa00 %l 0x851a7a0 0x51a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S3_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_SEC_ACCESS (at 0x11ad0)"
      tindex a:0xfc4cfa00 %l 0x851ad00 0x51ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
      tindex a:0xfc4cfa00 %l 0x851ad80 0x51ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
      tindex a:0xfc4cfa00 %l 0x851ad90 0x51ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
      tindex a:0xfc4cfa00 %l 0x851ada0 0x51ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
      tindex a:0xfc4cfa00 %l 0x851adb0 0x51adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_TEST1 (at 0x11ae0)"
      tindex a:0xfc4cfa00 %l 0x851ae00 0x51ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
      tindex a:0xfc4cfa00 %l 0x851ae10 0x51ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S3_CTRL_CTLR_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTLR_TEST (at 0x11ae2)"
      tindex a:0xfc4cfa00 %l 0x851ae20 0x51ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_TRIM_NUM (at 0x11af0)"
      tindex a:0xfc4cfa00 %l 0x851af00 0x51af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_CTRL_CTL_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM1 (at 0x11af1)"
      tindex a:0xfc4cfa00 %l 0x851af10 0x51af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S3_CTRL_CTL_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM2 (at 0x11af2)"
      tindex a:0xfc4cfa00 %l 0x851af20 0x51af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S3_CTRL_CTL_TRIM3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM3 (at 0x11af3)"
      tindex a:0xfc4cfa00 %l 0x851af30 0x51af30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S3_CTRL_CTL_TRIM4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_CTRL_CTL_TRIM4 (at 0x11af4)"
      tindex a:0xfc4cfa00 %l 0x851af40 0x51af40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0, 1"
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_REVISION1 (at 0x11c00)"
      tindex a:0xfc4cfa00 %l 0x851c000 0x51c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_REVISION2 (at 0x11c01)"
      tindex a:0xfc4cfa00 %l 0x851c010 0x51c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_REVISION3 (at 0x11c02)"
      tindex a:0xfc4cfa00 %l 0x851c020 0x51c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_REVISION4 (at 0x11c03)"
      tindex a:0xfc4cfa00 %l 0x851c030 0x51c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_TYPE (at 0x11c04)"
      tindex a:0xfc4cfa00 %l 0x851c040 0x51c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
      tindex a:0xfc4cfa00 %l 0x851c050 0x51c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_CLK_ENABLE (at 0x11c46)"
      tindex a:0xfc4cfa00 %l 0x851c460 0x51c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_CLK_DIV (at 0x11c50)"
      tindex a:0xfc4cfa00 %l 0x851c500 0x51c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_CLK_PHASE (at 0x11c51)"
      tindex a:0xfc4cfa00 %l 0x851c510 0x51c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
      tindex a:0xfc4cfa00 %l 0x851cc00 0x51cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
      tindex a:0xfc4cfa00 %l 0x851cc10 0x51cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
      tindex a:0xfc4cfa00 %l 0x851cd00 0x51cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
      tindex a:0xfc4cfa00 %l 0x851cd90 0x51cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
      tindex a:0xfc4cfa00 %l 0x851cda0 0x51cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
      tindex a:0xfc4cfa00 %l 0x851cdb0 0x51cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S3_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_FREQ_TEST1 (at 0x11ce2)"
      tindex a:0xfc4cfa00 %l 0x851ce20 0x51ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION1 (at 0x11b00)"
      tindex a:0xfc4cfa00 %l 0x851b000 0x51b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION2 (at 0x11b01)"
      tindex a:0xfc4cfa00 %l 0x851b010 0x51b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION3 (at 0x11b02)"
      tindex a:0xfc4cfa00 %l 0x851b020 0x51b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_REVISION4 (at 0x11b03)"
      tindex a:0xfc4cfa00 %l 0x851b030 0x51b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_TYPE (at 0x11b04)"
      tindex a:0xfc4cfa00 %l 0x851b040 0x51b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
      tindex a:0xfc4cfa00 %l 0x851b050 0x51b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_PWM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PWM_CURRENT_LIM_CTL (at 0x11b4a)"
      tindex a:0xfc4cfa00 %l 0x851b4a0 0x51b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_PS_PFM_CURRENT_LIM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PFM_CURRENT_LIM_CTL (at 0x11b4b)"
      tindex a:0xfc4cfa00 %l 0x851b4b0 0x51b4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_PS_SOFT_START_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_SOFT_START_CTL (at 0x11b4c)"
      tindex a:0xfc4cfa00 %l 0x851b4c0 0x51b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0, 1"
    tree.end
    tree "S3_PS_SWITCH_SIZE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_SWITCH_SIZE_CTL (at 0x11b70)"
      tindex a:0xfc4cfa00 %l 0x851b700 0x51b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   P_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   N_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   P_DRIVER_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_DRIVER_SIZE                            = " "0, 1"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_DEAD_TIME_CTRL1 (at 0x11b71)"
      tindex a:0xfc4cfa00 %l 0x851b710 0x51b710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0, 1"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_DEAD_TIME_CTRL2 (at 0x11b72)"
      tindex a:0xfc4cfa00 %l 0x851b720 0x51b720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S3_PS_BLNK_TIME_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_BLNK_TIME_CTL (at 0x11b73)"
      tindex a:0xfc4cfa00 %l 0x851b730 0x51b730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0, 1"
    tree.end
    tree "S3_PS_INZERO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_INZERO_CTL (at 0x11b74)"
      tindex a:0xfc4cfa00 %l 0x851b740 0x51b740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0, 1"
    tree.end
    tree "S3_PS_DIG_FSM_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_DIG_FSM_CTL (at 0x11b75)"
      tindex a:0xfc4cfa00 %l 0x851b750 0x51b750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0, 1"
    tree.end
    tree "S3_PS_PWR_STG_MISC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PWR_STG_MISC (at 0x11b79)"
      tindex a:0xfc4cfa00 %l 0x851b790 0x51b790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0, 1"
    tree.end
    tree "S3_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_SEC_ACCESS (at 0x11bd0)"
      tindex a:0xfc4cfa00 %l 0x851bd00 0x51bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_RESET_CTL1 (at 0x11bd8)"
      tindex a:0xfc4cfa00 %l 0x851bd80 0x51bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
      tindex a:0xfc4cfa00 %l 0x851bd90 0x51bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
      tindex a:0xfc4cfa00 %l 0x851bda0 0x51bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
      tindex a:0xfc4cfa00 %l 0x851bdb0 0x51bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S3_PS_FORCE_FET_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_FORCE_FET_TEST (at 0x11be3)"
      tindex a:0xfc4cfa00 %l 0x851be30 0x51be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0, 1, 2, 3"
    tree.end
    tree "S3_PS_PWR_STG_TEST"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PWR_STG_TEST (at 0x11be4)"
      tindex a:0xfc4cfa00 %l 0x851be40 0x51be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S3_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_TRIM_NUM (at 0x11bf0)"
      tindex a:0xfc4cfa00 %l 0x851bf00 0x51bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_PS_PS_TRIM1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PS_TRIM1 (at 0x11bf1)"
      tindex a:0xfc4cfa00 %l 0x851bf10 0x51bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S3_PS_PS_TRIM2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S3_PS_PS_TRIM2 (at 0x11bf2)"
      tindex a:0xfc4cfa00 %l 0x851bf20 0x51bf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION1 (at 0x11d00)"
      tindex a:0xfc4cfa00 %l 0x851d000 0x51d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION2 (at 0x11d01)"
      tindex a:0xfc4cfa00 %l 0x851d010 0x51d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION3 (at 0x11d02)"
      tindex a:0xfc4cfa00 %l 0x851d020 0x51d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REVISION4 (at 0x11d03)"
      tindex a:0xfc4cfa00 %l 0x851d030 0x51d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_TYPE (at 0x11d04)"
      tindex a:0xfc4cfa00 %l 0x851d040 0x51d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_SUBTYPE (at 0x11d05)"
      tindex a:0xfc4cfa00 %l 0x851d050 0x51d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS_1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_STATUS_1 (at 0x11d08)"
      tindex a:0xfc4cfa00 %l 0x851d080 0x51d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S4_CTRL_STATUS_2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_STATUS_2 (at 0x11d09)"
      tindex a:0xfc4cfa00 %l 0x851d090 0x51d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S4_CTRL_STATUS_3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_STATUS_3 (at 0x11d0a)"
      tindex a:0xfc4cfa00 %l 0x851d0a0 0x51d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S4_CTRL_STATUS_4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_STATUS_4 (at 0x11d0b)"
      tindex a:0xfc4cfa00 %l 0x851d0b0 0x51d0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_RT_STS (at 0x11d10)"
      tindex a:0xfc4cfa00 %l 0x851d100 0x51d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_SET_TYPE (at 0x11d11)"
      tindex a:0xfc4cfa00 %l 0x851d110 0x51d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_POLARITY_HIGH (at 0x11d12)"
      tindex a:0xfc4cfa00 %l 0x851d120 0x51d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_POLARITY_LOW (at 0x11d13)"
      tindex a:0xfc4cfa00 %l 0x851d130 0x51d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_LATCHED_CLR (at 0x11d14)"
      tindex a:0xfc4cfa00 %l 0x851d140 0x51d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_EN_SET (at 0x11d15)"
      tindex a:0xfc4cfa00 %l 0x851d150 0x51d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_EN_CLR (at 0x11d16)"
      tindex a:0xfc4cfa00 %l 0x851d160 0x51d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_LATCHED_STS (at 0x11d18)"
      tindex a:0xfc4cfa00 %l 0x851d180 0x51d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_PENDING_STS (at 0x11d19)"
      tindex a:0xfc4cfa00 %l 0x851d190 0x51d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_MID_SEL (at 0x11d1a)"
      tindex a:0xfc4cfa00 %l 0x851d1a0 0x51d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_PRIORITY (at 0x11d1b)"
      tindex a:0xfc4cfa00 %l 0x851d1b0 0x51d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VOLTAGE_CTL1 (at 0x11d40)"
      tindex a:0xfc4cfa00 %l 0x851d400 0x51d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VOLTAGE_CTL2 (at 0x11d41)"
      tindex a:0xfc4cfa00 %l 0x851d410 0x51d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S4_CTRL_VSET_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VSET_VALID (at 0x11d42)"
      tindex a:0xfc4cfa00 %l 0x851d420 0x51d420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VOLTAGE_CTL3 (at 0x11d44)"
      tindex a:0xfc4cfa00 %l 0x851d440 0x51d440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_MODE_CTL (at 0x11d45)"
      tindex a:0xfc4cfa00 %l 0x851d450 0x51d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S4_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_EN_CTL (at 0x11d46)"
      tindex a:0xfc4cfa00 %l 0x851d460 0x51d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S4_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PD_CTL (at 0x11d48)"
      tindex a:0xfc4cfa00 %l 0x851d480 0x51d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S4_CTRL_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_FREQ_CTL (at 0x11d50)"
      tindex a:0xfc4cfa00 %l 0x851d500 0x51d500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S4_CTRL_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_MULTIPHASE_CTL (at 0x11d51)"
      tindex a:0xfc4cfa00 %l 0x851d510 0x51d510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S4_CTRL_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PHASE_CTL (at 0x11d52)"
      tindex a:0xfc4cfa00 %l 0x851d520 0x51d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PHASE_ID (at 0x11d53)"
      tindex a:0xfc4cfa00 %l 0x851d530 0x51d530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PHASE_CNT (at 0x11d54)"
      tindex a:0xfc4cfa00 %l 0x851d540 0x51d540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_SS_CTL (at 0x11d60)"
      tindex a:0xfc4cfa00 %l 0x851d600 0x51d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VS_CTL (at 0x11d61)"
      tindex a:0xfc4cfa00 %l 0x851d610 0x51d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CORR_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CORR_CFG (at 0x11d62)"
      tindex a:0xfc4cfa00 %l 0x851d620 0x51d620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S4_CTRL_RAMP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_RAMP_CFG (at 0x11d63)"
      tindex a:0xfc4cfa00 %l 0x851d630 0x51d630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_COMPENS_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_COMPENS_CFG (at 0x11d64)"
      tindex a:0xfc4cfa00 %l 0x851d640 0x51d640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_VREG_OK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_VREG_OK (at 0x11d65)"
      tindex a:0xfc4cfa00 %l 0x851d650 0x51d650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_VREG_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_VREG_FAULT (at 0x11d66)"
      tindex a:0xfc4cfa00 %l 0x851d660 0x51d660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_PFM_COMP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_PFM_COMP (at 0x11d67)"
      tindex a:0xfc4cfa00 %l 0x851d670 0x51d670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_UL_LL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_UL_LL_CTL (at 0x11d68)"
      tindex a:0xfc4cfa00 %l 0x851d680 0x51d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S4_CTRL_VSET_ULS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VSET_ULS (at 0x11d69)"
      tindex a:0xfc4cfa00 %l 0x851d690 0x51d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S4_CTRL_ULS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_ULS_VALID (at 0x11d6a)"
      tindex a:0xfc4cfa00 %l 0x851d6a0 0x51d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S4_CTRL_VSET_LLS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_VSET_LLS (at 0x11d6b)"
      tindex a:0xfc4cfa00 %l 0x851d6b0 0x51d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S4_CTRL_LLS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_LLS_VALID (at 0x11d6c)"
      tindex a:0xfc4cfa00 %l 0x851d6c0 0x51d6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S4_CTRL_GPL_HI"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_GPL_HI (at 0x11d6d)"
      tindex a:0xfc4cfa00 %l 0x851d6d0 0x51d6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S4_CTRL_GPL_LO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_GPL_LO (at 0x11d6e)"
      tindex a:0xfc4cfa00 %l 0x851d6e0 0x51d6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S4_CTRL_CFG_ATEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_ATEST1 (at 0x11db0)"
      tindex a:0xfc4cfa00 %l 0x851db00 0x51db00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_ATEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_ATEST2 (at 0x11db1)"
      tindex a:0xfc4cfa00 %l 0x851db10 0x51db10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_ATEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_ATEST3 (at 0x11db2)"
      tindex a:0xfc4cfa00 %l 0x851db20 0x51db20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_ATEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_ATEST4 (at 0x11db3)"
      tindex a:0xfc4cfa00 %l 0x851db30 0x51db30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_DTEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_DTEST1 (at 0x11db4)"
      tindex a:0xfc4cfa00 %l 0x851db40 0x51db40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_DTEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_DTEST2 (at 0x11db5)"
      tindex a:0xfc4cfa00 %l 0x851db50 0x51db50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_DTEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_DTEST3 (at 0x11db6)"
      tindex a:0xfc4cfa00 %l 0x851db60 0x51db60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_DTEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CFG_DTEST4 (at 0x11db7)"
      tindex a:0xfc4cfa00 %l 0x851db70 0x51db70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_GANG_CTL1 (at 0x11dc0)"
      tindex a:0xfc4cfa00 %l 0x851dc00 0x51dc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_CTRL_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_GANG_CTL2 (at 0x11dc1)"
      tindex a:0xfc4cfa00 %l 0x851dc10 0x51dc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_SEC_ACCESS (at 0x11dd0)"
      tindex a:0xfc4cfa00 %l 0x851dd00 0x51dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL1 (at 0x11dd8)"
      tindex a:0xfc4cfa00 %l 0x851dd80 0x51dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL2 (at 0x11dd9)"
      tindex a:0xfc4cfa00 %l 0x851dd90 0x51dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL3 (at 0x11dda)"
      tindex a:0xfc4cfa00 %l 0x851dda0 0x51dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PERPH_RESET_CTL4 (at 0x11ddb)"
      tindex a:0xfc4cfa00 %l 0x851ddb0 0x51ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_TEST1 (at 0x11de0)"
      tindex a:0xfc4cfa00 %l 0x851de00 0x51de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_INT_TEST_VAL (at 0x11de1)"
      tindex a:0xfc4cfa00 %l 0x851de10 0x51de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S4_CTRL_MODE_FSM_MASK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_MODE_FSM_MASK (at 0x11de2)"
      tindex a:0xfc4cfa00 %l 0x851de20 0x51de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S4_CTRL_GATE_DRV_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_GATE_DRV_MUX (at 0x11de3)"
      tindex a:0xfc4cfa00 %l 0x851de30 0x51de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CORR_DUTY_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CORR_DUTY_MUX (at 0x11de4)"
      tindex a:0xfc4cfa00 %l 0x851de40 0x51de40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_EN_OPTIONS_DFT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_EN_OPTIONS_DFT (at 0x11de5)"
      tindex a:0xfc4cfa00 %l 0x851de50 0x51de50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_CAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CAL_CTL (at 0x11de8)"
      tindex a:0xfc4cfa00 %l 0x851de80 0x51de80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S4_CTRL_IDAC_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_IDAC_CAL_VAL (at 0x11de9)"
      tindex a:0xfc4cfa00 %l 0x851de90 0x51de90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S4_CTRL_CORR_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CORR_CAL_VAL (at 0x11dea)"
      tindex a:0xfc4cfa00 %l 0x851dea0 0x51dea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S4_CTRL_PWM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PWM_CAL_VAL (at 0x11deb)"
      tindex a:0xfc4cfa00 %l 0x851deb0 0x51deb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S4_CTRL_PFM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PFM_CAL_VAL (at 0x11dec)"
      tindex a:0xfc4cfa00 %l 0x851dec0 0x51dec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S4_CTRL_MPHASE_IDAC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_MPHASE_IDAC (at 0x11ded)"
      tindex a:0xfc4cfa00 %l 0x851ded0 0x51ded0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_TRIM_NUM (at 0x11df0)"
      tindex a:0xfc4cfa00 %l 0x851df00 0x51df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S4_CTRL_CAL_EN_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CAL_EN_TRIM (at 0x11df1)"
      tindex a:0xfc4cfa00 %l 0x851df10 0x51df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S4_CTRL_REFDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_REFDAC_TRIM (at 0x11df2)"
      tindex a:0xfc4cfa00 %l 0x851df20 0x51df20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S4_CTRL_IDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_IDAC_TRIM (at 0x11df3)"
      tindex a:0xfc4cfa00 %l 0x851df30 0x51df30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S4_CTRL_CORR_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_CORR_TRIM (at 0x11df4)"
      tindex a:0xfc4cfa00 %l 0x851df40 0x51df40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S4_CTRL_PWM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PWM_TRIM (at 0x11df5)"
      tindex a:0xfc4cfa00 %l 0x851df50 0x51df50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S4_CTRL_PFM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_PFM_TRIM (at 0x11df6)"
      tindex a:0xfc4cfa00 %l 0x851df60 0x51df60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S4_CTRL_RAMP_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_CTRL_RAMP_TRIM (at 0x11df7)"
      tindex a:0xfc4cfa00 %l 0x851df70 0x51df70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_REVISION1 (at 0x11f00)"
      tindex a:0xfc4cfa00 %l 0x851f000 0x51f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_REVISION2 (at 0x11f01)"
      tindex a:0xfc4cfa00 %l 0x851f010 0x51f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_REVISION3 (at 0x11f02)"
      tindex a:0xfc4cfa00 %l 0x851f020 0x51f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_REVISION4 (at 0x11f03)"
      tindex a:0xfc4cfa00 %l 0x851f030 0x51f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_TYPE (at 0x11f04)"
      tindex a:0xfc4cfa00 %l 0x851f040 0x51f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_SUBTYPE (at 0x11f05)"
      tindex a:0xfc4cfa00 %l 0x851f050 0x51f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_CLK_ENABLE (at 0x11f46)"
      tindex a:0xfc4cfa00 %l 0x851f460 0x51f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_CLK_DIV (at 0x11f50)"
      tindex a:0xfc4cfa00 %l 0x851f500 0x51f500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_CLK_PHASE (at 0x11f51)"
      tindex a:0xfc4cfa00 %l 0x851f510 0x51f510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_GANG_CTL1 (at 0x11fc0)"
      tindex a:0xfc4cfa00 %l 0x851fc00 0x51fc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_GANG_CTL2 (at 0x11fc1)"
      tindex a:0xfc4cfa00 %l 0x851fc10 0x51fc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_SEC_ACCESS (at 0x11fd0)"
      tindex a:0xfc4cfa00 %l 0x851fd00 0x51fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_RESET_CTL2 (at 0x11fd9)"
      tindex a:0xfc4cfa00 %l 0x851fd90 0x51fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_RESET_CTL3 (at 0x11fda)"
      tindex a:0xfc4cfa00 %l 0x851fda0 0x51fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_PERPH_RESET_CTL4 (at 0x11fdb)"
      tindex a:0xfc4cfa00 %l 0x851fdb0 0x51fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S4_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_FREQ_TEST1 (at 0x11fe2)"
      tindex a:0xfc4cfa00 %l 0x851fe20 0x51fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION1 (at 0x11e00)"
      tindex a:0xfc4cfa00 %l 0x851e000 0x51e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION2 (at 0x11e01)"
      tindex a:0xfc4cfa00 %l 0x851e010 0x51e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION3 (at 0x11e02)"
      tindex a:0xfc4cfa00 %l 0x851e020 0x51e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_REVISION4 (at 0x11e03)"
      tindex a:0xfc4cfa00 %l 0x851e030 0x51e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_TYPE (at 0x11e04)"
      tindex a:0xfc4cfa00 %l 0x851e040 0x51e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_SUBTYPE (at 0x11e05)"
      tindex a:0xfc4cfa00 %l 0x851e050 0x51e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_VOLTAGE_CTL1 (at 0x11e40)"
      tindex a:0xfc4cfa00 %l 0x851e400 0x51e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S4_PS_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_VOLTAGE_CTL2 (at 0x11e41)"
      tindex a:0xfc4cfa00 %l 0x851e410 0x51e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S4_PS_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_FREQ_CTL (at 0x11e50)"
      tindex a:0xfc4cfa00 %l 0x851e500 0x51e500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S4_PS_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MULTIPHASE_CTL (at 0x11e51)"
      tindex a:0xfc4cfa00 %l 0x851e510 0x51e510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S4_PS_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PHASE_CTL (at 0x11e52)"
      tindex a:0xfc4cfa00 %l 0x851e520 0x51e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PHASE_ID (at 0x11e53)"
      tindex a:0xfc4cfa00 %l 0x851e530 0x51e530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PHASE_CNT (at 0x11e54)"
      tindex a:0xfc4cfa00 %l 0x851e540 0x51e540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_PWM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PWM_CL_CTL (at 0x11e60)"
      tindex a:0xfc4cfa00 %l 0x851e600 0x51e600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_PS_LPM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_LPM_CL_CTL (at 0x11e61)"
      tindex a:0xfc4cfa00 %l 0x851e610 0x51e610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_PS_AUTO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_AUTO_CTL (at 0x11e62)"
      tindex a:0xfc4cfa00 %l 0x851e620 0x51e620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_PS_FSM_MINON_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_FSM_MINON_CFG (at 0x11e70)"
      tindex a:0xfc4cfa00 %l 0x851e700 0x51e700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_ICOMP_EN_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_ICOMP_EN_CFG (at 0x11e71)"
      tindex a:0xfc4cfa00 %l 0x851e710 0x51e710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_ZX_CAL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_ZX_CAL_CFG (at 0x11e72)"
      tindex a:0xfc4cfa00 %l 0x851e720 0x51e720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_NONOVLAP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_NONOVLAP_CFG (at 0x11e73)"
      tindex a:0xfc4cfa00 %l 0x851e730 0x51e730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_MPHASE_PI_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MPHASE_PI_CFG1 (at 0x11e74)"
      tindex a:0xfc4cfa00 %l 0x851e740 0x51e740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MPHASE_PI_CFG2 (at 0x11e75)"
      tindex a:0xfc4cfa00 %l 0x851e750 0x51e750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MPHASE_PI_CFG3 (at 0x11e76)"
      tindex a:0xfc4cfa00 %l 0x851e760 0x51e760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MPHASE_PI_CFG4 (at 0x11e77)"
      tindex a:0xfc4cfa00 %l 0x851e770 0x51e770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MPHASE_PI_CFG5 (at 0x11e78)"
      tindex a:0xfc4cfa00 %l 0x851e780 0x51e780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MPHASE_PI_CFG6 (at 0x11e79)"
      tindex a:0xfc4cfa00 %l 0x851e790 0x51e790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S4_PS_CAL_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_CAL_FAULT (at 0x11e7a)"
      tindex a:0xfc4cfa00 %l 0x851e7a0 0x51e7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S4_PS_ADC_OUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_ADC_OUT (at 0x11e7b)"
      tindex a:0xfc4cfa00 %l 0x851e7b0 0x51e7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S4_PS_MP_IAVG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MP_IAVG2 (at 0x11e7c)"
      tindex a:0xfc4cfa00 %l 0x851e7c0 0x51e7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S4_PS_MP_IAVG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MP_IAVG1 (at 0x11e7d)"
      tindex a:0xfc4cfa00 %l 0x851e7d0 0x51e7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S4_PS_MP_DAC_DATA"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_MP_DAC_DATA (at 0x11e7e)"
      tindex a:0xfc4cfa00 %l 0x851e7e0 0x51e7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S4_PS_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_GANG_CTL1 (at 0x11ec0)"
      tindex a:0xfc4cfa00 %l 0x851ec00 0x51ec00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_PS_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_GANG_CTL2 (at 0x11ec1)"
      tindex a:0xfc4cfa00 %l 0x851ec10 0x51ec10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S4_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_SEC_ACCESS (at 0x11ed0)"
      tindex a:0xfc4cfa00 %l 0x851ed00 0x51ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_RESET_CTL1 (at 0x11ed8)"
      tindex a:0xfc4cfa00 %l 0x851ed80 0x51ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_RESET_CTL2 (at 0x11ed9)"
      tindex a:0xfc4cfa00 %l 0x851ed90 0x51ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_RESET_CTL3 (at 0x11eda)"
      tindex a:0xfc4cfa00 %l 0x851eda0 0x51eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_PERPH_RESET_CTL4 (at 0x11edb)"
      tindex a:0xfc4cfa00 %l 0x851edb0 0x51edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S4_PS_ATEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_ATEST12 (at 0x11ee2)"
      tindex a:0xfc4cfa00 %l 0x851ee20 0x51ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_ATEST34"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_ATEST34 (at 0x11ee3)"
      tindex a:0xfc4cfa00 %l 0x851ee30 0x51ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_DTEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_DTEST12 (at 0x11ee4)"
      tindex a:0xfc4cfa00 %l 0x851ee40 0x51ee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S4_PS_DTEST43"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_DTEST43 (at 0x11ee5)"
      tindex a:0xfc4cfa00 %l 0x851ee50 0x51ee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S4_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_TRIM_NUM (at 0x11ef0)"
      tindex a:0xfc4cfa00 %l 0x851ef00 0x51ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S4_PS_ZX_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_ZX_TRIM (at 0x11ef1)"
      tindex a:0xfc4cfa00 %l 0x851ef10 0x51ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S4_PS_CL_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S4_PS_CL_TRIM (at 0x11ef2)"
      tindex a:0xfc4cfa00 %l 0x851ef20 0x51ef20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S5_CTRL"
  tree "S5_CTRL"
    tree "S5_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION1 (at 0x12000)"
      tindex a:0xfc4cfa00 %l 0x8520000 0x520000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION2 (at 0x12001)"
      tindex a:0xfc4cfa00 %l 0x8520010 0x520010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION3 (at 0x12002)"
      tindex a:0xfc4cfa00 %l 0x8520020 0x520020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REVISION4 (at 0x12003)"
      tindex a:0xfc4cfa00 %l 0x8520030 0x520030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_TYPE (at 0x12004)"
      tindex a:0xfc4cfa00 %l 0x8520040 0x520040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_SUBTYPE (at 0x12005)"
      tindex a:0xfc4cfa00 %l 0x8520050 0x520050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_CTRL_STATUS_1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_STATUS_1 (at 0x12008)"
      tindex a:0xfc4cfa00 %l 0x8520080 0x520080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S5_CTRL_STATUS_2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_STATUS_2 (at 0x12009)"
      tindex a:0xfc4cfa00 %l 0x8520090 0x520090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S5_CTRL_STATUS_3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_STATUS_3 (at 0x1200a)"
      tindex a:0xfc4cfa00 %l 0x85200a0 0x5200a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S5_CTRL_STATUS_4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_STATUS_4 (at 0x1200b)"
      tindex a:0xfc4cfa00 %l 0x85200b0 0x5200b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_RT_STS (at 0x12010)"
      tindex a:0xfc4cfa00 %l 0x8520100 0x520100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_SET_TYPE (at 0x12011)"
      tindex a:0xfc4cfa00 %l 0x8520110 0x520110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_POLARITY_HIGH (at 0x12012)"
      tindex a:0xfc4cfa00 %l 0x8520120 0x520120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_POLARITY_LOW (at 0x12013)"
      tindex a:0xfc4cfa00 %l 0x8520130 0x520130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_LATCHED_CLR (at 0x12014)"
      tindex a:0xfc4cfa00 %l 0x8520140 0x520140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_EN_SET (at 0x12015)"
      tindex a:0xfc4cfa00 %l 0x8520150 0x520150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_EN_CLR (at 0x12016)"
      tindex a:0xfc4cfa00 %l 0x8520160 0x520160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_LATCHED_STS (at 0x12018)"
      tindex a:0xfc4cfa00 %l 0x8520180 0x520180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_PENDING_STS (at 0x12019)"
      tindex a:0xfc4cfa00 %l 0x8520190 0x520190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_MID_SEL (at 0x1201a)"
      tindex a:0xfc4cfa00 %l 0x85201a0 0x5201a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_PRIORITY (at 0x1201b)"
      tindex a:0xfc4cfa00 %l 0x85201b0 0x5201b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VOLTAGE_CTL1 (at 0x12040)"
      tindex a:0xfc4cfa00 %l 0x8520400 0x520400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VOLTAGE_CTL2 (at 0x12041)"
      tindex a:0xfc4cfa00 %l 0x8520410 0x520410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S5_CTRL_VSET_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VSET_VALID (at 0x12042)"
      tindex a:0xfc4cfa00 %l 0x8520420 0x520420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VOLTAGE_CTL3 (at 0x12044)"
      tindex a:0xfc4cfa00 %l 0x8520440 0x520440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_MODE_CTL (at 0x12045)"
      tindex a:0xfc4cfa00 %l 0x8520450 0x520450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S5_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_EN_CTL (at 0x12046)"
      tindex a:0xfc4cfa00 %l 0x8520460 0x520460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S5_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PD_CTL (at 0x12048)"
      tindex a:0xfc4cfa00 %l 0x8520480 0x520480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S5_CTRL_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_FREQ_CTL (at 0x12050)"
      tindex a:0xfc4cfa00 %l 0x8520500 0x520500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S5_CTRL_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_MULTIPHASE_CTL (at 0x12051)"
      tindex a:0xfc4cfa00 %l 0x8520510 0x520510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S5_CTRL_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PHASE_CTL (at 0x12052)"
      tindex a:0xfc4cfa00 %l 0x8520520 0x520520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PHASE_ID (at 0x12053)"
      tindex a:0xfc4cfa00 %l 0x8520530 0x520530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PHASE_CNT (at 0x12054)"
      tindex a:0xfc4cfa00 %l 0x8520540 0x520540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_SS_CTL (at 0x12060)"
      tindex a:0xfc4cfa00 %l 0x8520600 0x520600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VS_CTL (at 0x12061)"
      tindex a:0xfc4cfa00 %l 0x8520610 0x520610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CORR_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CORR_CFG (at 0x12062)"
      tindex a:0xfc4cfa00 %l 0x8520620 0x520620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S5_CTRL_RAMP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_RAMP_CFG (at 0x12063)"
      tindex a:0xfc4cfa00 %l 0x8520630 0x520630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_COMPENS_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_COMPENS_CFG (at 0x12064)"
      tindex a:0xfc4cfa00 %l 0x8520640 0x520640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_VREG_OK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_VREG_OK (at 0x12065)"
      tindex a:0xfc4cfa00 %l 0x8520650 0x520650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_VREG_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_VREG_FAULT (at 0x12066)"
      tindex a:0xfc4cfa00 %l 0x8520660 0x520660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_PFM_COMP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_PFM_COMP (at 0x12067)"
      tindex a:0xfc4cfa00 %l 0x8520670 0x520670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_UL_LL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_UL_LL_CTL (at 0x12068)"
      tindex a:0xfc4cfa00 %l 0x8520680 0x520680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S5_CTRL_VSET_ULS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VSET_ULS (at 0x12069)"
      tindex a:0xfc4cfa00 %l 0x8520690 0x520690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S5_CTRL_ULS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_ULS_VALID (at 0x1206a)"
      tindex a:0xfc4cfa00 %l 0x85206a0 0x5206a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S5_CTRL_VSET_LLS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_VSET_LLS (at 0x1206b)"
      tindex a:0xfc4cfa00 %l 0x85206b0 0x5206b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S5_CTRL_LLS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_LLS_VALID (at 0x1206c)"
      tindex a:0xfc4cfa00 %l 0x85206c0 0x5206c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S5_CTRL_GPL_HI"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_GPL_HI (at 0x1206d)"
      tindex a:0xfc4cfa00 %l 0x85206d0 0x5206d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S5_CTRL_GPL_LO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_GPL_LO (at 0x1206e)"
      tindex a:0xfc4cfa00 %l 0x85206e0 0x5206e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S5_CTRL_CFG_ATEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_ATEST1 (at 0x120b0)"
      tindex a:0xfc4cfa00 %l 0x8520b00 0x520b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_ATEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_ATEST2 (at 0x120b1)"
      tindex a:0xfc4cfa00 %l 0x8520b10 0x520b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_ATEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_ATEST3 (at 0x120b2)"
      tindex a:0xfc4cfa00 %l 0x8520b20 0x520b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_ATEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_ATEST4 (at 0x120b3)"
      tindex a:0xfc4cfa00 %l 0x8520b30 0x520b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_DTEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_DTEST1 (at 0x120b4)"
      tindex a:0xfc4cfa00 %l 0x8520b40 0x520b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_DTEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_DTEST2 (at 0x120b5)"
      tindex a:0xfc4cfa00 %l 0x8520b50 0x520b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_DTEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_DTEST3 (at 0x120b6)"
      tindex a:0xfc4cfa00 %l 0x8520b60 0x520b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_DTEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CFG_DTEST4 (at 0x120b7)"
      tindex a:0xfc4cfa00 %l 0x8520b70 0x520b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_GANG_CTL1 (at 0x120c0)"
      tindex a:0xfc4cfa00 %l 0x8520c00 0x520c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_CTRL_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_GANG_CTL2 (at 0x120c1)"
      tindex a:0xfc4cfa00 %l 0x8520c10 0x520c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_SEC_ACCESS (at 0x120d0)"
      tindex a:0xfc4cfa00 %l 0x8520d00 0x520d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL1 (at 0x120d8)"
      tindex a:0xfc4cfa00 %l 0x8520d80 0x520d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL2 (at 0x120d9)"
      tindex a:0xfc4cfa00 %l 0x8520d90 0x520d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL3 (at 0x120da)"
      tindex a:0xfc4cfa00 %l 0x8520da0 0x520da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PERPH_RESET_CTL4 (at 0x120db)"
      tindex a:0xfc4cfa00 %l 0x8520db0 0x520db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_TEST1 (at 0x120e0)"
      tindex a:0xfc4cfa00 %l 0x8520e00 0x520e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_INT_TEST_VAL (at 0x120e1)"
      tindex a:0xfc4cfa00 %l 0x8520e10 0x520e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S5_CTRL_MODE_FSM_MASK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_MODE_FSM_MASK (at 0x120e2)"
      tindex a:0xfc4cfa00 %l 0x8520e20 0x520e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S5_CTRL_GATE_DRV_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_GATE_DRV_MUX (at 0x120e3)"
      tindex a:0xfc4cfa00 %l 0x8520e30 0x520e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CORR_DUTY_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CORR_DUTY_MUX (at 0x120e4)"
      tindex a:0xfc4cfa00 %l 0x8520e40 0x520e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_EN_OPTIONS_DFT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_EN_OPTIONS_DFT (at 0x120e5)"
      tindex a:0xfc4cfa00 %l 0x8520e50 0x520e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_CAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CAL_CTL (at 0x120e8)"
      tindex a:0xfc4cfa00 %l 0x8520e80 0x520e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S5_CTRL_IDAC_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_IDAC_CAL_VAL (at 0x120e9)"
      tindex a:0xfc4cfa00 %l 0x8520e90 0x520e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S5_CTRL_CORR_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CORR_CAL_VAL (at 0x120ea)"
      tindex a:0xfc4cfa00 %l 0x8520ea0 0x520ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S5_CTRL_PWM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PWM_CAL_VAL (at 0x120eb)"
      tindex a:0xfc4cfa00 %l 0x8520eb0 0x520eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S5_CTRL_PFM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PFM_CAL_VAL (at 0x120ec)"
      tindex a:0xfc4cfa00 %l 0x8520ec0 0x520ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S5_CTRL_MPHASE_IDAC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_MPHASE_IDAC (at 0x120ed)"
      tindex a:0xfc4cfa00 %l 0x8520ed0 0x520ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S5_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_TRIM_NUM (at 0x120f0)"
      tindex a:0xfc4cfa00 %l 0x8520f00 0x520f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S5_CTRL_CAL_EN_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CAL_EN_TRIM (at 0x120f1)"
      tindex a:0xfc4cfa00 %l 0x8520f10 0x520f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S5_CTRL_REFDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_REFDAC_TRIM (at 0x120f2)"
      tindex a:0xfc4cfa00 %l 0x8520f20 0x520f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S5_CTRL_IDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_IDAC_TRIM (at 0x120f3)"
      tindex a:0xfc4cfa00 %l 0x8520f30 0x520f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S5_CTRL_CORR_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_CORR_TRIM (at 0x120f4)"
      tindex a:0xfc4cfa00 %l 0x8520f40 0x520f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S5_CTRL_PWM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PWM_TRIM (at 0x120f5)"
      tindex a:0xfc4cfa00 %l 0x8520f50 0x520f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S5_CTRL_PFM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_PFM_TRIM (at 0x120f6)"
      tindex a:0xfc4cfa00 %l 0x8520f60 0x520f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S5_CTRL_RAMP_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_CTRL_RAMP_TRIM (at 0x120f7)"
      tindex a:0xfc4cfa00 %l 0x8520f70 0x520f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S5_FREQ"
  tree "S5_FREQ"
    tree "S5_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_REVISION1 (at 0x12200)"
      tindex a:0xfc4cfa00 %l 0x8522000 0x522000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_REVISION2 (at 0x12201)"
      tindex a:0xfc4cfa00 %l 0x8522010 0x522010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_REVISION3 (at 0x12202)"
      tindex a:0xfc4cfa00 %l 0x8522020 0x522020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_REVISION4 (at 0x12203)"
      tindex a:0xfc4cfa00 %l 0x8522030 0x522030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_TYPE (at 0x12204)"
      tindex a:0xfc4cfa00 %l 0x8522040 0x522040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_SUBTYPE (at 0x12205)"
      tindex a:0xfc4cfa00 %l 0x8522050 0x522050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_CLK_ENABLE (at 0x12246)"
      tindex a:0xfc4cfa00 %l 0x8522460 0x522460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S5_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_CLK_DIV (at 0x12250)"
      tindex a:0xfc4cfa00 %l 0x8522500 0x522500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S5_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_CLK_PHASE (at 0x12251)"
      tindex a:0xfc4cfa00 %l 0x8522510 0x522510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S5_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_GANG_CTL1 (at 0x122c0)"
      tindex a:0xfc4cfa00 %l 0x8522c00 0x522c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_GANG_CTL2 (at 0x122c1)"
      tindex a:0xfc4cfa00 %l 0x8522c10 0x522c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S5_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_SEC_ACCESS (at 0x122d0)"
      tindex a:0xfc4cfa00 %l 0x8522d00 0x522d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_RESET_CTL2 (at 0x122d9)"
      tindex a:0xfc4cfa00 %l 0x8522d90 0x522d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_RESET_CTL3 (at 0x122da)"
      tindex a:0xfc4cfa00 %l 0x8522da0 0x522da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_PERPH_RESET_CTL4 (at 0x122db)"
      tindex a:0xfc4cfa00 %l 0x8522db0 0x522db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S5_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_FREQ_TEST1 (at 0x122e2)"
      tindex a:0xfc4cfa00 %l 0x8522e20 0x522e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S5_PS"
  tree "S5_PS"
    tree "S5_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION1 (at 0x12100)"
      tindex a:0xfc4cfa00 %l 0x8521000 0x521000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION2 (at 0x12101)"
      tindex a:0xfc4cfa00 %l 0x8521010 0x521010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION3 (at 0x12102)"
      tindex a:0xfc4cfa00 %l 0x8521020 0x521020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_REVISION4 (at 0x12103)"
      tindex a:0xfc4cfa00 %l 0x8521030 0x521030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_TYPE (at 0x12104)"
      tindex a:0xfc4cfa00 %l 0x8521040 0x521040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_SUBTYPE (at 0x12105)"
      tindex a:0xfc4cfa00 %l 0x8521050 0x521050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_PS_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_VOLTAGE_CTL1 (at 0x12140)"
      tindex a:0xfc4cfa00 %l 0x8521400 0x521400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S5_PS_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_VOLTAGE_CTL2 (at 0x12141)"
      tindex a:0xfc4cfa00 %l 0x8521410 0x521410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S5_PS_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_FREQ_CTL (at 0x12150)"
      tindex a:0xfc4cfa00 %l 0x8521500 0x521500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S5_PS_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MULTIPHASE_CTL (at 0x12151)"
      tindex a:0xfc4cfa00 %l 0x8521510 0x521510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S5_PS_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PHASE_CTL (at 0x12152)"
      tindex a:0xfc4cfa00 %l 0x8521520 0x521520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PHASE_ID (at 0x12153)"
      tindex a:0xfc4cfa00 %l 0x8521530 0x521530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PHASE_CNT (at 0x12154)"
      tindex a:0xfc4cfa00 %l 0x8521540 0x521540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_PWM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PWM_CL_CTL (at 0x12160)"
      tindex a:0xfc4cfa00 %l 0x8521600 0x521600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_PS_LPM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_LPM_CL_CTL (at 0x12161)"
      tindex a:0xfc4cfa00 %l 0x8521610 0x521610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_PS_AUTO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_AUTO_CTL (at 0x12162)"
      tindex a:0xfc4cfa00 %l 0x8521620 0x521620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_PS_FSM_MINON_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_FSM_MINON_CFG (at 0x12170)"
      tindex a:0xfc4cfa00 %l 0x8521700 0x521700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_ICOMP_EN_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_ICOMP_EN_CFG (at 0x12171)"
      tindex a:0xfc4cfa00 %l 0x8521710 0x521710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_ZX_CAL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_ZX_CAL_CFG (at 0x12172)"
      tindex a:0xfc4cfa00 %l 0x8521720 0x521720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_NONOVLAP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_NONOVLAP_CFG (at 0x12173)"
      tindex a:0xfc4cfa00 %l 0x8521730 0x521730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_MPHASE_PI_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MPHASE_PI_CFG1 (at 0x12174)"
      tindex a:0xfc4cfa00 %l 0x8521740 0x521740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MPHASE_PI_CFG2 (at 0x12175)"
      tindex a:0xfc4cfa00 %l 0x8521750 0x521750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MPHASE_PI_CFG3 (at 0x12176)"
      tindex a:0xfc4cfa00 %l 0x8521760 0x521760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MPHASE_PI_CFG4 (at 0x12177)"
      tindex a:0xfc4cfa00 %l 0x8521770 0x521770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MPHASE_PI_CFG5 (at 0x12178)"
      tindex a:0xfc4cfa00 %l 0x8521780 0x521780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MPHASE_PI_CFG6 (at 0x12179)"
      tindex a:0xfc4cfa00 %l 0x8521790 0x521790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S5_PS_CAL_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_CAL_FAULT (at 0x1217a)"
      tindex a:0xfc4cfa00 %l 0x85217a0 0x5217a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S5_PS_ADC_OUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_ADC_OUT (at 0x1217b)"
      tindex a:0xfc4cfa00 %l 0x85217b0 0x5217b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S5_PS_MP_IAVG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MP_IAVG2 (at 0x1217c)"
      tindex a:0xfc4cfa00 %l 0x85217c0 0x5217c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S5_PS_MP_IAVG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MP_IAVG1 (at 0x1217d)"
      tindex a:0xfc4cfa00 %l 0x85217d0 0x5217d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S5_PS_MP_DAC_DATA"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_MP_DAC_DATA (at 0x1217e)"
      tindex a:0xfc4cfa00 %l 0x85217e0 0x5217e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S5_PS_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_GANG_CTL1 (at 0x121c0)"
      tindex a:0xfc4cfa00 %l 0x8521c00 0x521c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_PS_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_GANG_CTL2 (at 0x121c1)"
      tindex a:0xfc4cfa00 %l 0x8521c10 0x521c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S5_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_SEC_ACCESS (at 0x121d0)"
      tindex a:0xfc4cfa00 %l 0x8521d00 0x521d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_RESET_CTL1 (at 0x121d8)"
      tindex a:0xfc4cfa00 %l 0x8521d80 0x521d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_RESET_CTL2 (at 0x121d9)"
      tindex a:0xfc4cfa00 %l 0x8521d90 0x521d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_RESET_CTL3 (at 0x121da)"
      tindex a:0xfc4cfa00 %l 0x8521da0 0x521da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_PERPH_RESET_CTL4 (at 0x121db)"
      tindex a:0xfc4cfa00 %l 0x8521db0 0x521db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S5_PS_ATEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_ATEST12 (at 0x121e2)"
      tindex a:0xfc4cfa00 %l 0x8521e20 0x521e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_ATEST34"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_ATEST34 (at 0x121e3)"
      tindex a:0xfc4cfa00 %l 0x8521e30 0x521e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_DTEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_DTEST12 (at 0x121e4)"
      tindex a:0xfc4cfa00 %l 0x8521e40 0x521e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S5_PS_DTEST43"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_DTEST43 (at 0x121e5)"
      tindex a:0xfc4cfa00 %l 0x8521e50 0x521e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S5_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_TRIM_NUM (at 0x121f0)"
      tindex a:0xfc4cfa00 %l 0x8521f00 0x521f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S5_PS_ZX_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_ZX_TRIM (at 0x121f1)"
      tindex a:0xfc4cfa00 %l 0x8521f10 0x521f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S5_PS_CL_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S5_PS_CL_TRIM (at 0x121f2)"
      tindex a:0xfc4cfa00 %l 0x8521f20 0x521f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S6_CTRL"
  tree "S6_CTRL"
    tree "S6_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_REVISION1 (at 0x12300)"
      tindex a:0xfc4cfa00 %l 0x8523000 0x523000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_REVISION2 (at 0x12301)"
      tindex a:0xfc4cfa00 %l 0x8523010 0x523010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_REVISION3 (at 0x12302)"
      tindex a:0xfc4cfa00 %l 0x8523020 0x523020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_REVISION4 (at 0x12303)"
      tindex a:0xfc4cfa00 %l 0x8523030 0x523030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PERPH_TYPE (at 0x12304)"
      tindex a:0xfc4cfa00 %l 0x8523040 0x523040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PERPH_SUBTYPE (at 0x12305)"
      tindex a:0xfc4cfa00 %l 0x8523050 0x523050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_CTRL_STATUS_1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_STATUS_1 (at 0x12308)"
      tindex a:0xfc4cfa00 %l 0x8523080 0x523080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S6_CTRL_STATUS_2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_STATUS_2 (at 0x12309)"
      tindex a:0xfc4cfa00 %l 0x8523090 0x523090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S6_CTRL_STATUS_3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_STATUS_3 (at 0x1230a)"
      tindex a:0xfc4cfa00 %l 0x85230a0 0x5230a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S6_CTRL_STATUS_4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_STATUS_4 (at 0x1230b)"
      tindex a:0xfc4cfa00 %l 0x85230b0 0x5230b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_RT_STS (at 0x12310)"
      tindex a:0xfc4cfa00 %l 0x8523100 0x523100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_SET_TYPE (at 0x12311)"
      tindex a:0xfc4cfa00 %l 0x8523110 0x523110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_POLARITY_HIGH (at 0x12312)"
      tindex a:0xfc4cfa00 %l 0x8523120 0x523120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_POLARITY_LOW (at 0x12313)"
      tindex a:0xfc4cfa00 %l 0x8523130 0x523130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_LATCHED_CLR (at 0x12314)"
      tindex a:0xfc4cfa00 %l 0x8523140 0x523140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_EN_SET (at 0x12315)"
      tindex a:0xfc4cfa00 %l 0x8523150 0x523150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_EN_CLR (at 0x12316)"
      tindex a:0xfc4cfa00 %l 0x8523160 0x523160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_LATCHED_STS (at 0x12318)"
      tindex a:0xfc4cfa00 %l 0x8523180 0x523180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_PENDING_STS (at 0x12319)"
      tindex a:0xfc4cfa00 %l 0x8523190 0x523190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_MID_SEL (at 0x1231a)"
      tindex a:0xfc4cfa00 %l 0x85231a0 0x5231a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_PRIORITY (at 0x1231b)"
      tindex a:0xfc4cfa00 %l 0x85231b0 0x5231b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_VOLTAGE_CTL1 (at 0x12340)"
      tindex a:0xfc4cfa00 %l 0x8523400 0x523400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_VOLTAGE_CTL2 (at 0x12341)"
      tindex a:0xfc4cfa00 %l 0x8523410 0x523410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S6_CTRL_VSET_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_VSET_VALID (at 0x12342)"
      tindex a:0xfc4cfa00 %l 0x8523420 0x523420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_VOLTAGE_CTL3 (at 0x12344)"
      tindex a:0xfc4cfa00 %l 0x8523440 0x523440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_MODE_CTL (at 0x12345)"
      tindex a:0xfc4cfa00 %l 0x8523450 0x523450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S6_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_EN_CTL (at 0x12346)"
      tindex a:0xfc4cfa00 %l 0x8523460 0x523460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S6_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PD_CTL (at 0x12348)"
      tindex a:0xfc4cfa00 %l 0x8523480 0x523480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S6_CTRL_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_FREQ_CTL (at 0x12350)"
      tindex a:0xfc4cfa00 %l 0x8523500 0x523500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S6_CTRL_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_MULTIPHASE_CTL (at 0x12351)"
      tindex a:0xfc4cfa00 %l 0x8523510 0x523510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S6_CTRL_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PHASE_CTL (at 0x12352)"
      tindex a:0xfc4cfa00 %l 0x8523520 0x523520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PHASE_ID (at 0x12353)"
      tindex a:0xfc4cfa00 %l 0x8523530 0x523530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PHASE_CNT (at 0x12354)"
      tindex a:0xfc4cfa00 %l 0x8523540 0x523540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_SS_CTL (at 0x12360)"
      tindex a:0xfc4cfa00 %l 0x8523600 0x523600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_VS_CTL (at 0x12361)"
      tindex a:0xfc4cfa00 %l 0x8523610 0x523610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CORR_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CORR_CFG (at 0x12362)"
      tindex a:0xfc4cfa00 %l 0x8523620 0x523620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S6_CTRL_RAMP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_RAMP_CFG (at 0x12363)"
      tindex a:0xfc4cfa00 %l 0x8523630 0x523630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_COMPENS_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_COMPENS_CFG (at 0x12364)"
      tindex a:0xfc4cfa00 %l 0x8523640 0x523640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_VREG_OK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_VREG_OK (at 0x12365)"
      tindex a:0xfc4cfa00 %l 0x8523650 0x523650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_VREG_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_VREG_FAULT (at 0x12366)"
      tindex a:0xfc4cfa00 %l 0x8523660 0x523660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_PFM_COMP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_PFM_COMP (at 0x12367)"
      tindex a:0xfc4cfa00 %l 0x8523670 0x523670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S6_CTRL_UL_LL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_UL_LL_CTL (at 0x12368)"
      tindex a:0xfc4cfa00 %l 0x8523680 0x523680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S6_CTRL_VSET_ULS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_VSET_ULS (at 0x12369)"
      tindex a:0xfc4cfa00 %l 0x8523690 0x523690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S6_CTRL_ULS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_ULS_VALID (at 0x1236a)"
      tindex a:0xfc4cfa00 %l 0x85236a0 0x5236a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S6_CTRL_VSET_LLS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_VSET_LLS (at 0x1236b)"
      tindex a:0xfc4cfa00 %l 0x85236b0 0x5236b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S6_CTRL_LLS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_LLS_VALID (at 0x1236c)"
      tindex a:0xfc4cfa00 %l 0x85236c0 0x5236c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S6_CTRL_GPL_HI"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_GPL_HI (at 0x1236d)"
      tindex a:0xfc4cfa00 %l 0x85236d0 0x5236d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S6_CTRL_GPL_LO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_GPL_LO (at 0x1236e)"
      tindex a:0xfc4cfa00 %l 0x85236e0 0x5236e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S6_CTRL_CFG_ATEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_ATEST1 (at 0x123b0)"
      tindex a:0xfc4cfa00 %l 0x8523b00 0x523b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_ATEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_ATEST2 (at 0x123b1)"
      tindex a:0xfc4cfa00 %l 0x8523b10 0x523b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_ATEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_ATEST3 (at 0x123b2)"
      tindex a:0xfc4cfa00 %l 0x8523b20 0x523b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_ATEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_ATEST4 (at 0x123b3)"
      tindex a:0xfc4cfa00 %l 0x8523b30 0x523b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_DTEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_DTEST1 (at 0x123b4)"
      tindex a:0xfc4cfa00 %l 0x8523b40 0x523b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_DTEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_DTEST2 (at 0x123b5)"
      tindex a:0xfc4cfa00 %l 0x8523b50 0x523b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_DTEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_DTEST3 (at 0x123b6)"
      tindex a:0xfc4cfa00 %l 0x8523b60 0x523b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_DTEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CFG_DTEST4 (at 0x123b7)"
      tindex a:0xfc4cfa00 %l 0x8523b70 0x523b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_GANG_CTL1 (at 0x123c0)"
      tindex a:0xfc4cfa00 %l 0x8523c00 0x523c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_CTRL_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_GANG_CTL2 (at 0x123c1)"
      tindex a:0xfc4cfa00 %l 0x8523c10 0x523c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S6_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_SEC_ACCESS (at 0x123d0)"
      tindex a:0xfc4cfa00 %l 0x8523d00 0x523d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PERPH_RESET_CTL1 (at 0x123d8)"
      tindex a:0xfc4cfa00 %l 0x8523d80 0x523d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PERPH_RESET_CTL2 (at 0x123d9)"
      tindex a:0xfc4cfa00 %l 0x8523d90 0x523d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PERPH_RESET_CTL3 (at 0x123da)"
      tindex a:0xfc4cfa00 %l 0x8523da0 0x523da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PERPH_RESET_CTL4 (at 0x123db)"
      tindex a:0xfc4cfa00 %l 0x8523db0 0x523db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_TEST1 (at 0x123e0)"
      tindex a:0xfc4cfa00 %l 0x8523e00 0x523e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_INT_TEST_VAL (at 0x123e1)"
      tindex a:0xfc4cfa00 %l 0x8523e10 0x523e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S6_CTRL_MODE_FSM_MASK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_MODE_FSM_MASK (at 0x123e2)"
      tindex a:0xfc4cfa00 %l 0x8523e20 0x523e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S6_CTRL_GATE_DRV_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_GATE_DRV_MUX (at 0x123e3)"
      tindex a:0xfc4cfa00 %l 0x8523e30 0x523e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CORR_DUTY_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CORR_DUTY_MUX (at 0x123e4)"
      tindex a:0xfc4cfa00 %l 0x8523e40 0x523e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_EN_OPTIONS_DFT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_EN_OPTIONS_DFT (at 0x123e5)"
      tindex a:0xfc4cfa00 %l 0x8523e50 0x523e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S6_CTRL_CAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CAL_CTL (at 0x123e8)"
      tindex a:0xfc4cfa00 %l 0x8523e80 0x523e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S6_CTRL_IDAC_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_IDAC_CAL_VAL (at 0x123e9)"
      tindex a:0xfc4cfa00 %l 0x8523e90 0x523e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S6_CTRL_CORR_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CORR_CAL_VAL (at 0x123ea)"
      tindex a:0xfc4cfa00 %l 0x8523ea0 0x523ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S6_CTRL_PWM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PWM_CAL_VAL (at 0x123eb)"
      tindex a:0xfc4cfa00 %l 0x8523eb0 0x523eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S6_CTRL_PFM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PFM_CAL_VAL (at 0x123ec)"
      tindex a:0xfc4cfa00 %l 0x8523ec0 0x523ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S6_CTRL_MPHASE_IDAC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_MPHASE_IDAC (at 0x123ed)"
      tindex a:0xfc4cfa00 %l 0x8523ed0 0x523ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S6_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_TRIM_NUM (at 0x123f0)"
      tindex a:0xfc4cfa00 %l 0x8523f00 0x523f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S6_CTRL_CAL_EN_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CAL_EN_TRIM (at 0x123f1)"
      tindex a:0xfc4cfa00 %l 0x8523f10 0x523f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S6_CTRL_REFDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_REFDAC_TRIM (at 0x123f2)"
      tindex a:0xfc4cfa00 %l 0x8523f20 0x523f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S6_CTRL_IDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_IDAC_TRIM (at 0x123f3)"
      tindex a:0xfc4cfa00 %l 0x8523f30 0x523f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S6_CTRL_CORR_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_CORR_TRIM (at 0x123f4)"
      tindex a:0xfc4cfa00 %l 0x8523f40 0x523f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S6_CTRL_PWM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PWM_TRIM (at 0x123f5)"
      tindex a:0xfc4cfa00 %l 0x8523f50 0x523f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S6_CTRL_PFM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_PFM_TRIM (at 0x123f6)"
      tindex a:0xfc4cfa00 %l 0x8523f60 0x523f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S6_CTRL_RAMP_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_CTRL_RAMP_TRIM (at 0x123f7)"
      tindex a:0xfc4cfa00 %l 0x8523f70 0x523f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S6_FREQ"
  tree "S6_FREQ"
    tree "S6_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_REVISION1 (at 0x12500)"
      tindex a:0xfc4cfa00 %l 0x8525000 0x525000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_REVISION2 (at 0x12501)"
      tindex a:0xfc4cfa00 %l 0x8525010 0x525010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_REVISION3 (at 0x12502)"
      tindex a:0xfc4cfa00 %l 0x8525020 0x525020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_REVISION4 (at 0x12503)"
      tindex a:0xfc4cfa00 %l 0x8525030 0x525030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_PERPH_TYPE (at 0x12504)"
      tindex a:0xfc4cfa00 %l 0x8525040 0x525040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_PERPH_SUBTYPE (at 0x12505)"
      tindex a:0xfc4cfa00 %l 0x8525050 0x525050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_CLK_ENABLE (at 0x12546)"
      tindex a:0xfc4cfa00 %l 0x8525460 0x525460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S6_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_CLK_DIV (at 0x12550)"
      tindex a:0xfc4cfa00 %l 0x8525500 0x525500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S6_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_CLK_PHASE (at 0x12551)"
      tindex a:0xfc4cfa00 %l 0x8525510 0x525510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S6_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_GANG_CTL1 (at 0x125c0)"
      tindex a:0xfc4cfa00 %l 0x8525c00 0x525c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_GANG_CTL2 (at 0x125c1)"
      tindex a:0xfc4cfa00 %l 0x8525c10 0x525c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S6_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_SEC_ACCESS (at 0x125d0)"
      tindex a:0xfc4cfa00 %l 0x8525d00 0x525d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_PERPH_RESET_CTL2 (at 0x125d9)"
      tindex a:0xfc4cfa00 %l 0x8525d90 0x525d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_PERPH_RESET_CTL3 (at 0x125da)"
      tindex a:0xfc4cfa00 %l 0x8525da0 0x525da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_PERPH_RESET_CTL4 (at 0x125db)"
      tindex a:0xfc4cfa00 %l 0x8525db0 0x525db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S6_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_FREQ_TEST1 (at 0x125e2)"
      tindex a:0xfc4cfa00 %l 0x8525e20 0x525e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S6_PS"
  tree "S6_PS"
    tree "S6_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_REVISION1 (at 0x12400)"
      tindex a:0xfc4cfa00 %l 0x8524000 0x524000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_REVISION2 (at 0x12401)"
      tindex a:0xfc4cfa00 %l 0x8524010 0x524010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_REVISION3 (at 0x12402)"
      tindex a:0xfc4cfa00 %l 0x8524020 0x524020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_REVISION4 (at 0x12403)"
      tindex a:0xfc4cfa00 %l 0x8524030 0x524030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PERPH_TYPE (at 0x12404)"
      tindex a:0xfc4cfa00 %l 0x8524040 0x524040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PERPH_SUBTYPE (at 0x12405)"
      tindex a:0xfc4cfa00 %l 0x8524050 0x524050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_PS_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_VOLTAGE_CTL1 (at 0x12440)"
      tindex a:0xfc4cfa00 %l 0x8524400 0x524400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S6_PS_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_VOLTAGE_CTL2 (at 0x12441)"
      tindex a:0xfc4cfa00 %l 0x8524410 0x524410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S6_PS_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_FREQ_CTL (at 0x12450)"
      tindex a:0xfc4cfa00 %l 0x8524500 0x524500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S6_PS_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MULTIPHASE_CTL (at 0x12451)"
      tindex a:0xfc4cfa00 %l 0x8524510 0x524510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S6_PS_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PHASE_CTL (at 0x12452)"
      tindex a:0xfc4cfa00 %l 0x8524520 0x524520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PHASE_ID (at 0x12453)"
      tindex a:0xfc4cfa00 %l 0x8524530 0x524530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PHASE_CNT (at 0x12454)"
      tindex a:0xfc4cfa00 %l 0x8524540 0x524540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_PWM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PWM_CL_CTL (at 0x12460)"
      tindex a:0xfc4cfa00 %l 0x8524600 0x524600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_PS_LPM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_LPM_CL_CTL (at 0x12461)"
      tindex a:0xfc4cfa00 %l 0x8524610 0x524610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_PS_AUTO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_AUTO_CTL (at 0x12462)"
      tindex a:0xfc4cfa00 %l 0x8524620 0x524620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_PS_FSM_MINON_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_FSM_MINON_CFG (at 0x12470)"
      tindex a:0xfc4cfa00 %l 0x8524700 0x524700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_ICOMP_EN_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_ICOMP_EN_CFG (at 0x12471)"
      tindex a:0xfc4cfa00 %l 0x8524710 0x524710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_ZX_CAL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_ZX_CAL_CFG (at 0x12472)"
      tindex a:0xfc4cfa00 %l 0x8524720 0x524720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_NONOVLAP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_NONOVLAP_CFG (at 0x12473)"
      tindex a:0xfc4cfa00 %l 0x8524730 0x524730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_MPHASE_PI_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MPHASE_PI_CFG1 (at 0x12474)"
      tindex a:0xfc4cfa00 %l 0x8524740 0x524740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MPHASE_PI_CFG2 (at 0x12475)"
      tindex a:0xfc4cfa00 %l 0x8524750 0x524750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MPHASE_PI_CFG3 (at 0x12476)"
      tindex a:0xfc4cfa00 %l 0x8524760 0x524760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MPHASE_PI_CFG4 (at 0x12477)"
      tindex a:0xfc4cfa00 %l 0x8524770 0x524770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MPHASE_PI_CFG5 (at 0x12478)"
      tindex a:0xfc4cfa00 %l 0x8524780 0x524780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MPHASE_PI_CFG6 (at 0x12479)"
      tindex a:0xfc4cfa00 %l 0x8524790 0x524790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S6_PS_CAL_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_CAL_FAULT (at 0x1247a)"
      tindex a:0xfc4cfa00 %l 0x85247a0 0x5247a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S6_PS_ADC_OUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_ADC_OUT (at 0x1247b)"
      tindex a:0xfc4cfa00 %l 0x85247b0 0x5247b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S6_PS_MP_IAVG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MP_IAVG2 (at 0x1247c)"
      tindex a:0xfc4cfa00 %l 0x85247c0 0x5247c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S6_PS_MP_IAVG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MP_IAVG1 (at 0x1247d)"
      tindex a:0xfc4cfa00 %l 0x85247d0 0x5247d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S6_PS_MP_DAC_DATA"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_MP_DAC_DATA (at 0x1247e)"
      tindex a:0xfc4cfa00 %l 0x85247e0 0x5247e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S6_PS_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_GANG_CTL1 (at 0x124c0)"
      tindex a:0xfc4cfa00 %l 0x8524c00 0x524c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_PS_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_GANG_CTL2 (at 0x124c1)"
      tindex a:0xfc4cfa00 %l 0x8524c10 0x524c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S6_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_SEC_ACCESS (at 0x124d0)"
      tindex a:0xfc4cfa00 %l 0x8524d00 0x524d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PERPH_RESET_CTL1 (at 0x124d8)"
      tindex a:0xfc4cfa00 %l 0x8524d80 0x524d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PERPH_RESET_CTL2 (at 0x124d9)"
      tindex a:0xfc4cfa00 %l 0x8524d90 0x524d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PERPH_RESET_CTL3 (at 0x124da)"
      tindex a:0xfc4cfa00 %l 0x8524da0 0x524da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_PERPH_RESET_CTL4 (at 0x124db)"
      tindex a:0xfc4cfa00 %l 0x8524db0 0x524db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S6_PS_ATEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_ATEST12 (at 0x124e2)"
      tindex a:0xfc4cfa00 %l 0x8524e20 0x524e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_ATEST34"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_ATEST34 (at 0x124e3)"
      tindex a:0xfc4cfa00 %l 0x8524e30 0x524e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_DTEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_DTEST12 (at 0x124e4)"
      tindex a:0xfc4cfa00 %l 0x8524e40 0x524e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S6_PS_DTEST43"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_DTEST43 (at 0x124e5)"
      tindex a:0xfc4cfa00 %l 0x8524e50 0x524e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S6_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_TRIM_NUM (at 0x124f0)"
      tindex a:0xfc4cfa00 %l 0x8524f00 0x524f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S6_PS_ZX_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_ZX_TRIM (at 0x124f1)"
      tindex a:0xfc4cfa00 %l 0x8524f10 0x524f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S6_PS_CL_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S6_PS_CL_TRIM (at 0x124f2)"
      tindex a:0xfc4cfa00 %l 0x8524f20 0x524f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S7_CTRL"
  tree "S7_CTRL"
    tree "S7_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_REVISION1 (at 0x12600)"
      tindex a:0xfc4cfa00 %l 0x8526000 0x526000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_REVISION2 (at 0x12601)"
      tindex a:0xfc4cfa00 %l 0x8526010 0x526010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_REVISION3 (at 0x12602)"
      tindex a:0xfc4cfa00 %l 0x8526020 0x526020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_REVISION4 (at 0x12603)"
      tindex a:0xfc4cfa00 %l 0x8526030 0x526030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PERPH_TYPE (at 0x12604)"
      tindex a:0xfc4cfa00 %l 0x8526040 0x526040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PERPH_SUBTYPE (at 0x12605)"
      tindex a:0xfc4cfa00 %l 0x8526050 0x526050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_CTRL_STATUS_1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_STATUS_1 (at 0x12608)"
      tindex a:0xfc4cfa00 %l 0x8526080 0x526080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S7_CTRL_STATUS_2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_STATUS_2 (at 0x12609)"
      tindex a:0xfc4cfa00 %l 0x8526090 0x526090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S7_CTRL_STATUS_3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_STATUS_3 (at 0x1260a)"
      tindex a:0xfc4cfa00 %l 0x85260a0 0x5260a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S7_CTRL_STATUS_4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_STATUS_4 (at 0x1260b)"
      tindex a:0xfc4cfa00 %l 0x85260b0 0x5260b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_RT_STS (at 0x12610)"
      tindex a:0xfc4cfa00 %l 0x8526100 0x526100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_SET_TYPE (at 0x12611)"
      tindex a:0xfc4cfa00 %l 0x8526110 0x526110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_POLARITY_HIGH (at 0x12612)"
      tindex a:0xfc4cfa00 %l 0x8526120 0x526120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_POLARITY_LOW (at 0x12613)"
      tindex a:0xfc4cfa00 %l 0x8526130 0x526130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_LATCHED_CLR (at 0x12614)"
      tindex a:0xfc4cfa00 %l 0x8526140 0x526140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_EN_SET (at 0x12615)"
      tindex a:0xfc4cfa00 %l 0x8526150 0x526150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_EN_CLR (at 0x12616)"
      tindex a:0xfc4cfa00 %l 0x8526160 0x526160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_LATCHED_STS (at 0x12618)"
      tindex a:0xfc4cfa00 %l 0x8526180 0x526180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_PENDING_STS (at 0x12619)"
      tindex a:0xfc4cfa00 %l 0x8526190 0x526190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_MID_SEL (at 0x1261a)"
      tindex a:0xfc4cfa00 %l 0x85261a0 0x5261a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_PRIORITY (at 0x1261b)"
      tindex a:0xfc4cfa00 %l 0x85261b0 0x5261b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_VOLTAGE_CTL1 (at 0x12640)"
      tindex a:0xfc4cfa00 %l 0x8526400 0x526400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_VOLTAGE_CTL2 (at 0x12641)"
      tindex a:0xfc4cfa00 %l 0x8526410 0x526410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S7_CTRL_VSET_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_VSET_VALID (at 0x12642)"
      tindex a:0xfc4cfa00 %l 0x8526420 0x526420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_VOLTAGE_CTL3 (at 0x12644)"
      tindex a:0xfc4cfa00 %l 0x8526440 0x526440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_MODE_CTL (at 0x12645)"
      tindex a:0xfc4cfa00 %l 0x8526450 0x526450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S7_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_EN_CTL (at 0x12646)"
      tindex a:0xfc4cfa00 %l 0x8526460 0x526460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S7_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PD_CTL (at 0x12648)"
      tindex a:0xfc4cfa00 %l 0x8526480 0x526480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S7_CTRL_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_FREQ_CTL (at 0x12650)"
      tindex a:0xfc4cfa00 %l 0x8526500 0x526500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S7_CTRL_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_MULTIPHASE_CTL (at 0x12651)"
      tindex a:0xfc4cfa00 %l 0x8526510 0x526510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S7_CTRL_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PHASE_CTL (at 0x12652)"
      tindex a:0xfc4cfa00 %l 0x8526520 0x526520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PHASE_ID (at 0x12653)"
      tindex a:0xfc4cfa00 %l 0x8526530 0x526530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PHASE_CNT (at 0x12654)"
      tindex a:0xfc4cfa00 %l 0x8526540 0x526540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_SS_CTL (at 0x12660)"
      tindex a:0xfc4cfa00 %l 0x8526600 0x526600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_VS_CTL (at 0x12661)"
      tindex a:0xfc4cfa00 %l 0x8526610 0x526610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CORR_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CORR_CFG (at 0x12662)"
      tindex a:0xfc4cfa00 %l 0x8526620 0x526620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S7_CTRL_RAMP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_RAMP_CFG (at 0x12663)"
      tindex a:0xfc4cfa00 %l 0x8526630 0x526630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_COMPENS_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_COMPENS_CFG (at 0x12664)"
      tindex a:0xfc4cfa00 %l 0x8526640 0x526640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_VREG_OK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_VREG_OK (at 0x12665)"
      tindex a:0xfc4cfa00 %l 0x8526650 0x526650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_VREG_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_VREG_FAULT (at 0x12666)"
      tindex a:0xfc4cfa00 %l 0x8526660 0x526660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_PFM_COMP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_PFM_COMP (at 0x12667)"
      tindex a:0xfc4cfa00 %l 0x8526670 0x526670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S7_CTRL_UL_LL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_UL_LL_CTL (at 0x12668)"
      tindex a:0xfc4cfa00 %l 0x8526680 0x526680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S7_CTRL_VSET_ULS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_VSET_ULS (at 0x12669)"
      tindex a:0xfc4cfa00 %l 0x8526690 0x526690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S7_CTRL_ULS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_ULS_VALID (at 0x1266a)"
      tindex a:0xfc4cfa00 %l 0x85266a0 0x5266a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S7_CTRL_VSET_LLS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_VSET_LLS (at 0x1266b)"
      tindex a:0xfc4cfa00 %l 0x85266b0 0x5266b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S7_CTRL_LLS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_LLS_VALID (at 0x1266c)"
      tindex a:0xfc4cfa00 %l 0x85266c0 0x5266c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S7_CTRL_GPL_HI"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_GPL_HI (at 0x1266d)"
      tindex a:0xfc4cfa00 %l 0x85266d0 0x5266d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S7_CTRL_GPL_LO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_GPL_LO (at 0x1266e)"
      tindex a:0xfc4cfa00 %l 0x85266e0 0x5266e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S7_CTRL_CFG_ATEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_ATEST1 (at 0x126b0)"
      tindex a:0xfc4cfa00 %l 0x8526b00 0x526b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_ATEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_ATEST2 (at 0x126b1)"
      tindex a:0xfc4cfa00 %l 0x8526b10 0x526b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_ATEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_ATEST3 (at 0x126b2)"
      tindex a:0xfc4cfa00 %l 0x8526b20 0x526b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_ATEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_ATEST4 (at 0x126b3)"
      tindex a:0xfc4cfa00 %l 0x8526b30 0x526b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_DTEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_DTEST1 (at 0x126b4)"
      tindex a:0xfc4cfa00 %l 0x8526b40 0x526b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_DTEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_DTEST2 (at 0x126b5)"
      tindex a:0xfc4cfa00 %l 0x8526b50 0x526b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_DTEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_DTEST3 (at 0x126b6)"
      tindex a:0xfc4cfa00 %l 0x8526b60 0x526b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_DTEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CFG_DTEST4 (at 0x126b7)"
      tindex a:0xfc4cfa00 %l 0x8526b70 0x526b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_GANG_CTL1 (at 0x126c0)"
      tindex a:0xfc4cfa00 %l 0x8526c00 0x526c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S7_CTRL_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_GANG_CTL2 (at 0x126c1)"
      tindex a:0xfc4cfa00 %l 0x8526c10 0x526c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S7_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_SEC_ACCESS (at 0x126d0)"
      tindex a:0xfc4cfa00 %l 0x8526d00 0x526d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PERPH_RESET_CTL1 (at 0x126d8)"
      tindex a:0xfc4cfa00 %l 0x8526d80 0x526d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PERPH_RESET_CTL2 (at 0x126d9)"
      tindex a:0xfc4cfa00 %l 0x8526d90 0x526d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PERPH_RESET_CTL3 (at 0x126da)"
      tindex a:0xfc4cfa00 %l 0x8526da0 0x526da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PERPH_RESET_CTL4 (at 0x126db)"
      tindex a:0xfc4cfa00 %l 0x8526db0 0x526db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_TEST1 (at 0x126e0)"
      tindex a:0xfc4cfa00 %l 0x8526e00 0x526e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_INT_TEST_VAL (at 0x126e1)"
      tindex a:0xfc4cfa00 %l 0x8526e10 0x526e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S7_CTRL_MODE_FSM_MASK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_MODE_FSM_MASK (at 0x126e2)"
      tindex a:0xfc4cfa00 %l 0x8526e20 0x526e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S7_CTRL_GATE_DRV_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_GATE_DRV_MUX (at 0x126e3)"
      tindex a:0xfc4cfa00 %l 0x8526e30 0x526e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CORR_DUTY_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CORR_DUTY_MUX (at 0x126e4)"
      tindex a:0xfc4cfa00 %l 0x8526e40 0x526e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_EN_OPTIONS_DFT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_EN_OPTIONS_DFT (at 0x126e5)"
      tindex a:0xfc4cfa00 %l 0x8526e50 0x526e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S7_CTRL_CAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CAL_CTL (at 0x126e8)"
      tindex a:0xfc4cfa00 %l 0x8526e80 0x526e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S7_CTRL_IDAC_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_IDAC_CAL_VAL (at 0x126e9)"
      tindex a:0xfc4cfa00 %l 0x8526e90 0x526e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S7_CTRL_CORR_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CORR_CAL_VAL (at 0x126ea)"
      tindex a:0xfc4cfa00 %l 0x8526ea0 0x526ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S7_CTRL_PWM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PWM_CAL_VAL (at 0x126eb)"
      tindex a:0xfc4cfa00 %l 0x8526eb0 0x526eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S7_CTRL_PFM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PFM_CAL_VAL (at 0x126ec)"
      tindex a:0xfc4cfa00 %l 0x8526ec0 0x526ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S7_CTRL_MPHASE_IDAC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_MPHASE_IDAC (at 0x126ed)"
      tindex a:0xfc4cfa00 %l 0x8526ed0 0x526ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S7_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_TRIM_NUM (at 0x126f0)"
      tindex a:0xfc4cfa00 %l 0x8526f00 0x526f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S7_CTRL_CAL_EN_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CAL_EN_TRIM (at 0x126f1)"
      tindex a:0xfc4cfa00 %l 0x8526f10 0x526f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S7_CTRL_REFDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_REFDAC_TRIM (at 0x126f2)"
      tindex a:0xfc4cfa00 %l 0x8526f20 0x526f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S7_CTRL_IDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_IDAC_TRIM (at 0x126f3)"
      tindex a:0xfc4cfa00 %l 0x8526f30 0x526f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S7_CTRL_CORR_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_CORR_TRIM (at 0x126f4)"
      tindex a:0xfc4cfa00 %l 0x8526f40 0x526f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S7_CTRL_PWM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PWM_TRIM (at 0x126f5)"
      tindex a:0xfc4cfa00 %l 0x8526f50 0x526f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S7_CTRL_PFM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_PFM_TRIM (at 0x126f6)"
      tindex a:0xfc4cfa00 %l 0x8526f60 0x526f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S7_CTRL_RAMP_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_CTRL_RAMP_TRIM (at 0x126f7)"
      tindex a:0xfc4cfa00 %l 0x8526f70 0x526f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S7_FREQ"
  tree "S7_FREQ"
    tree "S7_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_REVISION1 (at 0x12800)"
      tindex a:0xfc4cfa00 %l 0x8528000 0x528000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_REVISION2 (at 0x12801)"
      tindex a:0xfc4cfa00 %l 0x8528010 0x528010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_REVISION3 (at 0x12802)"
      tindex a:0xfc4cfa00 %l 0x8528020 0x528020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_REVISION4 (at 0x12803)"
      tindex a:0xfc4cfa00 %l 0x8528030 0x528030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_PERPH_TYPE (at 0x12804)"
      tindex a:0xfc4cfa00 %l 0x8528040 0x528040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_PERPH_SUBTYPE (at 0x12805)"
      tindex a:0xfc4cfa00 %l 0x8528050 0x528050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_CLK_ENABLE (at 0x12846)"
      tindex a:0xfc4cfa00 %l 0x8528460 0x528460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S7_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_CLK_DIV (at 0x12850)"
      tindex a:0xfc4cfa00 %l 0x8528500 0x528500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S7_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_CLK_PHASE (at 0x12851)"
      tindex a:0xfc4cfa00 %l 0x8528510 0x528510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S7_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_GANG_CTL1 (at 0x128c0)"
      tindex a:0xfc4cfa00 %l 0x8528c00 0x528c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S7_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_GANG_CTL2 (at 0x128c1)"
      tindex a:0xfc4cfa00 %l 0x8528c10 0x528c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S7_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_SEC_ACCESS (at 0x128d0)"
      tindex a:0xfc4cfa00 %l 0x8528d00 0x528d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_PERPH_RESET_CTL2 (at 0x128d9)"
      tindex a:0xfc4cfa00 %l 0x8528d90 0x528d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_PERPH_RESET_CTL3 (at 0x128da)"
      tindex a:0xfc4cfa00 %l 0x8528da0 0x528da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_PERPH_RESET_CTL4 (at 0x128db)"
      tindex a:0xfc4cfa00 %l 0x8528db0 0x528db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S7_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_FREQ_TEST1 (at 0x128e2)"
      tindex a:0xfc4cfa00 %l 0x8528e20 0x528e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S7_PS"
  tree "S7_PS"
    tree "S7_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_REVISION1 (at 0x12700)"
      tindex a:0xfc4cfa00 %l 0x8527000 0x527000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_REVISION2 (at 0x12701)"
      tindex a:0xfc4cfa00 %l 0x8527010 0x527010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_REVISION3 (at 0x12702)"
      tindex a:0xfc4cfa00 %l 0x8527020 0x527020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_REVISION4 (at 0x12703)"
      tindex a:0xfc4cfa00 %l 0x8527030 0x527030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PERPH_TYPE (at 0x12704)"
      tindex a:0xfc4cfa00 %l 0x8527040 0x527040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PERPH_SUBTYPE (at 0x12705)"
      tindex a:0xfc4cfa00 %l 0x8527050 0x527050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_PS_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_VOLTAGE_CTL1 (at 0x12740)"
      tindex a:0xfc4cfa00 %l 0x8527400 0x527400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S7_PS_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_VOLTAGE_CTL2 (at 0x12741)"
      tindex a:0xfc4cfa00 %l 0x8527410 0x527410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S7_PS_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_FREQ_CTL (at 0x12750)"
      tindex a:0xfc4cfa00 %l 0x8527500 0x527500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S7_PS_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MULTIPHASE_CTL (at 0x12751)"
      tindex a:0xfc4cfa00 %l 0x8527510 0x527510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S7_PS_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PHASE_CTL (at 0x12752)"
      tindex a:0xfc4cfa00 %l 0x8527520 0x527520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PHASE_ID (at 0x12753)"
      tindex a:0xfc4cfa00 %l 0x8527530 0x527530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PHASE_CNT (at 0x12754)"
      tindex a:0xfc4cfa00 %l 0x8527540 0x527540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_PWM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PWM_CL_CTL (at 0x12760)"
      tindex a:0xfc4cfa00 %l 0x8527600 0x527600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_PS_LPM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_LPM_CL_CTL (at 0x12761)"
      tindex a:0xfc4cfa00 %l 0x8527610 0x527610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_PS_AUTO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_AUTO_CTL (at 0x12762)"
      tindex a:0xfc4cfa00 %l 0x8527620 0x527620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_PS_FSM_MINON_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_FSM_MINON_CFG (at 0x12770)"
      tindex a:0xfc4cfa00 %l 0x8527700 0x527700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_ICOMP_EN_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_ICOMP_EN_CFG (at 0x12771)"
      tindex a:0xfc4cfa00 %l 0x8527710 0x527710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_ZX_CAL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_ZX_CAL_CFG (at 0x12772)"
      tindex a:0xfc4cfa00 %l 0x8527720 0x527720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_NONOVLAP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_NONOVLAP_CFG (at 0x12773)"
      tindex a:0xfc4cfa00 %l 0x8527730 0x527730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_MPHASE_PI_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MPHASE_PI_CFG1 (at 0x12774)"
      tindex a:0xfc4cfa00 %l 0x8527740 0x527740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MPHASE_PI_CFG2 (at 0x12775)"
      tindex a:0xfc4cfa00 %l 0x8527750 0x527750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MPHASE_PI_CFG3 (at 0x12776)"
      tindex a:0xfc4cfa00 %l 0x8527760 0x527760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MPHASE_PI_CFG4 (at 0x12777)"
      tindex a:0xfc4cfa00 %l 0x8527770 0x527770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MPHASE_PI_CFG5 (at 0x12778)"
      tindex a:0xfc4cfa00 %l 0x8527780 0x527780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MPHASE_PI_CFG6 (at 0x12779)"
      tindex a:0xfc4cfa00 %l 0x8527790 0x527790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S7_PS_CAL_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_CAL_FAULT (at 0x1277a)"
      tindex a:0xfc4cfa00 %l 0x85277a0 0x5277a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S7_PS_ADC_OUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_ADC_OUT (at 0x1277b)"
      tindex a:0xfc4cfa00 %l 0x85277b0 0x5277b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S7_PS_MP_IAVG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MP_IAVG2 (at 0x1277c)"
      tindex a:0xfc4cfa00 %l 0x85277c0 0x5277c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S7_PS_MP_IAVG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MP_IAVG1 (at 0x1277d)"
      tindex a:0xfc4cfa00 %l 0x85277d0 0x5277d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S7_PS_MP_DAC_DATA"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_MP_DAC_DATA (at 0x1277e)"
      tindex a:0xfc4cfa00 %l 0x85277e0 0x5277e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S7_PS_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_GANG_CTL1 (at 0x127c0)"
      tindex a:0xfc4cfa00 %l 0x8527c00 0x527c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S7_PS_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_GANG_CTL2 (at 0x127c1)"
      tindex a:0xfc4cfa00 %l 0x8527c10 0x527c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S7_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_SEC_ACCESS (at 0x127d0)"
      tindex a:0xfc4cfa00 %l 0x8527d00 0x527d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PERPH_RESET_CTL1 (at 0x127d8)"
      tindex a:0xfc4cfa00 %l 0x8527d80 0x527d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PERPH_RESET_CTL2 (at 0x127d9)"
      tindex a:0xfc4cfa00 %l 0x8527d90 0x527d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PERPH_RESET_CTL3 (at 0x127da)"
      tindex a:0xfc4cfa00 %l 0x8527da0 0x527da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_PERPH_RESET_CTL4 (at 0x127db)"
      tindex a:0xfc4cfa00 %l 0x8527db0 0x527db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S7_PS_ATEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_ATEST12 (at 0x127e2)"
      tindex a:0xfc4cfa00 %l 0x8527e20 0x527e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_ATEST34"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_ATEST34 (at 0x127e3)"
      tindex a:0xfc4cfa00 %l 0x8527e30 0x527e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_DTEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_DTEST12 (at 0x127e4)"
      tindex a:0xfc4cfa00 %l 0x8527e40 0x527e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S7_PS_DTEST43"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_DTEST43 (at 0x127e5)"
      tindex a:0xfc4cfa00 %l 0x8527e50 0x527e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S7_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_TRIM_NUM (at 0x127f0)"
      tindex a:0xfc4cfa00 %l 0x8527f00 0x527f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S7_PS_ZX_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_ZX_TRIM (at 0x127f1)"
      tindex a:0xfc4cfa00 %l 0x8527f10 0x527f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S7_PS_CL_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S7_PS_CL_TRIM (at 0x127f2)"
      tindex a:0xfc4cfa00 %l 0x8527f20 0x527f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S8_CTRL"
  tree "S8_CTRL"
    tree "S8_CTRL_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_REVISION1 (at 0x12900)"
      tindex a:0xfc4cfa00 %l 0x8529000 0x529000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_CTRL_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_REVISION2 (at 0x12901)"
      tindex a:0xfc4cfa00 %l 0x8529010 0x529010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_CTRL_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_REVISION3 (at 0x12902)"
      tindex a:0xfc4cfa00 %l 0x8529020 0x529020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_CTRL_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_REVISION4 (at 0x12903)"
      tindex a:0xfc4cfa00 %l 0x8529030 0x529030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_CTRL_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PERPH_TYPE (at 0x12904)"
      tindex a:0xfc4cfa00 %l 0x8529040 0x529040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_CTRL_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PERPH_SUBTYPE (at 0x12905)"
      tindex a:0xfc4cfa00 %l 0x8529050 0x529050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_CTRL_STATUS_1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_STATUS_1 (at 0x12908)"
      tindex a:0xfc4cfa00 %l 0x8529080 0x529080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S8_CTRL_STATUS_2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_STATUS_2 (at 0x12909)"
      tindex a:0xfc4cfa00 %l 0x8529090 0x529090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S8_CTRL_STATUS_3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_STATUS_3 (at 0x1290a)"
      tindex a:0xfc4cfa00 %l 0x85290a0 0x5290a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S8_CTRL_STATUS_4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_STATUS_4 (at 0x1290b)"
      tindex a:0xfc4cfa00 %l 0x85290b0 0x5290b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_RT_STS (at 0x12910)"
      tindex a:0xfc4cfa00 %l 0x8529100 0x529100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_SET_TYPE (at 0x12911)"
      tindex a:0xfc4cfa00 %l 0x8529110 0x529110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_POLARITY_HIGH (at 0x12912)"
      tindex a:0xfc4cfa00 %l 0x8529120 0x529120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_POLARITY_LOW (at 0x12913)"
      tindex a:0xfc4cfa00 %l 0x8529130 0x529130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_LATCHED_CLR (at 0x12914)"
      tindex a:0xfc4cfa00 %l 0x8529140 0x529140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_EN_SET (at 0x12915)"
      tindex a:0xfc4cfa00 %l 0x8529150 0x529150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_EN_CLR (at 0x12916)"
      tindex a:0xfc4cfa00 %l 0x8529160 0x529160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_LATCHED_STS (at 0x12918)"
      tindex a:0xfc4cfa00 %l 0x8529180 0x529180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_PENDING_STS (at 0x12919)"
      tindex a:0xfc4cfa00 %l 0x8529190 0x529190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_MID_SEL (at 0x1291a)"
      tindex a:0xfc4cfa00 %l 0x85291a0 0x5291a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_PRIORITY (at 0x1291b)"
      tindex a:0xfc4cfa00 %l 0x85291b0 0x5291b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_VOLTAGE_CTL1 (at 0x12940)"
      tindex a:0xfc4cfa00 %l 0x8529400 0x529400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_VOLTAGE_CTL2 (at 0x12941)"
      tindex a:0xfc4cfa00 %l 0x8529410 0x529410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S8_CTRL_VSET_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_VSET_VALID (at 0x12942)"
      tindex a:0xfc4cfa00 %l 0x8529420 0x529420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_VOLTAGE_CTL3 (at 0x12944)"
      tindex a:0xfc4cfa00 %l 0x8529440 0x529440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_MODE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_MODE_CTL (at 0x12945)"
      tindex a:0xfc4cfa00 %l 0x8529450 0x529450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S8_CTRL_EN_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_EN_CTL (at 0x12946)"
      tindex a:0xfc4cfa00 %l 0x8529460 0x529460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S8_CTRL_PD_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PD_CTL (at 0x12948)"
      tindex a:0xfc4cfa00 %l 0x8529480 0x529480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S8_CTRL_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_FREQ_CTL (at 0x12950)"
      tindex a:0xfc4cfa00 %l 0x8529500 0x529500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S8_CTRL_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_MULTIPHASE_CTL (at 0x12951)"
      tindex a:0xfc4cfa00 %l 0x8529510 0x529510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S8_CTRL_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PHASE_CTL (at 0x12952)"
      tindex a:0xfc4cfa00 %l 0x8529520 0x529520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PHASE_ID (at 0x12953)"
      tindex a:0xfc4cfa00 %l 0x8529530 0x529530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PHASE_CNT (at 0x12954)"
      tindex a:0xfc4cfa00 %l 0x8529540 0x529540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_SS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_SS_CTL (at 0x12960)"
      tindex a:0xfc4cfa00 %l 0x8529600 0x529600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_VS_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_VS_CTL (at 0x12961)"
      tindex a:0xfc4cfa00 %l 0x8529610 0x529610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CORR_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CORR_CFG (at 0x12962)"
      tindex a:0xfc4cfa00 %l 0x8529620 0x529620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S8_CTRL_RAMP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_RAMP_CFG (at 0x12963)"
      tindex a:0xfc4cfa00 %l 0x8529630 0x529630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_COMPENS_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_COMPENS_CFG (at 0x12964)"
      tindex a:0xfc4cfa00 %l 0x8529640 0x529640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_VREG_OK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_VREG_OK (at 0x12965)"
      tindex a:0xfc4cfa00 %l 0x8529650 0x529650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_VREG_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_VREG_FAULT (at 0x12966)"
      tindex a:0xfc4cfa00 %l 0x8529660 0x529660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_PFM_COMP"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_PFM_COMP (at 0x12967)"
      tindex a:0xfc4cfa00 %l 0x8529670 0x529670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S8_CTRL_UL_LL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_UL_LL_CTL (at 0x12968)"
      tindex a:0xfc4cfa00 %l 0x8529680 0x529680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S8_CTRL_VSET_ULS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_VSET_ULS (at 0x12969)"
      tindex a:0xfc4cfa00 %l 0x8529690 0x529690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S8_CTRL_ULS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_ULS_VALID (at 0x1296a)"
      tindex a:0xfc4cfa00 %l 0x85296a0 0x5296a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S8_CTRL_VSET_LLS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_VSET_LLS (at 0x1296b)"
      tindex a:0xfc4cfa00 %l 0x85296b0 0x5296b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S8_CTRL_LLS_VALID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_LLS_VALID (at 0x1296c)"
      tindex a:0xfc4cfa00 %l 0x85296c0 0x5296c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S8_CTRL_GPL_HI"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_GPL_HI (at 0x1296d)"
      tindex a:0xfc4cfa00 %l 0x85296d0 0x5296d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S8_CTRL_GPL_LO"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_GPL_LO (at 0x1296e)"
      tindex a:0xfc4cfa00 %l 0x85296e0 0x5296e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S8_CTRL_CFG_ATEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_ATEST1 (at 0x129b0)"
      tindex a:0xfc4cfa00 %l 0x8529b00 0x529b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_ATEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_ATEST2 (at 0x129b1)"
      tindex a:0xfc4cfa00 %l 0x8529b10 0x529b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_ATEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_ATEST3 (at 0x129b2)"
      tindex a:0xfc4cfa00 %l 0x8529b20 0x529b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_ATEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_ATEST4 (at 0x129b3)"
      tindex a:0xfc4cfa00 %l 0x8529b30 0x529b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_DTEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_DTEST1 (at 0x129b4)"
      tindex a:0xfc4cfa00 %l 0x8529b40 0x529b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_DTEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_DTEST2 (at 0x129b5)"
      tindex a:0xfc4cfa00 %l 0x8529b50 0x529b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_DTEST3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_DTEST3 (at 0x129b6)"
      tindex a:0xfc4cfa00 %l 0x8529b60 0x529b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_DTEST4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CFG_DTEST4 (at 0x129b7)"
      tindex a:0xfc4cfa00 %l 0x8529b70 0x529b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_GANG_CTL1 (at 0x129c0)"
      tindex a:0xfc4cfa00 %l 0x8529c00 0x529c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_CTRL_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_GANG_CTL2 (at 0x129c1)"
      tindex a:0xfc4cfa00 %l 0x8529c10 0x529c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S8_CTRL_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_SEC_ACCESS (at 0x129d0)"
      tindex a:0xfc4cfa00 %l 0x8529d00 0x529d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PERPH_RESET_CTL1 (at 0x129d8)"
      tindex a:0xfc4cfa00 %l 0x8529d80 0x529d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PERPH_RESET_CTL2 (at 0x129d9)"
      tindex a:0xfc4cfa00 %l 0x8529d90 0x529d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PERPH_RESET_CTL3 (at 0x129da)"
      tindex a:0xfc4cfa00 %l 0x8529da0 0x529da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PERPH_RESET_CTL4 (at 0x129db)"
      tindex a:0xfc4cfa00 %l 0x8529db0 0x529db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_TEST1 (at 0x129e0)"
      tindex a:0xfc4cfa00 %l 0x8529e00 0x529e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_INT_TEST_VAL (at 0x129e1)"
      tindex a:0xfc4cfa00 %l 0x8529e10 0x529e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S8_CTRL_MODE_FSM_MASK"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_MODE_FSM_MASK (at 0x129e2)"
      tindex a:0xfc4cfa00 %l 0x8529e20 0x529e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S8_CTRL_GATE_DRV_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_GATE_DRV_MUX (at 0x129e3)"
      tindex a:0xfc4cfa00 %l 0x8529e30 0x529e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CORR_DUTY_MUX"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CORR_DUTY_MUX (at 0x129e4)"
      tindex a:0xfc4cfa00 %l 0x8529e40 0x529e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_EN_OPTIONS_DFT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_EN_OPTIONS_DFT (at 0x129e5)"
      tindex a:0xfc4cfa00 %l 0x8529e50 0x529e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S8_CTRL_CAL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CAL_CTL (at 0x129e8)"
      tindex a:0xfc4cfa00 %l 0x8529e80 0x529e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S8_CTRL_IDAC_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_IDAC_CAL_VAL (at 0x129e9)"
      tindex a:0xfc4cfa00 %l 0x8529e90 0x529e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S8_CTRL_CORR_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CORR_CAL_VAL (at 0x129ea)"
      tindex a:0xfc4cfa00 %l 0x8529ea0 0x529ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S8_CTRL_PWM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PWM_CAL_VAL (at 0x129eb)"
      tindex a:0xfc4cfa00 %l 0x8529eb0 0x529eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S8_CTRL_PFM_CAL_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PFM_CAL_VAL (at 0x129ec)"
      tindex a:0xfc4cfa00 %l 0x8529ec0 0x529ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S8_CTRL_MPHASE_IDAC"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_MPHASE_IDAC (at 0x129ed)"
      tindex a:0xfc4cfa00 %l 0x8529ed0 0x529ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S8_CTRL_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_TRIM_NUM (at 0x129f0)"
      tindex a:0xfc4cfa00 %l 0x8529f00 0x529f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S8_CTRL_CAL_EN_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CAL_EN_TRIM (at 0x129f1)"
      tindex a:0xfc4cfa00 %l 0x8529f10 0x529f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S8_CTRL_REFDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_REFDAC_TRIM (at 0x129f2)"
      tindex a:0xfc4cfa00 %l 0x8529f20 0x529f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S8_CTRL_IDAC_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_IDAC_TRIM (at 0x129f3)"
      tindex a:0xfc4cfa00 %l 0x8529f30 0x529f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S8_CTRL_CORR_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_CORR_TRIM (at 0x129f4)"
      tindex a:0xfc4cfa00 %l 0x8529f40 0x529f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S8_CTRL_PWM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PWM_TRIM (at 0x129f5)"
      tindex a:0xfc4cfa00 %l 0x8529f50 0x529f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S8_CTRL_PFM_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_PFM_TRIM (at 0x129f6)"
      tindex a:0xfc4cfa00 %l 0x8529f60 0x529f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S8_CTRL_RAMP_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_CTRL_RAMP_TRIM (at 0x129f7)"
      tindex a:0xfc4cfa00 %l 0x8529f70 0x529f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S8_FREQ"
  tree "S8_FREQ"
    tree "S8_FREQ_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_REVISION1 (at 0x12b00)"
      tindex a:0xfc4cfa00 %l 0x852b000 0x52b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_FREQ_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_REVISION2 (at 0x12b01)"
      tindex a:0xfc4cfa00 %l 0x852b010 0x52b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_FREQ_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_REVISION3 (at 0x12b02)"
      tindex a:0xfc4cfa00 %l 0x852b020 0x52b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_FREQ_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_REVISION4 (at 0x12b03)"
      tindex a:0xfc4cfa00 %l 0x852b030 0x52b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_FREQ_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_PERPH_TYPE (at 0x12b04)"
      tindex a:0xfc4cfa00 %l 0x852b040 0x52b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_FREQ_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_PERPH_SUBTYPE (at 0x12b05)"
      tindex a:0xfc4cfa00 %l 0x852b050 0x52b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_FREQ_CLK_ENABLE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_CLK_ENABLE (at 0x12b46)"
      tindex a:0xfc4cfa00 %l 0x852b460 0x52b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S8_FREQ_CLK_DIV"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_CLK_DIV (at 0x12b50)"
      tindex a:0xfc4cfa00 %l 0x852b500 0x52b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S8_FREQ_CLK_PHASE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_CLK_PHASE (at 0x12b51)"
      tindex a:0xfc4cfa00 %l 0x852b510 0x52b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S8_FREQ_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_GANG_CTL1 (at 0x12bc0)"
      tindex a:0xfc4cfa00 %l 0x852bc00 0x52bc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_FREQ_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_GANG_CTL2 (at 0x12bc1)"
      tindex a:0xfc4cfa00 %l 0x852bc10 0x52bc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S8_FREQ_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_SEC_ACCESS (at 0x12bd0)"
      tindex a:0xfc4cfa00 %l 0x852bd00 0x52bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_PERPH_RESET_CTL2 (at 0x12bd9)"
      tindex a:0xfc4cfa00 %l 0x852bd90 0x52bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_PERPH_RESET_CTL3 (at 0x12bda)"
      tindex a:0xfc4cfa00 %l 0x852bda0 0x52bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_PERPH_RESET_CTL4 (at 0x12bdb)"
      tindex a:0xfc4cfa00 %l 0x852bdb0 0x52bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S8_FREQ_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_FREQ_TEST1 (at 0x12be2)"
      tindex a:0xfc4cfa00 %l 0x852be20 0x52be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S8_PS"
  tree "S8_PS"
    tree "S8_PS_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_REVISION1 (at 0x12a00)"
      tindex a:0xfc4cfa00 %l 0x852a000 0x52a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_PS_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_REVISION2 (at 0x12a01)"
      tindex a:0xfc4cfa00 %l 0x852a010 0x52a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_PS_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_REVISION3 (at 0x12a02)"
      tindex a:0xfc4cfa00 %l 0x852a020 0x52a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_PS_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_REVISION4 (at 0x12a03)"
      tindex a:0xfc4cfa00 %l 0x852a030 0x52a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_PS_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PERPH_TYPE (at 0x12a04)"
      tindex a:0xfc4cfa00 %l 0x852a040 0x52a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_PS_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PERPH_SUBTYPE (at 0x12a05)"
      tindex a:0xfc4cfa00 %l 0x852a050 0x52a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_PS_VOLTAGE_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_VOLTAGE_CTL1 (at 0x12a40)"
      tindex a:0xfc4cfa00 %l 0x852a400 0x52a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S8_PS_VOLTAGE_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_VOLTAGE_CTL2 (at 0x12a41)"
      tindex a:0xfc4cfa00 %l 0x852a410 0x52a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S8_PS_FREQ_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_FREQ_CTL (at 0x12a50)"
      tindex a:0xfc4cfa00 %l 0x852a500 0x52a500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S8_PS_MULTIPHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MULTIPHASE_CTL (at 0x12a51)"
      tindex a:0xfc4cfa00 %l 0x852a510 0x52a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S8_PS_PHASE_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PHASE_CTL (at 0x12a52)"
      tindex a:0xfc4cfa00 %l 0x852a520 0x52a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_PHASE_ID"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PHASE_ID (at 0x12a53)"
      tindex a:0xfc4cfa00 %l 0x852a530 0x52a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_PHASE_CNT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PHASE_CNT (at 0x12a54)"
      tindex a:0xfc4cfa00 %l 0x852a540 0x52a540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_PWM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PWM_CL_CTL (at 0x12a60)"
      tindex a:0xfc4cfa00 %l 0x852a600 0x52a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_PS_LPM_CL_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_LPM_CL_CTL (at 0x12a61)"
      tindex a:0xfc4cfa00 %l 0x852a610 0x52a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_PS_AUTO_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_AUTO_CTL (at 0x12a62)"
      tindex a:0xfc4cfa00 %l 0x852a620 0x52a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_PS_FSM_MINON_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_FSM_MINON_CFG (at 0x12a70)"
      tindex a:0xfc4cfa00 %l 0x852a700 0x52a700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_ICOMP_EN_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_ICOMP_EN_CFG (at 0x12a71)"
      tindex a:0xfc4cfa00 %l 0x852a710 0x52a710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_ZX_CAL_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_ZX_CAL_CFG (at 0x12a72)"
      tindex a:0xfc4cfa00 %l 0x852a720 0x52a720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_NONOVLAP_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_NONOVLAP_CFG (at 0x12a73)"
      tindex a:0xfc4cfa00 %l 0x852a730 0x52a730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_MPHASE_PI_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MPHASE_PI_CFG1 (at 0x12a74)"
      tindex a:0xfc4cfa00 %l 0x852a740 0x52a740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MPHASE_PI_CFG2 (at 0x12a75)"
      tindex a:0xfc4cfa00 %l 0x852a750 0x52a750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MPHASE_PI_CFG3 (at 0x12a76)"
      tindex a:0xfc4cfa00 %l 0x852a760 0x52a760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MPHASE_PI_CFG4 (at 0x12a77)"
      tindex a:0xfc4cfa00 %l 0x852a770 0x52a770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG5"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MPHASE_PI_CFG5 (at 0x12a78)"
      tindex a:0xfc4cfa00 %l 0x852a780 0x52a780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG6"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MPHASE_PI_CFG6 (at 0x12a79)"
      tindex a:0xfc4cfa00 %l 0x852a790 0x52a790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S8_PS_CAL_FAULT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_CAL_FAULT (at 0x12a7a)"
      tindex a:0xfc4cfa00 %l 0x852a7a0 0x52a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S8_PS_ADC_OUT"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_ADC_OUT (at 0x12a7b)"
      tindex a:0xfc4cfa00 %l 0x852a7b0 0x52a7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S8_PS_MP_IAVG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MP_IAVG2 (at 0x12a7c)"
      tindex a:0xfc4cfa00 %l 0x852a7c0 0x52a7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S8_PS_MP_IAVG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MP_IAVG1 (at 0x12a7d)"
      tindex a:0xfc4cfa00 %l 0x852a7d0 0x52a7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S8_PS_MP_DAC_DATA"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_MP_DAC_DATA (at 0x12a7e)"
      tindex a:0xfc4cfa00 %l 0x852a7e0 0x52a7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S8_PS_GANG_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_GANG_CTL1 (at 0x12ac0)"
      tindex a:0xfc4cfa00 %l 0x852ac00 0x52ac00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_PS_GANG_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_GANG_CTL2 (at 0x12ac1)"
      tindex a:0xfc4cfa00 %l 0x852ac10 0x52ac10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S8_PS_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_SEC_ACCESS (at 0x12ad0)"
      tindex a:0xfc4cfa00 %l 0x852ad00 0x52ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_PS_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PERPH_RESET_CTL1 (at 0x12ad8)"
      tindex a:0xfc4cfa00 %l 0x852ad80 0x52ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PERPH_RESET_CTL2 (at 0x12ad9)"
      tindex a:0xfc4cfa00 %l 0x852ad90 0x52ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PERPH_RESET_CTL3 (at 0x12ada)"
      tindex a:0xfc4cfa00 %l 0x852ada0 0x52ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_PERPH_RESET_CTL4 (at 0x12adb)"
      tindex a:0xfc4cfa00 %l 0x852adb0 0x52adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S8_PS_ATEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_ATEST12 (at 0x12ae2)"
      tindex a:0xfc4cfa00 %l 0x852ae20 0x52ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_ATEST34"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_ATEST34 (at 0x12ae3)"
      tindex a:0xfc4cfa00 %l 0x852ae30 0x52ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_DTEST12"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_DTEST12 (at 0x12ae4)"
      tindex a:0xfc4cfa00 %l 0x852ae40 0x52ae40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S8_PS_DTEST43"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_DTEST43 (at 0x12ae5)"
      tindex a:0xfc4cfa00 %l 0x852ae50 0x52ae50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S8_PS_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_TRIM_NUM (at 0x12af0)"
      tindex a:0xfc4cfa00 %l 0x852af00 0x52af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S8_PS_ZX_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_ZX_TRIM (at 0x12af1)"
      tindex a:0xfc4cfa00 %l 0x852af10 0x52af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S8_PS_CL_TRIM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "S8_PS_CL_TRIM (at 0x12af2)"
      tindex a:0xfc4cfa00 %l 0x852af20 0x52af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION1 (at 0x600)"
      tindex a:0xfc4cfa00 %l 0x8406000 0x406000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION2 (at 0x601)"
      tindex a:0xfc4cfa00 %l 0x8406010 0x406010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION3 (at 0x602)"
      tindex a:0xfc4cfa00 %l 0x8406020 0x406020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_REVISION4 (at 0x603)"
      tindex a:0xfc4cfa00 %l 0x8406030 0x406030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_TYPE (at 0x604)"
      tindex a:0xfc4cfa00 %l 0x8406040 0x406040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_SUBTYPE (at 0x605)"
      tindex a:0xfc4cfa00 %l 0x8406050 0x406050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_ERROR_SYNDROME (at 0x608)"
      tindex a:0xfc4cfa00 %l 0x8406080 0x406080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_RT_STS (at 0x610)"
      tindex a:0xfc4cfa00 %l 0x8406100 0x406100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_SET_TYPE (at 0x611)"
      tindex a:0xfc4cfa00 %l 0x8406110 0x406110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_POLARITY_HIGH (at 0x612)"
      tindex a:0xfc4cfa00 %l 0x8406120 0x406120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_POLARITY_LOW (at 0x613)"
      tindex a:0xfc4cfa00 %l 0x8406130 0x406130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_LATCHED_CLR (at 0x614)"
      tindex a:0xfc4cfa00 %l 0x8406140 0x406140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_EN_SET (at 0x615)"
      tindex a:0xfc4cfa00 %l 0x8406150 0x406150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_EN_CLR (at 0x616)"
      tindex a:0xfc4cfa00 %l 0x8406160 0x406160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_LATCHED_STS (at 0x618)"
      tindex a:0xfc4cfa00 %l 0x8406180 0x406180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_PENDING_STS (at 0x619)"
      tindex a:0xfc4cfa00 %l 0x8406190 0x406190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_MID_SEL (at 0x61a)"
      tindex a:0xfc4cfa00 %l 0x84061a0 0x4061a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_PRIORITY (at 0x61b)"
      tindex a:0xfc4cfa00 %l 0x84061b0 0x4061b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_SPMI_BUF_CFG (at 0x640)"
      tindex a:0xfc4cfa00 %l 0x8406400 0x406400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_SEC_ACCESS (at 0x6d0)"
      tindex a:0xfc4cfa00 %l 0x8406d00 0x406d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
      tindex a:0xfc4cfa00 %l 0x8406d90 0x406d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
      tindex a:0xfc4cfa00 %l 0x8406da0 0x406da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
      tindex a:0xfc4cfa00 %l 0x8406db0 0x406db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SPMI_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_TEST1 (at 0x6e0)"
      tindex a:0xfc4cfa00 %l 0x8406e00 0x406e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_INT_TEST_VAL (at 0x6e1)"
      tindex a:0xfc4cfa00 %l 0x8406e10 0x406e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0, 1"
    tree.end
    tree "SPMI_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_TEST1 (at 0x6e2)"
      tindex a:0xfc4cfa00 %l 0x8406e20 0x406e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
      tindex a:0xfc4cfa00 %l 0x8606440 0x606440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
      tindex a:0xfc4cfa00 %l 0x8606450 0x606450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
      tindex a:0xfc4cfa00 %l 0x8606460 0x606460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
      tindex a:0xfc4cfa00 %l 0x8606470 0x606470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION1 (at 0x2400)"
      tindex a:0xfc4cfa00 %l 0x8424000 0x424000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION2 (at 0x2401)"
      tindex a:0xfc4cfa00 %l 0x8424010 0x424010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION3 (at 0x2402)"
      tindex a:0xfc4cfa00 %l 0x8424020 0x424020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_REVISION4 (at 0x2403)"
      tindex a:0xfc4cfa00 %l 0x8424030 0x424030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
      tindex a:0xfc4cfa00 %l 0x8424040 0x424040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
      tindex a:0xfc4cfa00 %l 0x8424050 0x424050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_STATUS1 (at 0x2408)"
      tindex a:0xfc4cfa00 %l 0x8424080 0x424080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_RT_STS (at 0x2410)"
      tindex a:0xfc4cfa00 %l 0x8424100 0x424100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
      tindex a:0xfc4cfa00 %l 0x8424110 0x424110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
      tindex a:0xfc4cfa00 %l 0x8424120 0x424120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
      tindex a:0xfc4cfa00 %l 0x8424130 0x424130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
      tindex a:0xfc4cfa00 %l 0x8424140 0x424140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_EN_SET (at 0x2415)"
      tindex a:0xfc4cfa00 %l 0x8424150 0x424150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
      tindex a:0xfc4cfa00 %l 0x8424160 0x424160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
      tindex a:0xfc4cfa00 %l 0x8424180 0x424180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
      tindex a:0xfc4cfa00 %l 0x8424190 0x424190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
      tindex a:0xfc4cfa00 %l 0x84241a0 0x4241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
      tindex a:0xfc4cfa00 %l 0x84241b0 0x4241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
      tindex a:0xfc4cfa00 %l 0x8424400 0x424400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
      tindex a:0xfc4cfa00 %l 0x8424420 0x424420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_EN_CTL1 (at 0x2446)"
      tindex a:0xfc4cfa00 %l 0x8424460 0x424460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0, 1"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
      tindex a:0xfc4cfa00 %l 0x8424d00 0x424d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
      tindex a:0xfc4cfa00 %l 0x8424d80 0x424d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
      tindex a:0xfc4cfa00 %l 0x8424d90 0x424d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
      tindex a:0xfc4cfa00 %l 0x8424da0 0x424da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
      tindex a:0xfc4cfa00 %l 0x8424db0 0x424db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
      tindex a:0xfc4cfa00 %l 0x8424e00 0x424e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
      tindex a:0xfc4cfa00 %l 0x8424e10 0x424e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0, 1"
    tree.end
    tree "TEMP_ALARM_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TEST1 (at 0x24e2)"
      tindex a:0xfc4cfa00 %l 0x8424e20 0x424e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_TEST2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TEST2 (at 0x24e3)"
      tindex a:0xfc4cfa00 %l 0x8424e30 0x424e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0, 1"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
      tindex a:0xfc4cfa00 %l 0x8424f00 0x424f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
      tindex a:0xfc4cfa00 %l 0x8424f10 0x424f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION1 (at 0xfe00)"
      tindex a:0xfc4cfa00 %l 0x84fe000 0x4fe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION2 (at 0xfe01)"
      tindex a:0xfc4cfa00 %l 0x84fe010 0x4fe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION3 (at 0xfe02)"
      tindex a:0xfc4cfa00 %l 0x84fe020 0x4fe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_REVISION4 (at 0xfe03)"
      tindex a:0xfc4cfa00 %l 0x84fe030 0x4fe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_TYPE (at 0xfe04)"
      tindex a:0xfc4cfa00 %l 0x84fe040 0x4fe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_SUBTYPE (at 0xfe05)"
      tindex a:0xfc4cfa00 %l 0x84fe050 0x4fe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
      tindex a:0xfc4cfa00 %l 0x84fe080 0x4fe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0, 1"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_OTP_PROG_STATUS (at 0xfe09)"
      tindex a:0xfc4cfa00 %l 0x84fe090 0x4fe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0, 1"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
      tindex a:0xfc4cfa00 %l 0x84fe0a0 0x4fe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
      tindex a:0xfc4cfa00 %l 0x84fe0b0 0x4fe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_SEC_ACCESS (at 0xfed0)"
      tindex a:0xfc4cfa00 %l 0x84fed00 0x4fed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_RESET_CTL1 (at 0xfed8)"
      tindex a:0xfc4cfa00 %l 0x84fed80 0x4fed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
      tindex a:0xfc4cfa00 %l 0x84fed90 0x4fed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0, 1"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
      tindex a:0xfc4cfa00 %l 0x84feda0 0x4feda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
      tindex a:0xfc4cfa00 %l 0x84fedb0 0x4fedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
      tindex a:0xfc4cfa00 %l 0x84fee00 0x4fee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0, 1, 2, 3"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
      tindex a:0xfc4cfa00 %l 0x84fee10 0x4fee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
      tindex a:0xfc4cfa00 %l 0x84fee20 0x4fee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0, 1"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
      tindex a:0xfc4cfa00 %l 0x84fee30 0x4fee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0, 1"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
      tindex a:0xfc4cfa00 %l 0x84fee40 0x4fee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0, 1"
    tree.end
    tree "TRIM_TEST1"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TEST1 (at 0xfee5)"
      tindex a:0xfc4cfa00 %l 0x84fee50 0x4fee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      wsgroup.long a:0xfc4cfa10++3 a:0xfc4cfa18 "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
      tindex a:0xfc4cfa00 %l 0x84fee60 0x4fee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0, 1"
    tree.end
  tree.end
tree.end
