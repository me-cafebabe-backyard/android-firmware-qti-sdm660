;----------------------------------------------------------------------------
;  Name: Gladiator_Registers.per
;    Present the Gladiator Register Description Details
;    inputs :
;       access_port : s3_s4_cpu / s2_qdss_cfg / s2_dap_apb
;  PoC:
;    c_apate / SWArch
;
; Copyright (c) 2006-2015 by QUALCOMM, Incorporated.  All Rights Reserved.
;---------------------------------------------------------------
;TODO: Need to enhance to access the registers from DAP.



;&gladiator_s3_s4_base_addr=0x17900000
;&gladiator_s2_qdss_cfg_base_addr=0x07BA0000  
;&gladiator_s2_apb_base_addr=0x87BA0000  

;BASE Data.Long(base_pointer)

; Allow non-secure access to gladiator registers via S3/S4 port ( clear NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSET0[bit0])
;d.s z:0x801C2450 %LE %LONG (d.long(z:0x801C2450)|(0x1))

; Allow non-secure access to gladiator registers via S2 port ( clear APCS_COMMON_CCI_INPUT_CFG[bit3])
;d.s ezaxi:0x0B1D1100 %LE %LONG (d.long(ezaxi:0x0B1D1100)&~(0x00000008))

config 16. 8.
width 6.

base eapb:0x87BA0000
  tree "Gladiator_Main_Crixus"
    tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ID_COREID"
      group.long 0x0--0x3 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ID_COREID (at 0x87BA0000)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ID_REVISIONID"
      group.long 0x4--0x7 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ID_REVISIONID (at 0x87BA0004)"
      line.long 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.long 0x0 0x8--0x1F 1 "  [31:8]   QNOCID                    = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                    = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGIO"
      group.long 0x8--0xB "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGIO (at 0x87BA0008)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x5 "    FORCENOFULLWR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4 "    FORCEFULLWR                         = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x3 "    FORCENOWRMERGE                      = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x2 "    FORCENORDFWD                        = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x1 "    FORCEMINSNPDATA                     = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x0 "    ENSNOOP                             = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGDUT"
      group.long 0x78--0x7B "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGDUT (at 0x87BA0078)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F    " [ 31: 18]  RESERVED_BITS31_18            = "
	  textline ""
	  bitfld.long 0x0 0x11--0x11 "  [    17]   STALLSNONEVFIFOFULL                   = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x10--0x10 " [    16]   DISDIRONPARERR	                     = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0xF--0xF "   [    15]   OPTEXTDVM		                         = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0xE--0xE "   [    14]   DISEXTDVM 		                     = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0xD--0xD "   [    13]   ENDICONNERRLOG	                     = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0xC--0xC "   [    12]   ENACCONNERRLOG	                     = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0xB--0xB "   [    11]   ENPARRERRLOG	                         = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x9--0xA "   [ 10: 9]   CULOCKFAILRATE                         = " "0, 1, 2, 3"
	  textline ""
	  bitfld.long 0x0 0x7--0x8 "   [ 8: 7]    EXCLMODE   	                         = " "0, 1, 2, 3"
	  textline ""
	  bitfld.long 0x0 0x6--0x6 "   [    6]    NORDFWDSTNDFWD	                     = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x0--0x5 "   [ 5: 0]    SPETHR                                 = " "0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31"
    tree.end
		tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE0CTL"
      group.long 0x84--0x87 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE0CTL (at 0x87BA0084)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x4--0x1F 1 " [ 31: 4]  RESERVED_BITS31_4                 = "
	  bitfld.long 0x0 0x4--0x4 "   [    4]    RstNeedFlush		                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x3--0x3 "   [    3]    EnEWRalloc		                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x2--0x2 "   [    2]    EnEWRbuf			                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x1--0x1 "   [    1]    NotUsed			                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "   [    0]    EnSpeRd			                      = " "0, 1"
	tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE0STS"
      group.long 0x88--0x8B "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE0STS : (at 0x87BA0088)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  RESERVED_BITS31_8                = "
	  textline ""
	  rbitfld.long 0x0 0x7--0x7 "   [    7]    NeedFlush		                      = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x4--0x6 "   [ 6: 4]    DirStatus			                  = " "0, 1, 2, 3, 4, 5, 6, 7"
	  textline ""
	  rbitfld.long 0x0 0x2--0x3 "   [ 3: 2]    DiPwrCtl			                      = " "0, 1, 2, 3"
	  textline ""
	  rbitfld.long 0x0 0x0--0x1 "   [ 1: 0]    AcPwrCtl			                      = " "0, 1, 2, 3"
	tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE1NSNCTOMEM"
      group.long 0xA0--0xA3 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE1NSNCTOMEM  : (at 0x87BA00A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F 1 " [ 31: 1]  RESERVED_BITS31_1                = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "   [    0]    Ace1NsNcToMem			                  = " "0, 1"
	tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE1CTL"
      group.long 0xA4--0xA7 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE1CTL (at 0x87BA00A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x4--0x1F 1 " [ 31: 4]  RESERVED_BITS31_4                 = "
	  bitfld.long 0x0 0x4--0x4 "   [    4]    RstNeedFlush		                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x3--0x3 "   [    3]    EnEWRalloc		                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x2--0x2 "   [    2]    EnEWRbuf			                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x1--0x1 "   [    1]    NotUsed			                      = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "   [    0]    EnSpeRd			                      = " "0, 1"
	tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE1STS"
      group.long 0xA8--0xAB "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ACE1STS  (at 0x87BA00A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  RESERVED_BITS31_8                = "
	  textline ""
	  rbitfld.long 0x0 0x7--0x7 "   [    7]    NeedFlush		                      = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x4--0x6 "   [ 6: 4]    DirStatus			                  = " "0, 1, 2, 3, 4, 5, 6, 7"
	  textline ""
	  rbitfld.long 0x0 0x2--0x3 "   [ 3: 2]    DiPwrCtl			                      = " "0, 1, 2, 3"
	  textline ""
	  rbitfld.long 0x0 0x0--0x1 "   [ 1: 0]    AcPwrCtl			                      = " "0, 1, 2, 3"
	tree.end
tree.end	

tree "CCI_Gladiator_Main_Crixus_DumpInfo"
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMPINFO"
      group.long 0x1000--0x1003 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMPINFO (at 0x87BA1000)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.byte 0x0 0x18--0x1F 1 "  [ 31: 24]  STEP                          = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x17 1 "  [ 23: 0]   INFO                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGDUMP"
      group.long 0x1004--0x1007 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGDUMP (at 0x87BA1004)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.byte 0x0 0x1D--0x1F 1 " [ 31: 29]  RESERVED_BITS31_29           = "
	  textline ""
	  bitfld.long 0x0 0x1C--0x1C "  [    28]   SELPOS                              = " "0, 1"
	  textline ""
	  hexmask.long.long 0x0 0x18--0x19 1 " [ 25: 24]  SELTABLE                     = "
	  textline ""
	  hexmask.long.long 0x0 0x16--0x17 1 " [ 23: 22]  RESERVED_BITS23_22           = "
	  textline ""
	  hexmask.long.long 0x0 0x10--0x15 1 " [ 21: 16]  INDEX                        = "
	  textline ""
	  hexmask.long.long 0x0 0x2--0xF 1 " [ 15: 2]  RESERVED_BITS15_2               = "
	  textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NOTAUTO                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DUMP                                   = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMP0"
      group.long 0x1008--0x100B "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMP0  (at 0x87BA1008)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.byte 0x0 0x18--0x1F 1 " [ 31: 24]  SELECHO                       = "
	  textline ""
	  rbitfld.long 0x0 0x17  " VALID                                                = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x16  " ISWR                                                 = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x15  " HASSPE                                               = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x14  " SPEINV                                               = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x13  " SPERSPKP                                             = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x12  " SPERSPDP                                             = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x11  " SNPDONE                                              = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0xF--0xF 1 " [    15]  SELPOS			                    = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0xC--0xE 1 " [ 14: 12]  SRCIDX                               = " "0, 1"
	  textline ""
	  hexmask.long.word 0x0 0x0--0xB 1 " [ 11: 0]  ADDRMSB                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMP1"
      group.long 0x100C--0x100F "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMP1 (at 0x87BA100C)"
      line.long 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.long 0x0 0x0--0x1F 1 "  [31:0]   DUMP1                           = "
      tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_FAULTEN"
      group.long 0x1010--0x1013 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_FAULTEN (at 0x87BA1010)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x1--0x1F 1 " [ 31: 1]  RESERVED_BITS31_1               = "
      textline ""
      bitfld.long 0x0 0x0   " FAULTEN                                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRVLD"
      group.long 0x1014--0x1017 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRVLD (at 0x87BA1014)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x1--0x1F 1 " [ 31: 1]  RESERVED_BITS31_1               = "
      textline ""
      rbitfld.long 0x0 0x0   " ERRVLD                                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRCLR"
      group.long 0x1018--0x101B "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRCLR (at 0x87BA1018)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x1--0x1F 1 " [ 31: 1]  RESERVED_BITS31_1               = "
      textline ""
      bitfld.long 0x0 0x0   " ERRCLR                                                = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG0"
      group.long 0x101C--0x101F "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG0 : 0x1790101C (at 0x87BA101C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  rbitfld.long 0x0 0x1F   " FORMAT                                              = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x10--0x1B " [ 27: 16]  LEN1               	                = " 
	  textline ""
	  rbitfld.long 0x0 0x8--0xA " [ 10: 8]  ERRTYPE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
	  textline ""
	  rbitfld.long 0x0 0x1--0x3 " [ 3: 1]  OPC                                      = " "0, 1, 2, 3, 4, 5, 6, 7"
	  textline ""
	  rbitfld.long 0x0 0x0   " LOCK                                                 = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG1"
      group.long 0x1020--0x1023 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG1 (at 0x87BA1020)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F 1 " [ 31: 3]  RESERVED_BITS31_3               = "
      textline ""
      rbitfld.long 0x0 0x0--0x2 " [ 2: 0]  ERRLOG1   Initiator Id                    = " "-1, 0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG2"
      group.long 0x1024--0x1027 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG2 (at 0x87BA1024)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x3--0x1F 1 " [ 31: 3]  RESERVED_BITS31_3                = "
      textline ""
      rbitfld.long 0x0 0x0--0x2 " [ 2: 0]  ERRLOG2  Target ID                        = " "-1, 0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG3"
      group.long 0x1028--0x102B "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG3 (at 0x80BA1028)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F 1 " [ 31: 0]  ERRLOG3 Addr[31:0] 		        = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG4"
      group.long 0x102C--0x102F "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG4 (at 0x80BA102C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F 1 " [ 31: 0]  ERRLOG4  Addr[63:32]            = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG5"
      group.long 0x1030--0x1033 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG5 (at 0x80BA1030)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F 1 " [ 31: 0]  ERRLOG5  User[31: 0]             = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG6"
      group.long 0x1034--0x1037 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG6 (at 0x80BA1034)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F 1 " [ 31: 0]  ERRLOG6  User[63:32]              = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG8"
      group.long 0x103C--0x103F "APCS_CCI_GLADIATOR_MAIN_CRIXUS_ERRLOG8 (at 0x87BA103C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F 1 " [ 31: 0]  ERRLOG6  User[95:64]              = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGDUMPDIR"
      group.long 0x1040--0x1043 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_CFGDUMPDIR (at 0x87BA1040)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  bitfld.long 0x0 0x10--0x10 "  [    16]   ENDUMPDIR                          = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0xF--0xF "  [    15]   SET	                              = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0xD--0xE "  [ 14: 13]  PORT                                 = " "0, 1, 2, 3"
	  textline ""
      bitfld.long 0x0 0xC--0xC "  [    12]   BANK	                              = " "0, 1"
      textline ""
      hexmask.long.tbyte 0x0 0x0--0xB "  [ 11: 0]   INDEX                         = " 
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_STSDUMPDIR"
      group.long 0x1044--0x1047 "APCS_CCI_GLADIATOR_MAIN_CRIXUS_STSDUMPDIR : (at 0x87BA1044)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  bitfld.long 0x0 0x10--0x14 "  [ 20: 16]   WORD                             = " "0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31"
	  textline ""
	  hexmask.long.tbyte 0x0 0x4--0xF "  [ 15: 4]   INDEX                        = " 
	  textline ""
	  bitfld.long 0x0 0x3--0x3 "  [    3]  BANK                                  = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RSV	                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PORT		                         = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMPDIR"
      group.long 0x1048--0x104B "APCS_CCI_GLADIATOR_MAIN_CRIXUS_DUMPDIR : 0x17901048 (at 0x87BA1048)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F 1 " [ 31: 0]  DUMPDIR             = "
    tree.end
tree.end
tree "CCI_PD_GNOC_Main_ProgPowerController"	
	tree "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_ID_COREID"
      group.long 0x4000--0x4003 "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_ID_COREID (at 0x87BA4000)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_ID_REVISIONID"
      group.long 0x4004--0x4007 "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_ID_REVISIONID (at 0x87BA4004)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_TARGET0"
      group.long 0x4008--0x400B "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_TARGET0 (at 0x87BA4008)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x3 "    ALTHWIDLEREQ                       = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x2 "    ALTHWEN		                       = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x1 "    IDLEACK		                       = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x0 "    IDLEREQ                             = " "0, 1"
    tree.end
	tree "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_TARGET1"
      group.long 0x400C--0x400F "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_TARGET0 (at 0x87BA400C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x3 "    ALTHWIDLEREQ                       = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x2 "    ALTHWEN		                       = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x1 "    IDLEACK		                       = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x0 "    IDLEREQ                             = " "0, 1"
    tree.end
	tree "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_TARGET2"
      group.long 0x4010--0x4013 "APCS_CCI_PD_GNOC_MAIN_PROGPOWERCONTROLLER_TARGET0 (at 0x87BA4010)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x3 "    ALTHWIDLEREQ                       = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x2 "    ALTHWEN		                       = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x1 "    IDLEACK		                       = " "0, 1"
	  textline ""
	  bitfld.long 0x0 0x0 "    IDLEREQ                             = " "0, 1"
    tree.end
tree.end	
tree "CCI_NS_Main_SidebandManager"
	tree "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID"
      group.long 0x4100--0x4103 "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID (at 0x87BA4100)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID"
      group.long 0x4104--0x4107 "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID (at 0x87BA4104)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSET0"
      group.long 0x4150--0x4153 "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSET0 (at 0x87BA4150)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0--0x2 "    FLAGOUTSET0                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTCLR0"
      group.long 0x4154--0x4157 "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTCLR0  (at 0x87BA4154)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0--0x2 "    FLAGOUTCLR0                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSTATUS0"
      group.long 0x4158--0x415B "APCS_CCI_NS_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSTATUS0 (at 0x87BA4158)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x0--0x2 "    FLAGOUTSTATUS0                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
tree.end	
tree "CCI_Mmap_Modes_Main_SidebandManager"
	tree "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID"
      group.long 0x4200--0x4203 "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID (at 0x87BA4200)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID"
      group.long 0x4204--0x4207 "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID (at 0x87BA4204)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSET0"
      group.long 0x4250--0x4253 "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSET0 (at 0x87BA4250)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0  "    FLAGOUTSET0                             = " "0, 1"
    tree.end
	tree "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTCLR0"
      group.long 0x4254--0x4257 "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTCLR0 (at 0x87BA4254)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0 "    FLAGOUTCLR0                             = " "0, 1"
    tree.end
	tree "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSTATUS0"
      group.long 0x4258--0x425B "APCS_CCI_MMAP_MODES_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGOUTSTATUS0 (at 0x87BA4258)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x0 "    FLAGOUTSTATUS0                             = " "0, 1"
    tree.end
tree.end
tree "CCI_Gladiator_Trace_Main_ErrorLogger"	
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ID_COREID"
      group.long 0x8000--0x8003 "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ID_COREID (at 0x87BA8000)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ID_REVISIONID"
      group.long 0x8004--0x8007 "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ID_REVISIONID (at 0x87BA8004)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_FAULTEN"
      group.long 0x8008--0x800B "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_FAULTEN (at 0x87BA8008)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0  "    FAULTEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRVLD"
      group.long 0x800C--0x800F "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRVLD (at 0x87BA800C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x0 "    ERRVLD                             = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRCLR"
      group.long 0x8010--0x8013 "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRCLR (at 0x87BA8010)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0 "    ERRVLD                             = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG0"
      group.long 0x8014--0x8017 "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG0 (at 0x87BA8014)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  rbitfld.long 0x0 0x1F   " FORMAT                                              = " "0, 1"
	  textline ""
	  rbitfld.long 0x0 0x10--0x18 " [ 24: 16]  LEN1               	                = " 
	  textline ""
	  rbitfld.long 0x0 0x8--0xA " [ 10: 8]  ERRCODE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
	  textline ""
	  rbitfld.long 0x0 0x1--0x4 " [ 4: 1]  OPC                                      = " "0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15"
	  textline ""
	  rbitfld.long 0x0 0x0   " LOCK                                                 = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG1"
      group.long 0x8018--0x801B "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG1 (at 0x87BA8018)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  ERRLOG11                           = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG2"
      group.long 0x801C--0x801F "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG2 (at 0x87BA801C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  rbitfld.long 0x0 0x0--0x2   " ERRLOG2                                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG3"
      group.long 0x8020--0x8023 "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG3 (at 0x87BA8020)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  ERRLOG3                             = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG4"
      group.long 0x8024--0x8027 "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG4 (at 0x87BA8024)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x0--0xB " [ 11: 0]  ERRLOG4                           = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG5"
      group.long 0x8028--0x802B "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG5 (at 0x87BA8028)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  ERRLOG5                           = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG7"
      group.long 0x8030--0x8033 "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_ERRLOG7 (at 0x87BA8030)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x0  "    ERRLOG7                             = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_STALLEN"
      group.long 0x8038--0x803B "APCS_CCI_GLADIATOR_TRACE_MAIN_ERRORLOGGER_0_STALLEN (at 0x87BA8038)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0  "    STALLEN                             = " "0, 1"
    tree.end
tree.end	
tree "CCI_ERR_Main_SideBandManager"	
	tree "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID"
      group.long 0x8100--0x8103 "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID (at 0x87BA8100)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID"
      group.long 0x8104--0x8107 "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID (at 0x87BA8104)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTEN"
      group.long 0x8108--0x810B "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTEN (at 0x87BA8108)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0  "    FAULTEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTSTATUS"
      group.long 0x810C--0x810F "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTSTATUS (at 0x87BA810C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x0  "    FAULTSTATUS                             = " "0, 1"
    tree.end
	tree "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINEN0"
      group.long 0x8110--0x8113 "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINEN0 (at 0x87BA8110)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  bitfld.long 0x0 0x0--0x1   " FLAGINEN0                                           = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINSTATUS0"
      group.long 0x8114--0x8117 "APCS_CCI_ERR_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINSTATUS0 (at 0x87BA8114)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  rbitfld.long 0x0 0x0--0x1   " FLAGINSTATUS0                                           = " "0, 1, 2, 3"
    tree.end
tree.end
tree "CCI_NOPNDG_Main_SideBandManager"		
	tree "APCS_CCI_NOPNDG_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID"
      group.long 0x8200--0x8203 "APCS_CCI_NOPNDG_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID (at 0x87BA8200)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                        = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_NOPNDG_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID"
      group.long 0x8204--0x8207 "APCS_CCI_NOPNDG_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID (at 0x87BA8204)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_NOPNDG_SIDEBANDS_MAIN_SIDEBANDMANAGER_SENSEIN0"
      group.long 0x82B0--0x82B3 "APCS_CCI_NOPNDG_SIDEBANDS_MAIN_SIDEBANDMANAGER_SENSEIN0 (at 0x87BA82B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SENSEIN0                          = "
    tree.end
tree.end
tree "CCI_PERF_Main_SideBandManager"		
	tree "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID"
      group.long 0x8300--0x8303 "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID (at 0x87BA8300)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID"
      group.long 0x8304--0x8307 "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID (at 0x87BA8304)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTEN"
      group.long 0x8308--0x830B "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTEN (at 0x87BA8308)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      bitfld.long 0x0 0x0  "    FAULTEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTSTATUS"
      group.long 0x830C--0x830F "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FAULTSTATUS (at 0x87BA830C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      rbitfld.long 0x0 0x0  "    FAULTSTATUS                             = " "0, 1"
    tree.end
	tree "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINEN0"
      group.long 0x8310--0x8313 "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINEN0 (at 0x87BA8310)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  bitfld.long 0x0 0x0   " FLAGINEN0                                           = " "0, 1"
    tree.end
	tree "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINSTATUS0"
      group.long 0x8314--0x8317 "APCS_CCI_PERF_SIDEBANDS_MAIN_SIDEBANDMANAGER_FLAGINSTATUS0 (at 0x87BA8314)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  rbitfld.long 0x0 0x0   " FLAGINSTATUS0                                           = " "0, 1"
    tree.end
tree.end
tree "CCI_PWACTIVE_Main_SideBandManager"		
    tree "APCS_CCI_PWRACTIVE_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID"
      group.long 0x8400--0x8403 "APCS_CCI_PWRACTIVE_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_COREID (at 0x87BA8400)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_PWRACTIVE_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID"
      group.long 0x8404--0x8407 "APCS_CCI_PWRACTIVE_SIDEBANDS_MAIN_SIDEBANDMANAGER_ID_REVISIONID (at 0x87BA8404)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_PWRACTIVE_SIDEBANDS_MAIN_SIDEBANDMANAGER_SENSEIN0"
      group.long 0x84B0--0x84B3 "APCS_CCI_PWRACTIVE_SIDEBANDS_MAIN_SIDEBANDMANAGER_SENSEIN0 (at 0x87BA84B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SENSEIN0                          = "
    tree.end
tree.end	
tree "CCI_Gladiator_Main_ACE_0_RD_TransactionFilter"	
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ID_COREID"
      group.long 0x9000--0x9003 "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ID_COREID (at 0x87BA9000)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ID_REVISIONID"
      group.long 0x9004--0x9007 "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ID_REVISIONID (at 0x87BA9004)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_MODE"
      group.long 0x9008--0x900B "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_MODE (at 0x87BA9008)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  MODE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ADDRBASE_LOW"
      group.long 0x900C--0x900F "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ADDRBASE_LOW (at 0x87BA900C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ADDRBASE_HIGH"
      group.long 0x9010--0x9013 "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ADDRBASE_HIGH (at 0x87BA9010)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xC--0x1F " [ 31: 12]  RESERVED_BITS31_12                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0xB " [ 11: 0]  ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ADDRWINDOWSIZE"
      group.long 0x9014--0x9017 "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_ADDRWINDOWSIZE (at 0x87BA9014)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0x5 " [ 5: 0]  ADDRWINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_SRCIDBASE"
      group.long 0x9018--0x901B "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_SRCIDBASE (at 0x87BA9018)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDBASE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_SRCIDMASK"
      group.long 0x901C--0x901F "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_SRCIDMASK (at 0x87BA901C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 7]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_OPCODE"
      group.long 0x9020--0x9023 "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_OPCODE (at 0x87BA9020)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x1--0x1 "  [   1]  WREN                               = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  RDEN                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_USERBASE"
      group.long 0x9024--0x9027 "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_USERBASE (at 0x87BA9024)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                     = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERBASE            			           = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_USERMASK"
      group.long 0x9028--0x902B "APCS_CCI_GLADIATOR_MAIN_ACE_0_RD_TRANSACTIONFILTER_USERMASK (at 0x87BA9028)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERMASK                       = "
    tree.end
tree.end
tree "CCI_Gladiator_Main_ACE_0_WR_TransactionFilter"	
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ID_COREID"
      group.long 0x9080--0x9083 "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ID_COREID (at 0x87BA9080)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ID_REVISIONID"
      group.long 0x9084--0x9087 "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ID_REVISIONID (at 0x87BA9084)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_MODE"
      group.long 0x9088--0x908B "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_MODE (at 0x87BA9088)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  MODE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ADDRBASE_LOW"
      group.long 0x908C--0x908F "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ADDRBASE_LOW (at 0x87BA908C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ADDRBASE_HIGH"
      group.long 0x9090--0x9093 "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ADDRBASE_HIGH (at 0x87BA9090)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xC--0x1F " [ 31: 12]  RESERVED_BITS31_12                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0xB " [ 11: 0]  ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ADDRWINDOWSIZE"
      group.long 0x9094--0x9097 "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_ADDRWINDOWSIZE (at 0x87BA9094)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0x5 " [ 5: 0]  ADDRWINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_SRCIDBASE"
      group.long 0x9098--0x909B "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_SRCIDBASE (at 0x87BA9098)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDBASE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_SRCIDMASK"
      group.long 0x909C--0x909F "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_SRCIDMASK (at 0x87BA909C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 7]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_OPCODE"
      group.long 0x90A0--0x90A3 "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_OPCODE (at 0x87BA90A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x1--0x1 "  [   1]  WREN                               = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  RDEN                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_USERBASE"
      group.long 0x90A4--0x90A7 "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_USERBASE (at 0x87BA90A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                     = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERBASE            			           = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_USERMASK"
      group.long 0x90A8--0x90AB "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_USERMASK (at 0x87BA90A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERMASK                       = "
    tree.end
tree.end
tree "CCI_Gladiator_Main_ACE_1_RD_TransactionFilter"	
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ID_COREID"
      group.long 0x9100--0x9103 "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ID_COREID (at 0x87BA9100)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ID_REVISIONID"
      group.long 0x9104--0x9107 "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ID_REVISIONID (at 0x87BA9104)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_MODE"
      group.long 0x9108--0x910B "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_MODE (at 0x87BA9108)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  MODE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ADDRBASE_LOW"
      group.long 0x910C--0x910F "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ADDRBASE_LOW (at 0x87BA910C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ADDRBASE_HIGH"
      group.long 0x9110--0x9113 "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ADDRBASE_HIGH (at 0x87BA9110)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xC--0x1F " [ 31: 12]  RESERVED_BITS31_12                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0xB " [ 11: 0]  ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ADDRWINDOWSIZE"
      group.long 0x9114--0x9117 "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_ADDRWINDOWSIZE (at 0x87BA9114)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0x5 " [ 5: 0]  ADDRWINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_SRCIDBASE"
      group.long 0x9118--0x911B "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_SRCIDBASE (at 0x87BA9118)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDBASE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_SRCIDMASK"
      group.long 0x911C--0x911F "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_SRCIDMASK (at 0x87BA911C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 7]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_OPCODE"
      group.long 0x9120--0x9123 "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_OPCODE (at 0x87BA9120)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x1--0x1 "  [   1]  WREN                               = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  RDEN                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_USERBASE"
      group.long 0x9124--0x9127 "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_USERBASE (at 0x87BA9124)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                     = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERBASE            			           = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_USERMASK"
      group.long 0x9128--0x912B "APCS_CCI_GLADIATOR_MAIN_ACE_1_RD_TRANSACTIONFILTER_USERMASK (at 0x87BA9128)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERMASK                       = "
    tree.end
tree.end
tree "CCI_Gladiator_Main_ACE_1_WR_TransactionFilter"	
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ID_COREID"
      group.long 0x9180--0x9183 "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ID_COREID (at 0x87BA9180)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ID_REVISIONID"
      group.long 0x9184--0x9187 "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ID_REVISIONID (at 0x87BA9184)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_MODE"
      group.long 0x9188--0x918B "APCS_CCI_GLADIATOR_MAIN_ACE_0_WR_TRANSACTIONFILTER_MODE (at 0x87BA9188)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  MODE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ADDRBASE_LOW"
      group.long 0x918C--0x918F "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ADDRBASE_LOW (at 0x87BA918C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ADDRBASE_HIGH"
      group.long 0x9190--0x9193 "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ADDRBASE_HIGH (at 0x87BA9190)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xC--0x1F " [ 31: 12]  RESERVED_BITS31_12                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0xB " [ 11: 0]  ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ADDRWINDOWSIZE"
      group.long 0x9194--0x9197 "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_ADDRWINDOWSIZE (at 0x87BA9194)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
	  hexmask.long.word 0x0 0x0--0x5 " [ 5: 0]  ADDRWINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_SRCIDBASE"
      group.long 0x9198--0x919B "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_SRCIDBASE (at 0x87BA9198)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDBASE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_SRCIDMASK"
      group.long 0x919C--0x919F "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_SRCIDMASK (at 0x87BA919C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 7]  RESERVED_BITS31_8                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  SRCIDMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_OPCODE"
      group.long 0x91A0--0x91A3 "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_OPCODE (at 0x87BA91A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x1--0x1 "  [   1]  WREN                               = " "0, 1"
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  RDEN                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_USERBASE"
      group.long 0x91A4--0x91A7 "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_USERBASE (at 0x87BA91A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                     = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERBASE            			           = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_USERMASK"
      group.long 0x91A8--0x91AB "APCS_CCI_GLADIATOR_MAIN_ACE_1_WR_TRANSACTIONFILTER_USERMASK (at 0x87BA91A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
	  hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  USERMASK                       = "
    tree.end
tree.end
tree "CCI_Gladiator_Main_TransactionStatProfiler"
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_ID_COREID"
      group.long 0x9200--0x9203 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_ID_COREID (at 0x87BA9200)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  CORETYPEID                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_ID_REVISIONID"
      group.long 0x9204--0x9207 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_ID_REVISIONID (at 0x87BA9204)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  QNOCID                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  USERID                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_EN"
      group.long 0x9208--0x920B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_EN (at 0x87BA9208)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]   EN                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_MODE"
      group.long 0x920C--0x920F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_MODE (at 0x87BA920C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1:  0]   MODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OBSERVEDSEL_0"
      group.long 0x9210--0x9213 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OBSERVEDSEL_0 : (at 0x87BA9210)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1:  0]   OBSERVEDSEL_0                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OBSERVEDSEL_1"
      group.long 0x9214--0x9217 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OBSERVEDSEL_1 (at 0x87BA9214)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1:  0]   OBSERVEDSEL_1                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_NTENURELINES_0"
      group.long 0x9220--0x9223 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_NTENURELINES_0 (at 0x87BA9220)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NTENURELINES_0                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_0"
      group.long 0x922C--0x922F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_0 (at 0x87BA922C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_0                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_1"
      group.long 0x9230--0x9233 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_1 (at 0x87BA9230)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	   hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_1                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_2"
      group.long 0x9234--0x9237 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_2 (at 0x87BA9234)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	   hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_2                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_3"
      group.long 0x9238--0x923B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_3 (at 0x87BA9238)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_3                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_4"
      group.long 0x923C--0x923F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_4 (at 0x87BA923C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_4                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_5"
      group.long 0x9240--0x9243 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_5 (at 0x87BA9240)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_5                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_6"
      group.long 0x9244--0x9247 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_6 (at 0x87BA9244)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_6                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_7"
      group.long 0x9248--0x924B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_7 (at 0x87BA9248)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_7                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_8"
      group.long 0x924C--0x924F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_8 (at 0x87BA924C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_8                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_9"
      group.long 0x9250--0x9253 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_9 (at 0x87BA9250)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_9                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_10"
      group.long 0x9254--0x9257 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_10 (at 0x87BA9254)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_10                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_11"
      group.long 0x9258--0x925B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_11 (at 0x87BA9258)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_11                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_12"
      group.long 0x925C--0x925F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_12 (at 0x87BA925C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_12                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_13"
      group.long 0x9260--0x9263 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_13 (at 0x87BA9260)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_13                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_14"
      group.long 0x9264--0x9267 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_0_14 (at 0x87BA9264)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_0_14                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_0"
      group.long 0x9268--0x926B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_0 (at 0x87BA9268)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_0                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_1"
      group.long 0x926C--0x926F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_1 (at 0x87BA926C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	   hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_1                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_2"
      group.long 0x9270--0x9273 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_2 (at 0x87BA9270)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	   hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_2                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_3"
      group.long 0x9274--0x9277 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_3 (at 0x87BA9274)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_3                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_4"
      group.long 0x9278--0x927B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_4 (at 0x87BA9278)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_4                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_5"
      group.long 0x927C--0x927F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_5 (at 0x87BA927C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_5                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_6"
      group.long 0x9280--0x9283 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_6 (at 0x87BA9280)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_6                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_7"
      group.long 0x9284--0x9287 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_7 (at 0x87BA9284)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_7                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_8"
      group.long 0x9288--0x928B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_8 (at 0x87BA9288)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_8                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_9"
      group.long 0x928C--0x928F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_9 (at 0x87BA928C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_9                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_10"
      group.long 0x9290--0x9293 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_10 (at 0x87BA9290)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_10                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_11"
      group.long 0x9294--0x9297 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_11 (at 0x87BA9294)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_11                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_12"
      group.long 0x9298--0x929B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_12 (at 0x87BA9298)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_12                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_13"
      group.long 0x929C--0x929F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_13 (at 0x87BA929C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_13                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_14"
      group.long 0x92A0--0x92A3 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_THRESHOLDS_1_14 (at 0x87BA92A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  THRESHOLDS_1_14                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OVERFLOWSTATUS"
      group.long 0x931C--0x931F "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OVERFLOWSTATUS (at 0x87BA931C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      rbitfld.long 0x0 0x0--0x1 "  [1:  0]   OVERFLOWSTATUS                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OVERFLOWRESET"
      group.long 0x9320--0x9323 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_OVERFLOWRESET (at 0x87BA9320)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1:  0]   OVERFLOWRESET                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_PENDINGEVENTMODE"
      group.long 0x9324--0x9327 "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_PENDINGEVENTMODE (at 0x87BA9324)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]   PENDINGEVENTMODE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_PRESCALER"
      group.long 0x9328--0x932B "APCS_CCI_GLADIATOR_MAIN_TRANSACTIONSTATPROFILER_PRESCALER (at 0x87BA9328)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  RESERVED_BITS31_8                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  PRESCALER                       = "
    tree.end
tree.end
tree "CCI_Gladiator_Main_PacketProbe"
    tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_ID_COREID"
      group.long 0x9400--0x9403 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_ID_COREID (at 0x87BA9400)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CORETYPEID                          = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_ID_REVISIONID"
      group.long 0x9404--0x9407 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_ID_REVISIONID (at 0x87BA9404)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.tbyte 0x0 0x8--0x1F 1 " [ 31: 8]  QNOCID                         = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USERID                          = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_MAINCTL"
      group.long 0x9408--0x940B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_MAINCTL (at 0x87BA9408)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]   RESERVED_BITS31_8               = "
	  textline ""
	  bitfld.long 0x0  0x7        "            FILTBYTEALWAYSCHAINABLEEN                          = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x6        "            INTRUSIVEMODE                             = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x5        "            STATCONDDUMP                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x4        "            ALARMEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x3        "            STATEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x2        "            PAYLOADEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x1        "            TRACEEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            ERREN                             = " "0, 1"
	tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_CFGCTL"
      group.long 0x940C--0x940F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_CFGCTL (at 0x87BA940C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]   RESERVED_BITS31_2                = "
	  textline ""
      rbitfld.long 0x0  0x1        "            ACTIVE                              = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            GLOBALEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERLUT"
      group.long 0x9414--0x9417 "GLADIATOR_MAIN_PACKETPROBE_FILTERLUT (at 0x87BA9414)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 "  [ 3: 0]   FILTERLUT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_TRACEALARMEN"
      group.long 0x9418--0x941B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_TRACEALARMEN (at 0x87BA9418)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x2 "  [ 2: 0]   TRACEALARMEN                               = "
    tree.end  
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_TRACEALARMSTATUS"
      group.long 0x941C--0x941F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_TRACEALARMSTATUS (at 0x87BA941C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x2 "  [ 2: 0]   TRACEALARMSTATUS                        = "
    tree.end  
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_TRACEALARMCLR"
      group.long 0x9420--0x9423 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_TRACEALARMCLR (at 0x87BA9420)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x2 "  [ 2: 0]   TRACEALARMCLR                        = "
    tree.end
	tree "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATPERIOD"
      group.long 0x9424--0x9427 "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATPERIOD (at 0x87BA9424)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 "  [ 4: 0]   STATPERIOD                        = "
    tree.end  
	tree "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATGO"
      group.long 0x9428--0x942B "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATGO (at 0x87BA9428)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
      textline ""
      bitfld.long 0x0  0x0        "            STATGO                             = " "0, 1"
    tree.end  
	tree "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMMIN"
      group.long 0x942C--0x942F "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMMIN (at 0x87BA942C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  STATALARMMIN                       = "
    tree.end  
	tree "APCS_CCS_APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMMAX"
      group.long 0x9430--0x9433 "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMMAX (at 0x87BA9430)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  STATALARMMAX                       = "
    tree.end
	tree "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMSTATUS"
      group.long 0x9434--0x9437 "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMSTATUS (at 0x87BA9434)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      rbitfld.long 0x0  0x0--0x1        " [ 1: 0]     STATALARMSTATUS                             = " "0, 1, 2, 3"
    tree.end  
	tree "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMCLR"
      group.long 0x9438--0x943B "APCS_CCS_GLADIATOR_MAIN_PACKETPROBE_STATALARMCLR (at 0x87BA9438)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0  0x0--0x1        "  [ 1: 0]    STATALARMCLR                             = " "1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_STATALARMEN"
      group.long 0x943C--0x943F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_STATALARMEN (at 0x87BA943C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0  0x0--0x1        "  [ 1: 0]    STATALARMCLR                             = " "1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ROUTEIDBASE"
      group.long 0x9444--0x9447 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ROUTEIDBASE (at 0x87BA9444)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  FILTERS_0_ROUTEIDBASE                       = "
    tree.end  
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ROUTEIDMASK"
      group.long 0x9448--0x944B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ROUTEIDMASK (at 0x87BA9448)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  FILTERS_0_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ADDRBASE_LOW"
      group.long 0x944C--0x944F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ADDRBASE_LOW (at 0x87BA944C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ADDRBASE_LOW                       = "
	tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ADDRBASE_HIGH"
      group.long 0x9450--0x9453 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ADDRBASE_HIGH (at 0x87BA9450)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xC--0x1F " [ 31: 12]  RESERVED_BITS31_12                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xB " [ 11: 0]  FILTERS_0_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_WINDOWSIZE"
      group.long 0x9454--0x9457 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_WINDOWSIZE (at 0x87BA9454)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_0_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_OPCODE"
      group.long 0x9460--0x9463 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_OPCODE (at 0x87BA9460)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_STATUS"
      group.long 0x9464--0x9467 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_STATUS (at 0x87BA9464)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_LENGTH"
      group.long 0x9468--0x946B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_LENGTH (at 0x87BA9468)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_0_LENGTH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_USERBASE"
      group.long 0x9470--0x9473 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_USERBASE (at 0x87BA9470)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERBASE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_USERMASK"
      group.long 0x9474--0x9477 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_USERMASK (at 0x87BA9474)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_ROUTEIDBASE"
      group.long 0x9480--0x9483 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_0_ROUTEIDBASE (at 0x87BA9480)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  FILTERS_1_ROUTEIDBASE                       = "
    tree.end  
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_ROUTEIDMASK"
      group.long 0x9484--0x9487 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_ROUTEIDMASK (at 0x87BA9484)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xB--0x1F " [ 31: 11]  RESERVED_BITS31_11                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xA " [ 10: 0]  FILTERS_1_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_ADDRBASE_LOW"
      group.long 0x9488--0x948B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_ADDRBASE_LOW (at 0x87BA9488)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ADDRBASE_LOW                       = "
	tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_ADDRBASE_HIGH"
      group.long 0x948C--0x948F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_ADDRBASE_HIGH (at 0x87BA948C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0xC--0x1F " [ 31: 12]  RESERVED_BITS31_12                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xB " [ 11: 0]  FILTERS_1_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_WINDOWSIZE"
      group.long 0x9490--0x9493 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_WINDOWSIZE (at 0x87BA9490)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_1_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_OPCODE"
      group.long 0x949C--0x949F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_OPCODE (at 0x87BA949C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_STATUS"
      group.long 0x94A0--0x94A3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_STATUS (at 0x87BA94A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_LENGTH"
      group.long 0x94A4--0x94A7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_LENGTH (at 0x87BA94A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_1_LENGTH                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_USERBASE"
      group.long 0x94AC--0x94AF "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_USERBASE (at 0x87BA94AC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERBASE                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_USERMASK"
      group.long 0x94B0--0x94B3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_FILTERS_1_USERMASK (at 0x87BA94B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERMASK                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_0_SRC"
      group.long 0x9538--0x953B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_0_SRC (at 0x87BA9538)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_0_ALARMMODE"
      group.long 0x953C--0x953F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_0_ALARMMODE (at 0x87BA953C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_0_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_0_VAL"
      group.long 0x9540--0x9543 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_0_VAL (at 0x87BA9540)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_0_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_1_SRC"
      group.long 0x954C--0x954F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_1_SRC (at 0x87BA954C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_1_ALARMMODE"
      group.long 0x9550--0x9553 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_1_ALARMMODE (at 0x87BA9550)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_1_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_1_VAL"
      group.long 0x9554--0x9557 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_1_VAL (at 0x87BA9554)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_1_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_2_SRC"
      group.long 0x9560--0x9563 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_2_SRC (at 0x87BA9560)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_2_ALARMMODE"
      group.long 0x9564--0x9567 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_2_ALARMMODE (at 0x87BA9564)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_2_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_2_VAL"
      group.long 0x9568--0x956B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_2_VAL (at 0x87BA9568)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_2_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_3_SRC"
      group.long 0x9574--0x9577 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_2_SRC (at 0x87BA9574)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_3_ALARMMODE"
      group.long 0x9578--0x957B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_3_ALARMMODE (at 0x87BA9578)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_2_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_3_VAL"
      group.long 0x957C--0x957F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_3_VAL (at 0x87BA957C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_3_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_4_SRC"
      group.long 0x9588--0x958B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_4_SRC (at 0x87BA9588)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_4_ALARMMODE"
      group.long 0x958C--0x958F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_4_ALARMMODE (at 0x87BA958C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_4_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_4_VAL"
      group.long 0x9590--0x9593 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_4_VAL (at 0x87BA9590)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_4_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_5_SRC"
      group.long 0x959C--0x959F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_5_SRC (at 0x87BA959C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_5_ALARMMODE"
      group.long 0x95A0--0x95A3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_5_ALARMMODE (at 0x87BA95A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_5_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_5_VAL"
      group.long 0x95A4--0x95A7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_5_VAL (at 0x87BA95A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_5_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_6_SRC"
      group.long 0x95B0--0x95B3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_6_SRC (at 0x87BA95B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_6_ALARMMODE"
      group.long 0x95B4--0x95B7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_6_ALARMMODE (at 0x87BA95B4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_6_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_6_VAL"
      group.long 0x95B8--0x95BB "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_6_VAL (at 0x87BA95B8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_6_VAL                       = "
    tree.end
    tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_7_SRC"
      group.long 0x95C4--0x95C7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_7_SRC (at 0x87BA95C4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_7_ALARMMODE"
      group.long 0x95C8--0x95CB "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_7_ALARMMODE (at 0x87BA95C8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_7_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_7_VAL"
      group.long 0x95CC--0x95CF "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_7_VAL (at 0x87BA95CC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_7_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_8_SRC"
      group.long 0x95D8--0x95DB "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_8_SRC (at 0x87BA95D8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_8_ALARMMODE"
      group.long 0x95DC--0x95DF "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_8_ALARMMODE (at 0x87BA95DC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_8_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_8_VAL"
      group.long 0x95E0--0x95E3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_8_VAL (at 0x87BA95E0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_8_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_9_SRC"
      group.long 0x95EC--0x95EF "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_9_SRC (at 0x87BA95EC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_9_ALARMMODE"
      group.long 0x95F0--0x95F3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_9_ALARMMODE (at 0x87BA95F0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_9_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_9_VAL"
      group.long 0x95F4--0x95F7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_9_VAL (at 0x87BA95F4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_9_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_10_SRC"
      group.long 0x9600--0x9603 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_10_SRC (at 0x87BA9600)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_10_ALARMMODE"
      group.long 0x9604--0x9607 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_10_ALARMMODE (at 0x87BA9604)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_10_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_10_VAL"
      group.long 0x9608--0x960B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_10_VAL (at 0x87BA9608)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_10_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_11_SRC"
      group.long 0x9614--0x9617 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_11_SRC (at 0x87BA9614)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_11_ALARMMODE"
      group.long 0x9618--0x961B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_11_ALARMMODE (at 0x87BA9618)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_11_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_11_VAL"
      group.long 0x961C--0x961F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_11_VAL (at 0x87BA961C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_11_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_12_SRC"
      group.long 0x9628--0x962B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_12_SRC (at 0x87BA9628)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_12_ALARMMODE"
      group.long 0x962C--0x962F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_12_ALARMMODE (at 0x87BA962C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_12_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_12_VAL"
      group.long 0x9630--0x9633 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_12_VAL (at 0x87BA9630)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_12_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_13_SRC"
      group.long 0x963C--0x963F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_13_SRC (at 0x87BA963C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_13_ALARMMODE"
      group.long 0x9640--0x9643 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_13_ALARMMODE (at 0x87BA9640)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_13_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_13_VAL"
      group.long 0x9644--0x9647 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_13_VAL (at 0x87BA9644)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_13_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_14_SRC"
      group.long 0x9650--0x9653 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_14_SRC (at 0x87BA9650)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_14_ALARMMODE"
      group.long 0x9654--0x9657 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_14_ALARMMODE (at 0x87BA9654)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_14_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_14_VAL"
      group.long 0x9658--0x965B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_14_VAL (at 0x87BA9658)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_14_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_15_SRC"
      group.long 0x9664--0x9667 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_15_SRC (at 0x87BA9664)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_15_ALARMMODE"
      group.long 0x9668--0x966B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_15_ALARMMODE (at 0x87BA9668)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_15_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_15_VAL"
      group.long 0x966C--0x966F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_14_VAL (at 0x87BA966C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_15_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_SRC"
      group.long 0x9678--0x967B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_SRC (at 0x87BA9678)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_ALARMMODE"
      group.long 0x967C--0x967F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_ALARMMODE (at 0x87BA967C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_16_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_VAL"
      group.long 0x9680--0x9683 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_VAL (at 0x87BA9680)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_16_VAL                       = "
    tree.end
 	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_SRC"
      group.long 0x9678--0x967B "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_SRC (at 0x87BA9678)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_ALARMMODE"
      group.long 0x967C--0x967F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_ALARMMODE (at 0x87BA967C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_16_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_VAL"
      group.long 0x9680--0x9683 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_16_VAL (at 0x87BA9680)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_16_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_17_SRC"
      group.long 0x968C--0x968F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_17_SRC (at 0x87BA968C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_17_ALARMMODE"
      group.long 0x9690--0x9693 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_17_ALARMMODE (at 0x87BA9690)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_17_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_17_VAL"
      group.long 0x9694--0x9697 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_17_VAL (at 0x87BA9694)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_17_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_18_SRC"
      group.long 0x96A0--0x96A3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_18_SRC (at 0x87BA96A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_18_ALARMMODE"
      group.long 0x96A4--0x96A7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_18_ALARMMODE (at 0x87BA96A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_18_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_18_VAL"
      group.long 0x96A8--0x96AB "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_18_VAL (at 0x87BA96A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_18_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_19_SRC"
      group.long 0x96B4--0x96B7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_19_SRC (at 0x87BA96B4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_19_ALARMMODE"
      group.long 0x96B8--0x96BB "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_19_ALARMMODE (at 0x87BA96B8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_19_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_19_VAL"
      group.long 0x96BC--0x96BF "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_19_VAL (at 0x87BA96BC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_19_VAL                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_20_SRC"
      group.long 0x96C8--0x96CB "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_20_SRC (at 0x87BA96C8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_20_ALARMMODE"
      group.long 0x96CC--0x96CF "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_20_ALARMMODE (at 0x87BA96CC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_20_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_20_VAL"
      group.long 0x96D0--0x96D3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_20_VAL (at 0x87BA96D0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_20_VAL                       = "
    tree.end
	
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_21_SRC"
      group.long 0x96DC--0x96DF "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_21_SRC (at 0x87BA96DC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x9--0x1F " [ 31: 9]  RESERVED_BITS31_9                       = "
	  textline ""
	  hexmask.long.byte 0x0 0x5--0x8 " [ 8: 5]  EXTEVENT                               = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  INTEVENT                               = "
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_21_ALARMMODE"
      group.long 0x96E0--0x96E3 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_21_ALARMMODE (at 0x87BA96E0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x1 "  [1: 0]  COUNTERS_21_ALARMMODE                               = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_21_VAL"
      group.long 0x96E4--0x96E7 "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_COUNTERS_21_VAL (at 0x87BA96E4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x10--0x1F " [ 31: 16]  RESERVED_BITS31_16                       = "
	  textline ""
      hexmask.long.word 0x0 0x0--0xF " [ 15: 0]  COUNTERS_21_VAL                       = "
    tree.end
tree.end
tree "CCI_Gladiator_M1ReqProbe_Main_Probe"
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_ID_COREID"
      group.long 0xC000--0xC003 "APCS_CCI_M1REQPROBE_MAIN_PROBE_ID_COREID (at 0x87BAC000)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  CORETYPEID                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_ID_REVISIONID"
      group.long 0xC004--0xC007 "M1REQPROBE_MAIN_PROBE_ID_REVISIONID (at 0x87BAC004)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  QNOCID                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  USERID                       = "
    tree.end
    tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_MAINCTL"
      group.long 0xC008--0xC00B "APCS_CCI_M1REQPROBE_MAIN_PROBE_MAINCTL (at 0x87BAC008)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]   RESERVED_BITS31_8               = "
	  textline ""
	  bitfld.long 0x0  0x7        "            FILTBYTEALWAYSCHAINABLEEN                          = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x6        "            INTRUSIVEMODE                             = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x5        "            STATCONDDUMP                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x4        "            ALARMEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x3        "            STATEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x2        "            PAYLOADEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x1        "            TRACEEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            ERREN                             = " "0, 1"
	tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_CFGCTL"
      group.long 0xC00C--0xC00F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_CFGCTL (at 0x87BAC00C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]   RESERVED_BITS31_2                = "
	  textline ""
      rbitfld.long 0x0  0x1        "            ACTIVE                              = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            GLOBALEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERLUT"
      group.long 0xC014--0xC017 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERLUT (at 0x87BAC014)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERLUT                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_TRACEALARMEN"
      group.long 0xC018--0xC01B "APCS_CCI_M1REQPROBE_MAIN_PROBE_TRACEALARMEN (at 0x87BAC018)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x2 " [ 2: 0]  TRACEALARMEN                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_TRACEALARMSTATUS"
      group.long 0xC01C--0xC01F "APCS_CCI_M1REQPROBE_MAIN_PROBE_TRACEALARMSTATUS (at 0x87BAC01C)"
      line.long 0x0 "VALUE"	
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      rbitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMSTATUS                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_TRACEALARMCLR"
      group.long 0xC020--0xC023 "APCS_CCI_M1REQPROBE_MAIN_PROBE_TRACEALARMCLR (at 0x87BAC020)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMCLR                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE"
      group.long 0xC044--0xC047 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE (at 0x87BAC044)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDBASE                       = "
    tree.end
    tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK"
      group.long 0xC048--0xC04B "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK (at 0x87BAC048)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW"
      group.long 0xC04C--0xC04F "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW (at 0x87BAC04C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH"
      group.long 0xC050--0xC053 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH (at 0x87BAC050)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_0_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE"
      group.long 0xC054--0xC057 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE (at 0x87BAC054)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_0_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE"
      group.long 0xC058--0xC05B "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE (at 0x87BAC058)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK"
      group.long 0xC05C--0xC05F "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK (at 0x87BAC05C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_OPCODE"
      group.long 0xC060--0xC063 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_OPCODE (at 0x87BAC060)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_STATUS"
      group.long 0xC064--0xC067 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_STATUS (at 0x87BAC064)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_LENGTH"
      group.long 0xC068--0xC06B "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_LENGTH (at 0x87BAC068)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_0_LENGTH                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_URGENCY"
      group.long 0xC06C--0xC06F "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_URGENCY (at 0x87BAC06C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_0_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_USERBASE"
      group.long 0xC070--0xC073 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_USERBASE (at 0x87BAC070)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERBASE                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_USERMASK"
      group.long 0xC074--0xC077 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_0_USERMASK (at 0x87BAC074)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERMASK                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE"
      group.long 0xC080--0xC083 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE (at 0x87BAC080)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDBASE                       = "
    tree.end  
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK"
      group.long 0xC084--0xC087 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK (at 0x87BAC084)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW"
      group.long 0xC088--0xC08B "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW (at 0x87BAC088)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ADDRBASE_LOW                       = "
	tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH"
      group.long 0xC08C--0xC08F "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH (at 0x87BAC08C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_1_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE"
      group.long 0xC090--0xC093 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE (at 0x87BAC090)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_1_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE"
      group.long 0xC094--0xC097 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE (at 0x87BAC094)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK"
      group.long 0xC098--0xC09B "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK (at 0x87BAC098)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_OPCODE"
      group.long 0xC09C--0xC09F "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_OPCODE (at 0x87BAC09C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_STATUS"
      group.long 0xC0A0--0xC0A3 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_STATUS (at 0x87BAC0A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_LENGTH"
      group.long 0xC0A4--0xC0A7 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_LENGTH (at 0x87BAC0A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_1_LENGTH                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_URGENCY"
      group.long 0xC0A8--0xC0AB "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_URGENCY (at 0x87BAC0A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_1_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_USERBASE"
      group.long 0xC0AC--0xC0AF "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_USERBASE (at 0x87BAC0AC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERBASE                       = "
    tree.end
	tree "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_USERMASK"
      group.long 0xC0B0--0xC0B3 "APCS_CCI_M1REQPROBE_MAIN_PROBE_FILTERS_1_USERMASK (at 0x87BAC0B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERMASK                       = "
    tree.end
tree.end
tree "CCI_Gladiator_Trace_Main_AtbEndPoint"
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ID_COREID"
      group.long 0xC400--0xC403 "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ID_COREID (at 0x87BAC400)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  CORETYPEID                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ID_REVISIONID"
      group.long 0xC404--0xC407 "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ID_REVISIONID (at 0x87BAC404)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  QNOCID                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  USERID                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ATBID"
      group.long 0xC408--0xC40B "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ATBID (at 0x87BAC408)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x7--0x1F " [ 31: 7]  RESERVED_BITS31_7                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x6 " [ 6: 0]  ATBID                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ATBEN"
      group.long 0xC40C--0xC40F "APCS_CCI_GLADIATOR_TRACE_MAIN_ATBENDPOINT_ATBEN(at 0x87BAC40C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  ATBEN                               = " "0, 1"
    tree.end
  tree.end
tree "CCI_Gladiator_Trace_Main_STPv2Converter"
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_ID_COREID"
      group.long 0xC480--0xC483 "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_ID_COREID (at 0x87BAC480)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  CORETYPEID                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_ID_REVISIONID"
      group.long 0xC484--0xC487 "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_ID_REVISIONID (at 0x87BAC484)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  QNOCID                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  USERID                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_ASYNCPERIOD"
      group.long 0xC488--0xC48B "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_ASYNCPERIOD (at 0x87BAC488)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  ASYNCPERIOD                       = "
    tree.end
	tree "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_STPV2EN"
      group.long 0xC48C--0xC48F "APCS_CCI_GLADIATOR_TRACE_MAIN_STPV2CONVERTER_STPV2EN (at 0x87BAC48C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x0 "  [   0]  STPV2EN                               = " "0, 1"
    tree.end
  tree.end
  
tree "CCI_Gladiator_M2ReqProbe_Main_Probe"
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_ID_COREID"
      group.long 0xD000--0xD003 "APCS_CCI_M2REQPROBE_MAIN_PROBE_ID_COREID (at 0x87BAD000)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  CORETYPEID                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_ID_REVISIONID"
      group.long 0xD004--0xD007 "M2REQPROBE_MAIN_PROBE_ID_REVISIONID (at 0x87BAD004)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  QNOCID                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  USERID                       = "
    tree.end
    tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_MAINCTL"
      group.long 0xD008--0xD00B "APCS_CCI_M2REQPROBE_MAIN_PROBE_MAINCTL (at 0x87BAD008)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]   RESERVED_BITS31_8               = "
	  textline ""
	  bitfld.long 0x0  0x7        "            FILTBYTEALWAYSCHAINABLEEN                          = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x6        "            INTRUSIVEMODE                             = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x5        "            STATCONDDUMP                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x4        "            ALARMEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x3        "            STATEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x2        "            PAYLOADEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x1        "            TRACEEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            ERREN                             = " "0, 1"
	tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_CFGCTL"
      group.long 0xD00C--0xD00F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_CFGCTL (at 0x87BAD00C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]   RESERVED_BITS31_2                = "
	  textline ""
      rbitfld.long 0x0  0x1        "            ACTIVE                              = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            GLOBALEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERLUT"
      group.long 0xD014--0xD017 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERLUT (at 0x87BAD014)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERLUT                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_TRACEALARMEN"
      group.long 0xD018--0xD01B "APCS_CCI_M2REQPROBE_MAIN_PROBE_TRACEALARMEN (at 0x87BAD018)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x2 " [ 2: 0]  TRACEALARMEN                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_TRACEALARMSTATUS"
      group.long 0xD01C--0xD01F "APCS_CCI_M2REQPROBE_MAIN_PROBE_TRACEALARMSTATUS (at 0x87BAD01C)"
      line.long 0x0 "VALUE"	
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      rbitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMSTATUS                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_TRACEALARMCLR"
      group.long 0xD020--0xD023 "APCS_CCI_M2REQPROBE_MAIN_PROBE_TRACEALARMCLR (at 0x87BAD020)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMCLR                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE"
      group.long 0xD044--0xD047 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE (at 0x87BAD044)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDBASE                       = "
    tree.end
    tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK"
      group.long 0xD048--0xD04B "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK (at 0x87BAD048)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW"
      group.long 0xD04C--0xD04F "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW (at 0x87BAD04C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH"
      group.long 0xD050--0xD053 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH (at 0x87BAD050)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_0_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE"
      group.long 0xD054--0xD057 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE (at 0x87BAD054)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_0_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE"
      group.long 0xD058--0xD05B "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE (at 0x87BAD058)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK"
      group.long 0xD05C--0xD05F "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK (at 0x87BAD05C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_OPCODE"
      group.long 0xD060--0xD063 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_OPCODE (at 0x87BAD060)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_STATUS"
      group.long 0xD064--0xD067 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_STATUS (at 0x87BAD064)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_LENGTH"
      group.long 0xD068--0xD06B "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_LENGTH (at 0x87BAD068)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_0_LENGTH                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_URGENCY"
      group.long 0xD06C--0xD06F "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_URGENCY (at 0x87BAD06C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_0_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_USERBASE"
      group.long 0xD070--0xD073 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_USERBASE (at 0x87BAD070)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERBASE                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_USERMASK"
      group.long 0xD074--0xD077 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_0_USERMASK (at 0x87BAD074)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERMASK                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE"
      group.long 0xD080--0xD083 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE (at 0x87BAD080)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDBASE                       = "
    tree.end  
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK"
      group.long 0xD084--0xD087 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK (at 0x87BAD084)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW"
      group.long 0xD088--0xD08B "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW (at 0x87BAD088)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ADDRBASE_LOW                       = "
	tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH"
      group.long 0xD08C--0xD08F "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH (at 0x87BAD08C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_1_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE"
      group.long 0xD090--0xD093 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE (at 0x87BAD090)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_1_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE"
      group.long 0xD094--0xD097 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE (at 0x87BAD094)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK"
      group.long 0xD098--0xD09B "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK (at 0x87BAD098)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_OPCODE"
      group.long 0xD09C--0xD09F "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_OPCODE (at 0x87BAD09C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_STATUS"
      group.long 0xD0A0--0xD0A3 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_STATUS (at 0x87BAD0A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_LENGTH"
      group.long 0xD0A4--0xD0A7 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_LENGTH (at 0x87BAD0A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_1_LENGTH                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_URGENCY"
      group.long 0xD0A8--0xD0AB "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_URGENCY (at 0x87BAD0A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_1_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_USERBASE"
      group.long 0xD0AC--0xD0AF "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_USERBASE (at 0x87BAD0AC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERBASE                       = "
    tree.end
	tree "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_USERMASK"
      group.long 0xD0B0--0xD0B3 "APCS_CCI_M2REQPROBE_MAIN_PROBE_FILTERS_1_USERMASK (at 0x87BAD0B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERMASK                       = "
    tree.end
tree.end
tree "CCI_Gladiator_SNOREQPROBE_Main_Probe"
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_ID_COREID"
      group.long 0xD400--0xD403 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_ID_COREID (at 0x87BAD400)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  CORETYPEID                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_ID_REVISIONID"
      group.long 0xD404--0xD407 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_ID_REVISIONID (at 0x87BAD404)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  QNOCID                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  USERID                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_MAINCTL"
      group.long 0xD408--0xD40B "APCS_CCI_SNOREQPROBE_MAIN_PROBE_MAINCTL (at 0x87BAD408)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]   RESERVED_BITS31_8               = "
	  textline ""
	  bitfld.long 0x0  0x7        "            FILTBYTEALWAYSCHAINABLEEN                          = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x6        "            INTRUSIVEMODE                             = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x5        "            STATCONDDUMP                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x4        "            ALARMEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x3        "            STATEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x2        "            PAYLOADEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x1        "            TRACEEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            ERREN                             = " "0, 1"
	tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_CFGCTL"
      group.long 0xD40C--0xD40F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_CFGCTL (at 0x87BAD40C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]   RESERVED_BITS31_2                = "
	  textline ""
      rbitfld.long 0x0  0x1        "            ACTIVE                              = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            GLOBALEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERLUT"
      group.long 0xD414--0xD417 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERLUT (at 0x87BAD414)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERLUT                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_TRACEALARMEN"
      group.long 0xD418--0xD41B "APCS_CCI_SNOREQPROBE_MAIN_PROBE_TRACEALARMEN (at 0x87BAD418)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x2 " [ 2: 0]  TRACEALARMEN                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_TRACEALARMSTATUS"
      group.long 0xD41C--0xD41F "APCS_CCI_SNOREQPROBE_MAIN_PROBE_TRACEALARMSTATUS (at 0x87BAD41C)"
      line.long 0x0 "VALUE"	
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      rbitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMSTATUS                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_TRACEALARMCLR"
      group.long 0xD420--0xD423 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_TRACEALARMCLR (at 0x87BAD420)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMCLR                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE"
      group.long 0xD444--0xD447 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE (at 0x87BAD444)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDBASE                       = "
    tree.end
    tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK"
      group.long 0xD448--0xD44B "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK (at 0x87BAD448)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW"
      group.long 0xD44C--0xD44F "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW (at 0x87BAD44C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH"
      group.long 0xD450--0xD453 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH (at 0x87BAD450)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_0_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE"
      group.long 0xD454--0xD457 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE (at 0x87BAD454)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_0_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE"
      group.long 0xD458--0xD45B "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE (at 0x87BAD458)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK"
      group.long 0xD45C--0xD45F "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK (at 0x87BAD45C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_OPCODE"
      group.long 0xD460--0xD463 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_OPCODE (at 0x87BAD460)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_STATUS"
      group.long 0xD464--0xD467 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_STATUS (at 0x87BAD464)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_LENGTH"
      group.long 0xD468--0xD46B "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_LENGTH (at 0x87BAD468)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_0_LENGTH                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_URGENCY"
      group.long 0xD46C--0xD46F "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_URGENCY (at 0x87BAD46C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_0_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_USERBASE"
      group.long 0xD470--0xD473 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_USERBASE (at 0x87BAD470)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERBASE                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_USERMASK"
      group.long 0xD474--0xD477 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_0_USERMASK (at 0x87BAD474)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERMASK                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE"
      group.long 0xD480--0xD483 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE (at 0x87BAD480)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDBASE                       = "
    tree.end  
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK"
      group.long 0xD484--0xD487 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK (at 0x87BAD484)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW"
      group.long 0xD488--0xD48B "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW (at 0x87BAD488)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ADDRBASE_LOW                       = "
	tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH"
      group.long 0xD48C--0xD48F "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH (at 0x87BAD48C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_1_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE"
      group.long 0xD490--0xD493 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE (at 0x87BAD490)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_1_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE"
      group.long 0xD494--0xD497 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE (at 0x87BAD494)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK"
      group.long 0xD498--0xD49B "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK (at 0x87BAD498)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_OPCODE"
      group.long 0xD49C--0xD49F "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_OPCODE (at 0x87BAD49C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_STATUS"
      group.long 0xD4A0--0xD4A3 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_STATUS (at 0x87BAD4A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_LENGTH"
      group.long 0xD4A4--0xD4A7 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_LENGTH (at 0x87BAD4A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_1_LENGTH                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_URGENCY"
      group.long 0xD4A8--0xD4AB "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_URGENCY (at 0x87BAD4A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_1_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_USERBASE"
      group.long 0xD4AC--0xD4AF "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_USERBASE (at 0x87BAD4AC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERBASE                       = "
    tree.end
	tree "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_USERMASK"
      group.long 0xD4B0--0xD4B3 "APCS_CCI_SNOREQPROBE_MAIN_PROBE_FILTERS_1_USERMASK (at 0x87BAD4B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERMASK                       = "
    tree.end
tree.end
tree "CCI_Gladiator_SRVCREQPROBE_Main_Probe"
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_ID_COREID"
      group.long 0xD800--0xD803 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_ID_COREID (at 0x87BAD800)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  CORECHECKSUM                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  CORETYPEID                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_ID_REVISIONID"
      group.long 0xD804--0xD807 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_ID_REVISIONID (at 0x87BAD804)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]  QNOCID                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x7 " [ 7: 0]  USERID                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_MAINCTL"
      group.long 0xD808--0xD80B "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_MAINCTL (at 0x87BAD808)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x8--0x1F " [ 31: 8]   RESERVED_BITS31_8               = "
	  textline ""
	  bitfld.long 0x0  0x7        "            FILTBYTEALWAYSCHAINABLEEN                          = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x6        "            INTRUSIVEMODE                             = " "0, 1"
	  textline ""
	  bitfld.long 0x0  0x5        "            STATCONDDUMP                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x4        "            ALARMEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x3        "            STATEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x2        "            PAYLOADEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x1        "            TRACEEN                             = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            ERREN                             = " "0, 1"
	tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_CFGCTL"
      group.long 0xD80C--0xD80F "APCS_CCI_GLADIATOR_MAIN_PACKETPROBE_CFGCTL (at 0x87BAD80C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]   RESERVED_BITS31_2                = "
	  textline ""
      rbitfld.long 0x0  0x1        "            ACTIVE                              = " "0, 1"
	  textline ""
      bitfld.long 0x0  0x0        "            GLOBALEN                             = " "0, 1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERLUT"
      group.long 0xD814--0xD817 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERLUT (at 0x87BAD814)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERLUT                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_TRACEALARMEN"
      group.long 0xD818--0xD81B "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_TRACEALARMEN (at 0x87BAD818)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x2 " [ 2: 0]  TRACEALARMEN                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_TRACEALARMSTATUS"
      group.long 0xD81C--0xD81F "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_TRACEALARMSTATUS (at 0x87BAD81C)"
      line.long 0x0 "VALUE"	
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      rbitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMSTATUS                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_TRACEALARMCLR"
      group.long 0xD820--0xD823 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_TRACEALARMCLR (at 0x87BAD820)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x3--0x1F " [ 31: 3]  RESERVED_BITS31_3                       = "
	  textline ""
      bitfld.long 0x0 0x0--0x2 "  [2:  0]   TRACEALARMCLR                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE"
      group.long 0xD844--0xD847 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDBASE (at 0x87BAD844)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDBASE                       = "
    tree.end
    tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK"
      group.long 0xD848--0xD84B "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ROUTEIDMASK (at 0x87BAD848)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW"
      group.long 0xD84C--0xD84F "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_LOW (at 0x87BAD84C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_0_ADDRBASE_LOW                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH"
      group.long 0xD850--0xD853 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_ADDRBASE_HIGH (at 0x87BAD850)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_0_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE"
      group.long 0xD854--0xD857 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_WINDOWSIZE (at 0x87BAD854)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_0_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE"
      group.long 0xD858--0xD85B "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYBASE (at 0x87BAD858)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK"
      group.long 0xD85C--0xD85F "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_SECURITYMASK (at 0x87BAD85C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_0_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_OPCODE"
      group.long 0xD860--0xD863 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_OPCODE (at 0x87BAD860)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_STATUS"
      group.long 0xD864--0xD867 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_STATUS (at 0x87BAD864)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_LENGTH"
      group.long 0xD868--0xD86B "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_LENGTH (at 0x87BAD868)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_0_LENGTH                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_URGENCY"
      group.long 0xD86C--0xD86F "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_URGENCY (at 0x87BAD86C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_0_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_USERBASE"
      group.long 0xD870--0xD873 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_USERBASE (at 0x87BAD870)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERBASE                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_USERMASK"
      group.long 0xD874--0xD877 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_0_USERMASK (at 0x87BAD874)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_0_USERMASK                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE"
      group.long 0xD880--0xD883 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDBASE (at 0x87BAD880)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDBASE                       = "
    tree.end  
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK"
      group.long 0xD884--0xD887 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ROUTEIDMASK (at 0x87BAD884)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
      hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ROUTEIDMASK                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW"
      group.long 0xD888--0xD88B "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_LOW (at 0x87BAD888)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x0--0x1F " [ 31: 0]  FILTERS_1_ADDRBASE_LOW                       = "
	tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH"
      group.long 0xD88C--0xD88F "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_ADDRBASE_HIGH (at 0x87BAD88C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x5--0x1F " [ 31: 5]  RESERVED_BITS31_5                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x4 " [ 4: 0]  FILTERS_1_ADDRBASE_HIGH                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE"
      group.long 0xD890--0xD893 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_WINDOWSIZE (at 0x87BAD890)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x6--0x1F " [ 31: 6]  RESERVED_BITS31_6                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x5 " [ 5: 0]  FILTERS_1_WINDOWSIZE                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE"
      group.long 0xD894--0xD897 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYBASE (at 0x87BAD894)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYBASE                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK"
      group.long 0xD898--0xD89B "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_SECURITYMASK (at 0x87BAD898)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x1--0x1F " [ 31: 1]  RESERVED_BITS31_1                       = "
	  textline ""
	  bitfld.long 0x0 0x0--0x0 "  [   0]   FILTERS_1_SECURITYMASK                               = " "0, 1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_OPCODE"
      group.long 0xD89C--0xD89F "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_OPCODE (at 0x87BAD89C)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                = "
	  textline ""
      bitfld.long 0x0  0x3        "  [    3]    URGEN                              = " "0,1"
	  textline ""
      bitfld.long 0x0  0x2        "  [    2]    LOCKEN                             = " "0,1"
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    WREN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    RDEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_STATUS"
      group.long 0xD8A0--0xD8A3 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_STATUS (at 0x87BAD8A0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                = "
	  textline ""
      bitfld.long 0x0  0x1        "  [    1]    RSPEN                               = " "0,1"
	  textline ""
      bitfld.long 0x0  0x0        "  [    0]    REQEN                               = " "0,1"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_LENGTH"
      group.long 0xD8A4--0xD8A7 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_LENGTH (at 0x87BAD8A4)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x4--0x1F " [ 31: 4]  RESERVED_BITS31_4                       = "
	  textline ""
      hexmask.long.byte 0x0 0x0--0x3 " [ 3: 0]  FILTERS_1_LENGTH                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_URGENCY"
      group.long 0xD8A8--0xD8AB "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_URGENCY (at 0x87BAD8A8)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.long 0x0 0x2--0x1F " [ 31: 2]  RESERVED_BITS31_2                       = "
	  textline ""
      bitfld.long  0x0 0x0--0x1 " [ 1: 0]  FILTERS_1_URGENCY                       = " "0, 1, 2, 3"
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_USERBASE"
      group.long 0xD8AC--0xD8AF "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_USERBASE (at 0x87BAD8AC)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.tbyte 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERBASE                       = "
    tree.end
	tree "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_USERMASK"
      group.long 0xD8B0--0xD8B3 "APCS_CCI_SRVCREQPROBE_MAIN_PROBE_FILTERS_1_USERMASK (at 0x87BAD8B0)"
      line.long 0x0 "VALUE"
      textline "BITS"
	  textline ""
	  hexmask.long.word 0x0 0x12--0x1F " [ 31: 18]  RESERVED_BITS31_18                       = "
	  textline ""
      hexmask.long.tbyte 0x0 0x0--0x11 " [ 17: 0]  FILTERS_1_USERMASK                       = "
    tree.end
tree.end


