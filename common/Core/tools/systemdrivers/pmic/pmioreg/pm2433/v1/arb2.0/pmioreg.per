entry &access &sid &cmd_addr &read_addr &write_addr
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&cmd_addr %l (0x8004000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&cmd_addr %l (0x8004010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&cmd_addr %l (0x8004040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&cmd_addr %l (0x8004050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&cmd_addr %l (0x8004080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&cmd_addr %l (0x8004440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&cmd_addr %l (0x8004d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&cmd_addr %l (0x8004d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&cmd_addr %l (0x8004da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&cmd_addr %l (0x8004db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&cmd_addr %l (0x8004e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x4e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&cmd_addr %l (0x8059000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&cmd_addr %l (0x8059010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&cmd_addr %l (0x8059020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&cmd_addr %l (0x8059030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&cmd_addr %l (0x8059040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&cmd_addr %l (0x8059050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&cmd_addr %l (0x8059080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0 (RC_19M_OFF),1 (RC_19M_ON)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&cmd_addr %l (0x8059100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0 (RC_19M_NOT_HALT),1 (RC_19M_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&cmd_addr %l (0x8059110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&cmd_addr %l (0x8059120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&cmd_addr %l (0x8059130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&cmd_addr %l (0x8059140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&cmd_addr %l (0x8059150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&cmd_addr %l (0x8059160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&cmd_addr %l (0x8059180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&cmd_addr %l (0x8059190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&cmd_addr %l (0x80591a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x591a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&cmd_addr %l (0x80591b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x591b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&cmd_addr %l (0x8059400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (SMPS_CLK_RC_19M),2 (SMPS_CLK_XO_19M),3 (SMPS_CLK_BASE_ON_HALT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0 (GP_CLK_XO_OUTBUFF_EN_DLY_AND_19M2_HALT_B),1 (GP_CLK_RC_19M),2 (GP_CLK_XO_19M),3 (GP_CLK_BASE_ON_HALT)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&cmd_addr %l (0x8059410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0 (ALT_SC_DIVIDER_DIS),1 (ALT_SC_DIVIDER_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&cmd_addr %l (0x8059420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&cmd_addr %l (0x8059430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0 (CALRC),1 (XO32K_EXT32K)"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      sgroup "CLK_DIST_HALT_CTL (at 0x5945)"
        set &access:&cmd_addr %l (0x8059450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0 (XO19M_HALT_DIS),1 (XO19M_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0 (FORCE_HALT_DIS),1 (FORCE_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_RC_CTL"
      sgroup "CLK_DIST_RC_CTL (at 0x5946)"
        set &access:&cmd_addr %l (0x8059460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0 (RC19M_NOT_FORCED),1 (RC19M_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0 (RC19M_NOT_FOLLOW_HW_DEMAND),1 (RC19M_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&cmd_addr %l (0x8059480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&cmd_addr %l (0x80594a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x594a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0 (NOT_FORCE_AWAKE),1 (FORCE_PMIC_AWAKE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (PMIC_AWAKE_NOT_FOLLOW_HW),1 (PMIC_AWAKE_FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&cmd_addr %l (0x8059510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&cmd_addr %l (0x8059520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&cmd_addr %l (0x8059530|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59530|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&cmd_addr %l (0x8059d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&cmd_addr %l (0x8059d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&cmd_addr %l (0x8059da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&cmd_addr %l (0x8059db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&cmd_addr %l (0x8059e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&cmd_addr %l (0x8059e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&cmd_addr %l (0x8059e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&cmd_addr %l (0x8059e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (CLK19M),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&cmd_addr %l (0x8059f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      sgroup "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
        set &access:&cmd_addr %l (0x8059f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      sgroup "CLK_DIST_RCLF_TRIM (at 0x59f2)"
        set &access:&cmd_addr %l (0x8059f20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x59f20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      sgroup "GPIO1_REVISION1 (at 0xc000)"
        set &access:&cmd_addr %l (0x80c0000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      sgroup "GPIO1_REVISION2 (at 0xc001)"
        set &access:&cmd_addr %l (0x80c0010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      sgroup "GPIO1_REVISION3 (at 0xc002)"
        set &access:&cmd_addr %l (0x80c0020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      sgroup "GPIO1_REVISION4 (at 0xc003)"
        set &access:&cmd_addr %l (0x80c0030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      sgroup "GPIO1_PERPH_TYPE (at 0xc004)"
        set &access:&cmd_addr %l (0x80c0040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      sgroup "GPIO1_PERPH_SUBTYPE (at 0xc005)"
        set &access:&cmd_addr %l (0x80c0050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      sgroup "GPIO1_STATUS1 (at 0xc008)"
        set &access:&cmd_addr %l (0x80c0080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO1_INT_RT_STS"
      sgroup "GPIO1_INT_RT_STS (at 0xc010)"
        set &access:&cmd_addr %l (0x80c0100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      sgroup "GPIO1_INT_SET_TYPE (at 0xc011)"
        set &access:&cmd_addr %l (0x80c0110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      sgroup "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&cmd_addr %l (0x80c0120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      sgroup "GPIO1_INT_POLARITY_LOW (at 0xc013)"
        set &access:&cmd_addr %l (0x80c0130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      sgroup "GPIO1_INT_LATCHED_CLR (at 0xc014)"
        set &access:&cmd_addr %l (0x80c0140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      sgroup "GPIO1_INT_EN_SET (at 0xc015)"
        set &access:&cmd_addr %l (0x80c0150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      sgroup "GPIO1_INT_EN_CLR (at 0xc016)"
        set &access:&cmd_addr %l (0x80c0160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      sgroup "GPIO1_INT_LATCHED_STS (at 0xc018)"
        set &access:&cmd_addr %l (0x80c0180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      sgroup "GPIO1_INT_PENDING_STS (at 0xc019)"
        set &access:&cmd_addr %l (0x80c0190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      sgroup "GPIO1_INT_MID_SEL (at 0xc01a)"
        set &access:&cmd_addr %l (0x80c01a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc01a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      sgroup "GPIO1_INT_PRIORITY (at 0xc01b)"
        set &access:&cmd_addr %l (0x80c01b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc01b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO1_MODE_CTL"
      sgroup "GPIO1_MODE_CTL (at 0xc040)"
        set &access:&cmd_addr %l (0x80c0400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      sgroup "GPIO1_DIG_VIN_CTL (at 0xc041)"
        set &access:&cmd_addr %l (0x80c0410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      sgroup "GPIO1_DIG_PULL_CTL (at 0xc042)"
        set &access:&cmd_addr %l (0x80c0420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO1_DIG_IN_CTL"
      sgroup "GPIO1_DIG_IN_CTL (at 0xc043)"
        set &access:&cmd_addr %l (0x80c0430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO1_DIG_OUT_CTL"
      sgroup "GPIO1_DIG_OUT_CTL (at 0xc045)"
        set &access:&cmd_addr %l (0x80c0450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO1_EN_CTL"
      sgroup "GPIO1_EN_CTL (at 0xc046)"
        set &access:&cmd_addr %l (0x80c0460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      sgroup "GPIO1_SEC_ACCESS (at 0xc0d0)"
        set &access:&cmd_addr %l (0x80c0d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      sgroup "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&cmd_addr %l (0x80c0d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      sgroup "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&cmd_addr %l (0x80c0d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      sgroup "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&cmd_addr %l (0x80c0da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      sgroup "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&cmd_addr %l (0x80c0db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      sgroup "GPIO2_REVISION1 (at 0xc100)"
        set &access:&cmd_addr %l (0x80c1000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      sgroup "GPIO2_REVISION2 (at 0xc101)"
        set &access:&cmd_addr %l (0x80c1010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      sgroup "GPIO2_REVISION3 (at 0xc102)"
        set &access:&cmd_addr %l (0x80c1020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      sgroup "GPIO2_REVISION4 (at 0xc103)"
        set &access:&cmd_addr %l (0x80c1030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      sgroup "GPIO2_PERPH_TYPE (at 0xc104)"
        set &access:&cmd_addr %l (0x80c1040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      sgroup "GPIO2_PERPH_SUBTYPE (at 0xc105)"
        set &access:&cmd_addr %l (0x80c1050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      sgroup "GPIO2_STATUS1 (at 0xc108)"
        set &access:&cmd_addr %l (0x80c1080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO2_INT_RT_STS"
      sgroup "GPIO2_INT_RT_STS (at 0xc110)"
        set &access:&cmd_addr %l (0x80c1100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      sgroup "GPIO2_INT_SET_TYPE (at 0xc111)"
        set &access:&cmd_addr %l (0x80c1110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      sgroup "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&cmd_addr %l (0x80c1120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      sgroup "GPIO2_INT_POLARITY_LOW (at 0xc113)"
        set &access:&cmd_addr %l (0x80c1130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      sgroup "GPIO2_INT_LATCHED_CLR (at 0xc114)"
        set &access:&cmd_addr %l (0x80c1140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      sgroup "GPIO2_INT_EN_SET (at 0xc115)"
        set &access:&cmd_addr %l (0x80c1150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      sgroup "GPIO2_INT_EN_CLR (at 0xc116)"
        set &access:&cmd_addr %l (0x80c1160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      sgroup "GPIO2_INT_LATCHED_STS (at 0xc118)"
        set &access:&cmd_addr %l (0x80c1180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      sgroup "GPIO2_INT_PENDING_STS (at 0xc119)"
        set &access:&cmd_addr %l (0x80c1190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      sgroup "GPIO2_INT_MID_SEL (at 0xc11a)"
        set &access:&cmd_addr %l (0x80c11a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc11a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      sgroup "GPIO2_INT_PRIORITY (at 0xc11b)"
        set &access:&cmd_addr %l (0x80c11b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc11b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO2_MODE_CTL"
      sgroup "GPIO2_MODE_CTL (at 0xc140)"
        set &access:&cmd_addr %l (0x80c1400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (RESERVED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      sgroup "GPIO2_DIG_VIN_CTL (at 0xc141)"
        set &access:&cmd_addr %l (0x80c1410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      sgroup "GPIO2_DIG_PULL_CTL (at 0xc142)"
        set &access:&cmd_addr %l (0x80c1420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO2_DIG_IN_CTL"
      sgroup "GPIO2_DIG_IN_CTL (at 0xc143)"
        set &access:&cmd_addr %l (0x80c1430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "GPIO2_DIG_OUT_CTL"
      sgroup "GPIO2_DIG_OUT_CTL (at 0xc145)"
        set &access:&cmd_addr %l (0x80c1450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_HIGH),2 (OPEN_LOW),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW),2 (MED),3 (HIGH)"
    tree.end
    tree "GPIO2_EN_CTL"
      sgroup "GPIO2_EN_CTL (at 0xc146)"
        set &access:&cmd_addr %l (0x80c1460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      sgroup "GPIO2_SEC_ACCESS (at 0xc1d0)"
        set &access:&cmd_addr %l (0x80c1d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      sgroup "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&cmd_addr %l (0x80c1d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      sgroup "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&cmd_addr %l (0x80c1d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      sgroup "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&cmd_addr %l (0x80c1da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      sgroup "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&cmd_addr %l (0x80c1db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc1db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&cmd_addr %l (0x8005000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&cmd_addr %l (0x8005010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&cmd_addr %l (0x8005040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&cmd_addr %l (0x8005050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&cmd_addr %l (0x8005080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&cmd_addr %l (0x8005090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&cmd_addr %l (0x8005400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&cmd_addr %l (0x8005460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&cmd_addr %l (0x8005d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&cmd_addr %l (0x8005d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&cmd_addr %l (0x8005d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&cmd_addr %l (0x8005da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&cmd_addr %l (0x8005db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&cmd_addr %l (0x8005e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&cmd_addr %l (0x802c000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&cmd_addr %l (0x802c010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&cmd_addr %l (0x802c020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&cmd_addr %l (0x802c030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&cmd_addr %l (0x802c040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&cmd_addr %l (0x802c050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&cmd_addr %l (0x802c080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&cmd_addr %l (0x802c440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&cmd_addr %l (0x802c460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&cmd_addr %l (0x802cd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&cmd_addr %l (0x802cd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&cmd_addr %l (0x802cd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&cmd_addr %l (0x802cda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&cmd_addr %l (0x802cdb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cdb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&cmd_addr %l (0x802ce20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2ce20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&cmd_addr %l (0x802ce30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2ce30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&cmd_addr %l (0x802cf00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&cmd_addr %l (0x802cf10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&cmd_addr %l (0x802cf20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&cmd_addr %l (0x802cf30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&cmd_addr %l (0x802cf40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&cmd_addr %l (0x802cf50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&cmd_addr %l (0x802cf60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&cmd_addr %l (0x802cf70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&cmd_addr %l (0x802cf80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&cmd_addr %l (0x8009000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&cmd_addr %l (0x8009010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&cmd_addr %l (0x8009020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&cmd_addr %l (0x8009030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&cmd_addr %l (0x8009040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&cmd_addr %l (0x8009050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS1"
      sgroup "MISC_STATUS1 (at 0x909)"
        set &access:&cmd_addr %l (0x8009090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      sgroup "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
        set &access:&cmd_addr %l (0x8009420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XVDD_DVDD_SRC_CTRL                       = " "0, 1"
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      sgroup "MISC_DTEST_DRV_CTL (at 0x943)"
        set &access:&cmd_addr %l (0x8009430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_DRV_EN                             = "
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      sgroup "MISC_DTEST_DRV_VAL (at 0x944)"
        set &access:&cmd_addr %l (0x8009440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_VAL                                = "
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      sgroup "MISC_BUCK_CMN_CTL1 (at 0x945)"
        set &access:&cmd_addr %l (0x8009450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   VPRE_CHARGE_SEL                          = " "0 (VPRE_CHARGE_LOW_RANGE_0P35V),1 (VPRE_CHARGE_LOW_RANGE_0P40V),2 (VPRE_CHARGE_LOW_RANGE_0P45V),3 (VPRE_CHARGE_LOW_RANGE_0P50V)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0 (BYPASS_IBG_DLY_DISABLED),1 (BYPASS_IBG_DLY_ENABLED)"
    tree.end
    tree "MISC_MISC_CTL1"
      sgroup "MISC_MISC_CTL1 (at 0x949)"
        set &access:&cmd_addr %l (0x8009490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_TRIGGER_DISABLE                      = " "0 (CBLPWR_N_PON_ENABLED),1 (CBLPWR_N_PON_DISABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FAULT_N_ENABLE                           = " "0 (FAULT_N_DISABLED_WHEN_HPBUCK_ENABLED),1 (FAULT_N_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VDD_IO_PRECISE_DET_DIS                   = " "0 (VDD_IO_PRECISE_DET_ENABLED),1 (VDD_IO_PRECISE_DET_DISABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALWAYS_ON_OVP_DIS                        = " "0 (ALWAYS_ON_OVP_TRIPS_FAULT_N_OUTPUT),1 (ALWAYS_ON_OVP_DOES_NOT_AFFECT_FAULT_N_PIN)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MISC_CTL                                 = "
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&cmd_addr %l (0x8009d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&cmd_addr %l (0x8009d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&cmd_addr %l (0x8009da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&cmd_addr %l (0x8009db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&cmd_addr %l (0x8009e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (TEST_ACCESS_DISABLED),1 (TEST_ACCESS_ENABLED)"
    tree.end
    tree "MISC_TEST1"
      sgroup "MISC_TEST1 (at 0x9e1)"
        set &access:&cmd_addr %l (0x8009e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (MISC_TEST1_DISABLE_DTEST4),1 (RESERVED1),2 (RESERVED2),3 (MISC_TEST1_TEST_ACCESS),4 (MISC_TEST1_BUCK_PWM_MSTR_EN),5 (MISC_TEST1_BUCK_MBG_MSTR_EN),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&cmd_addr %l (0x8009f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      sgroup "MPP1_REVISION1 (at 0xa000)"
        set &access:&cmd_addr %l (0x80a0000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      sgroup "MPP1_REVISION2 (at 0xa001)"
        set &access:&cmd_addr %l (0x80a0010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      sgroup "MPP1_REVISION3 (at 0xa002)"
        set &access:&cmd_addr %l (0x80a0020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      sgroup "MPP1_REVISION4 (at 0xa003)"
        set &access:&cmd_addr %l (0x80a0030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      sgroup "MPP1_PERPH_TYPE (at 0xa004)"
        set &access:&cmd_addr %l (0x80a0040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      sgroup "MPP1_PERPH_SUBTYPE (at 0xa005)"
        set &access:&cmd_addr %l (0x80a0050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      sgroup "MPP1_STATUS1 (at 0xa008)"
        set &access:&cmd_addr %l (0x80a0080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      sgroup "MPP1_INT_RT_STS (at 0xa010)"
        set &access:&cmd_addr %l (0x80a0100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      sgroup "MPP1_INT_SET_TYPE (at 0xa011)"
        set &access:&cmd_addr %l (0x80a0110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      sgroup "MPP1_INT_POLARITY_HIGH (at 0xa012)"
        set &access:&cmd_addr %l (0x80a0120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      sgroup "MPP1_INT_POLARITY_LOW (at 0xa013)"
        set &access:&cmd_addr %l (0x80a0130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      sgroup "MPP1_INT_LATCHED_CLR (at 0xa014)"
        set &access:&cmd_addr %l (0x80a0140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      sgroup "MPP1_INT_EN_SET (at 0xa015)"
        set &access:&cmd_addr %l (0x80a0150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      sgroup "MPP1_INT_EN_CLR (at 0xa016)"
        set &access:&cmd_addr %l (0x80a0160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      sgroup "MPP1_INT_LATCHED_STS (at 0xa018)"
        set &access:&cmd_addr %l (0x80a0180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      sgroup "MPP1_INT_PENDING_STS (at 0xa019)"
        set &access:&cmd_addr %l (0x80a0190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      sgroup "MPP1_INT_MID_SEL (at 0xa01a)"
        set &access:&cmd_addr %l (0x80a01a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa01a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      sgroup "MPP1_INT_PRIORITY (at 0xa01b)"
        set &access:&cmd_addr %l (0x80a01b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa01b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      sgroup "MPP1_MODE_CTL (at 0xa040)"
        set &access:&cmd_addr %l (0x80a0400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      sgroup "MPP1_DIG_VIN_CTL (at 0xa041)"
        set &access:&cmd_addr %l (0x80a0410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      sgroup "MPP1_DIG_PULL_CTL (at 0xa042)"
        set &access:&cmd_addr %l (0x80a0420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      sgroup "MPP1_DIG_IN_CTL (at 0xa043)"
        set &access:&cmd_addr %l (0x80a0430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      sgroup "MPP1_EN_CTL (at 0xa046)"
        set &access:&cmd_addr %l (0x80a0460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      sgroup "MPP1_ANA_OUT_CTL (at 0xa048)"
        set &access:&cmd_addr %l (0x80a0480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      sgroup "MPP1_ANA_IN_CTL (at 0xa04a)"
        set &access:&cmd_addr %l (0x80a04a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa04a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      sgroup "MPP1_SINK_CTL (at 0xa04c)"
        set &access:&cmd_addr %l (0x80a04c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa04c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      sgroup "MPP1_SEC_ACCESS (at 0xa0d0)"
        set &access:&cmd_addr %l (0x80a0d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      sgroup "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
        set &access:&cmd_addr %l (0x80a0d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      sgroup "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
        set &access:&cmd_addr %l (0x80a0d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      sgroup "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
        set &access:&cmd_addr %l (0x80a0da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      sgroup "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
        set &access:&cmd_addr %l (0x80a0db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      sgroup "MPP2_REVISION1 (at 0xa100)"
        set &access:&cmd_addr %l (0x80a1000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      sgroup "MPP2_REVISION2 (at 0xa101)"
        set &access:&cmd_addr %l (0x80a1010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      sgroup "MPP2_REVISION3 (at 0xa102)"
        set &access:&cmd_addr %l (0x80a1020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      sgroup "MPP2_REVISION4 (at 0xa103)"
        set &access:&cmd_addr %l (0x80a1030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      sgroup "MPP2_PERPH_TYPE (at 0xa104)"
        set &access:&cmd_addr %l (0x80a1040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      sgroup "MPP2_PERPH_SUBTYPE (at 0xa105)"
        set &access:&cmd_addr %l (0x80a1050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      sgroup "MPP2_STATUS1 (at 0xa108)"
        set &access:&cmd_addr %l (0x80a1080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      sgroup "MPP2_INT_RT_STS (at 0xa110)"
        set &access:&cmd_addr %l (0x80a1100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      sgroup "MPP2_INT_SET_TYPE (at 0xa111)"
        set &access:&cmd_addr %l (0x80a1110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      sgroup "MPP2_INT_POLARITY_HIGH (at 0xa112)"
        set &access:&cmd_addr %l (0x80a1120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      sgroup "MPP2_INT_POLARITY_LOW (at 0xa113)"
        set &access:&cmd_addr %l (0x80a1130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      sgroup "MPP2_INT_LATCHED_CLR (at 0xa114)"
        set &access:&cmd_addr %l (0x80a1140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      sgroup "MPP2_INT_EN_SET (at 0xa115)"
        set &access:&cmd_addr %l (0x80a1150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      sgroup "MPP2_INT_EN_CLR (at 0xa116)"
        set &access:&cmd_addr %l (0x80a1160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      sgroup "MPP2_INT_LATCHED_STS (at 0xa118)"
        set &access:&cmd_addr %l (0x80a1180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      sgroup "MPP2_INT_PENDING_STS (at 0xa119)"
        set &access:&cmd_addr %l (0x80a1190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      sgroup "MPP2_INT_MID_SEL (at 0xa11a)"
        set &access:&cmd_addr %l (0x80a11a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa11a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      sgroup "MPP2_INT_PRIORITY (at 0xa11b)"
        set &access:&cmd_addr %l (0x80a11b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa11b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      sgroup "MPP2_MODE_CTL (at 0xa140)"
        set &access:&cmd_addr %l (0x80a1400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      sgroup "MPP2_DIG_VIN_CTL (at 0xa141)"
        set &access:&cmd_addr %l (0x80a1410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      sgroup "MPP2_DIG_PULL_CTL (at 0xa142)"
        set &access:&cmd_addr %l (0x80a1420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      sgroup "MPP2_DIG_IN_CTL (at 0xa143)"
        set &access:&cmd_addr %l (0x80a1430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      sgroup "MPP2_EN_CTL (at 0xa146)"
        set &access:&cmd_addr %l (0x80a1460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      sgroup "MPP2_ANA_OUT_CTL (at 0xa148)"
        set &access:&cmd_addr %l (0x80a1480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      sgroup "MPP2_ANA_IN_CTL (at 0xa14a)"
        set &access:&cmd_addr %l (0x80a14a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa14a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      sgroup "MPP2_SINK_CTL (at 0xa14c)"
        set &access:&cmd_addr %l (0x80a14c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa14c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      sgroup "MPP2_SEC_ACCESS (at 0xa1d0)"
        set &access:&cmd_addr %l (0x80a1d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      sgroup "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
        set &access:&cmd_addr %l (0x80a1d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      sgroup "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
        set &access:&cmd_addr %l (0x80a1d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      sgroup "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
        set &access:&cmd_addr %l (0x80a1da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      sgroup "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
        set &access:&cmd_addr %l (0x80a1db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      sgroup "MPP3_REVISION1 (at 0xa200)"
        set &access:&cmd_addr %l (0x80a2000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      sgroup "MPP3_REVISION2 (at 0xa201)"
        set &access:&cmd_addr %l (0x80a2010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      sgroup "MPP3_REVISION3 (at 0xa202)"
        set &access:&cmd_addr %l (0x80a2020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      sgroup "MPP3_REVISION4 (at 0xa203)"
        set &access:&cmd_addr %l (0x80a2030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      sgroup "MPP3_PERPH_TYPE (at 0xa204)"
        set &access:&cmd_addr %l (0x80a2040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      sgroup "MPP3_PERPH_SUBTYPE (at 0xa205)"
        set &access:&cmd_addr %l (0x80a2050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      sgroup "MPP3_STATUS1 (at 0xa208)"
        set &access:&cmd_addr %l (0x80a2080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      sgroup "MPP3_INT_RT_STS (at 0xa210)"
        set &access:&cmd_addr %l (0x80a2100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      sgroup "MPP3_INT_SET_TYPE (at 0xa211)"
        set &access:&cmd_addr %l (0x80a2110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      sgroup "MPP3_INT_POLARITY_HIGH (at 0xa212)"
        set &access:&cmd_addr %l (0x80a2120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      sgroup "MPP3_INT_POLARITY_LOW (at 0xa213)"
        set &access:&cmd_addr %l (0x80a2130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      sgroup "MPP3_INT_LATCHED_CLR (at 0xa214)"
        set &access:&cmd_addr %l (0x80a2140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      sgroup "MPP3_INT_EN_SET (at 0xa215)"
        set &access:&cmd_addr %l (0x80a2150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      sgroup "MPP3_INT_EN_CLR (at 0xa216)"
        set &access:&cmd_addr %l (0x80a2160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      sgroup "MPP3_INT_LATCHED_STS (at 0xa218)"
        set &access:&cmd_addr %l (0x80a2180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      sgroup "MPP3_INT_PENDING_STS (at 0xa219)"
        set &access:&cmd_addr %l (0x80a2190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      sgroup "MPP3_INT_MID_SEL (at 0xa21a)"
        set &access:&cmd_addr %l (0x80a21a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa21a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      sgroup "MPP3_INT_PRIORITY (at 0xa21b)"
        set &access:&cmd_addr %l (0x80a21b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa21b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      sgroup "MPP3_MODE_CTL (at 0xa240)"
        set &access:&cmd_addr %l (0x80a2400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      sgroup "MPP3_DIG_VIN_CTL (at 0xa241)"
        set &access:&cmd_addr %l (0x80a2410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      sgroup "MPP3_DIG_PULL_CTL (at 0xa242)"
        set &access:&cmd_addr %l (0x80a2420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      sgroup "MPP3_DIG_IN_CTL (at 0xa243)"
        set &access:&cmd_addr %l (0x80a2430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      sgroup "MPP3_EN_CTL (at 0xa246)"
        set &access:&cmd_addr %l (0x80a2460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      sgroup "MPP3_ANA_OUT_CTL (at 0xa248)"
        set &access:&cmd_addr %l (0x80a2480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      sgroup "MPP3_ANA_IN_CTL (at 0xa24a)"
        set &access:&cmd_addr %l (0x80a24a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa24a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      sgroup "MPP3_SINK_CTL (at 0xa24c)"
        set &access:&cmd_addr %l (0x80a24c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa24c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      sgroup "MPP3_SEC_ACCESS (at 0xa2d0)"
        set &access:&cmd_addr %l (0x80a2d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      sgroup "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
        set &access:&cmd_addr %l (0x80a2d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      sgroup "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
        set &access:&cmd_addr %l (0x80a2d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      sgroup "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
        set &access:&cmd_addr %l (0x80a2da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      sgroup "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
        set &access:&cmd_addr %l (0x80a2db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      sgroup "MPP4_REVISION1 (at 0xa300)"
        set &access:&cmd_addr %l (0x80a3000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      sgroup "MPP4_REVISION2 (at 0xa301)"
        set &access:&cmd_addr %l (0x80a3010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      sgroup "MPP4_REVISION3 (at 0xa302)"
        set &access:&cmd_addr %l (0x80a3020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      sgroup "MPP4_REVISION4 (at 0xa303)"
        set &access:&cmd_addr %l (0x80a3030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      sgroup "MPP4_PERPH_TYPE (at 0xa304)"
        set &access:&cmd_addr %l (0x80a3040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      sgroup "MPP4_PERPH_SUBTYPE (at 0xa305)"
        set &access:&cmd_addr %l (0x80a3050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      sgroup "MPP4_STATUS1 (at 0xa308)"
        set &access:&cmd_addr %l (0x80a3080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      sgroup "MPP4_INT_RT_STS (at 0xa310)"
        set &access:&cmd_addr %l (0x80a3100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      sgroup "MPP4_INT_SET_TYPE (at 0xa311)"
        set &access:&cmd_addr %l (0x80a3110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      sgroup "MPP4_INT_POLARITY_HIGH (at 0xa312)"
        set &access:&cmd_addr %l (0x80a3120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      sgroup "MPP4_INT_POLARITY_LOW (at 0xa313)"
        set &access:&cmd_addr %l (0x80a3130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      sgroup "MPP4_INT_LATCHED_CLR (at 0xa314)"
        set &access:&cmd_addr %l (0x80a3140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      sgroup "MPP4_INT_EN_SET (at 0xa315)"
        set &access:&cmd_addr %l (0x80a3150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      sgroup "MPP4_INT_EN_CLR (at 0xa316)"
        set &access:&cmd_addr %l (0x80a3160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      sgroup "MPP4_INT_LATCHED_STS (at 0xa318)"
        set &access:&cmd_addr %l (0x80a3180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      sgroup "MPP4_INT_PENDING_STS (at 0xa319)"
        set &access:&cmd_addr %l (0x80a3190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      sgroup "MPP4_INT_MID_SEL (at 0xa31a)"
        set &access:&cmd_addr %l (0x80a31a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa31a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      sgroup "MPP4_INT_PRIORITY (at 0xa31b)"
        set &access:&cmd_addr %l (0x80a31b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa31b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      sgroup "MPP4_MODE_CTL (at 0xa340)"
        set &access:&cmd_addr %l (0x80a3400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      sgroup "MPP4_DIG_VIN_CTL (at 0xa341)"
        set &access:&cmd_addr %l (0x80a3410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      sgroup "MPP4_DIG_PULL_CTL (at 0xa342)"
        set &access:&cmd_addr %l (0x80a3420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      sgroup "MPP4_DIG_IN_CTL (at 0xa343)"
        set &access:&cmd_addr %l (0x80a3430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      sgroup "MPP4_EN_CTL (at 0xa346)"
        set &access:&cmd_addr %l (0x80a3460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      sgroup "MPP4_ANA_OUT_CTL (at 0xa348)"
        set &access:&cmd_addr %l (0x80a3480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      sgroup "MPP4_ANA_IN_CTL (at 0xa34a)"
        set &access:&cmd_addr %l (0x80a34a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa34a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      sgroup "MPP4_SINK_CTL (at 0xa34c)"
        set &access:&cmd_addr %l (0x80a34c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa34c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      sgroup "MPP4_SEC_ACCESS (at 0xa3d0)"
        set &access:&cmd_addr %l (0x80a3d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      sgroup "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
        set &access:&cmd_addr %l (0x80a3d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      sgroup "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
        set &access:&cmd_addr %l (0x80a3d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      sgroup "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
        set &access:&cmd_addr %l (0x80a3da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      sgroup "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
        set &access:&cmd_addr %l (0x80a3db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PADC1_USR"
  tree "PADC1_USR"
    tree "PADC1_USR_REVISION1"
      sgroup "PADC1_USR_REVISION1 (at 0x3000)"
        set &access:&cmd_addr %l (0x8030000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PADC1_USR_REVISION2"
      sgroup "PADC1_USR_REVISION2 (at 0x3001)"
        set &access:&cmd_addr %l (0x8030010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PADC1_USR_REVISION3"
      sgroup "PADC1_USR_REVISION3 (at 0x3002)"
        set &access:&cmd_addr %l (0x8030020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PADC1_USR_REVISION4"
      sgroup "PADC1_USR_REVISION4 (at 0x3003)"
        set &access:&cmd_addr %l (0x8030030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PADC1_USR_PERPH_TYPE"
      sgroup "PADC1_USR_PERPH_TYPE (at 0x3004)"
        set &access:&cmd_addr %l (0x8030040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PADC1_USR_PERPH_SUBTYPE"
      sgroup "PADC1_USR_PERPH_SUBTYPE (at 0x3005)"
        set &access:&cmd_addr %l (0x8030050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PADC1_USR_STATUS1"
      sgroup "PADC1_USR_STATUS1 (at 0x3008)"
        set &access:&cmd_addr %l (0x8030080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_OUT                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   V_BCL_DONE                               = " "0 (V_BCL_DONE_FLAG_FALSE),1 (V_BCL_DONE_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   I_BCL_DONE                               = " "0 (I_BCL_DONE_FLAG_FALSE),1 (I_BCL_DONE_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE                                = " "0 (VADC_DONE_FLAG_FALSE),1 (VADC_DONE_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE                                = " "0 (IADC_DONE_FLAG_FALSE),1 (IADC_DONE_FLAG_TRUE)"
    tree.end
    tree "PADC1_USR_INT_RT_STS"
      sgroup "PADC1_USR_INT_RT_STS (at 0x3010)"
        set &access:&cmd_addr %l (0x8030100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_RT_STS                     = " "0 (VADC_DONE_INT_FALSE),1 (VADC_DONE_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_RT_STS                     = " "0 (IADC_DONE_INT_FALSE),1 (IADC_DONE_INT_TRUE)"
    tree.end
    tree "PADC1_USR_INT_SET_TYPE"
      sgroup "PADC1_USR_INT_SET_TYPE (at 0x3011)"
        set &access:&cmd_addr %l (0x8030110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_SET_INT_TYPE                   = " "0 (VADC_DONE_INT_LEVEL_TRIGGERED),1 (VADC_DONE_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_SET_INT_TYPE                   = " "0 (IADC_DONE_INT_LEVEL_TRIGGERED),1 (IADC_DONE_INT_EDGE_TRIGGERED)"
    tree.end
    tree "PADC1_USR_INT_POLARITY_HIGH"
      sgroup "PADC1_USR_INT_POLARITY_HIGH (at 0x3012)"
        set &access:&cmd_addr %l (0x8030120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_HIGH                       = " "0 (VADC_DONE_INT_RISING_EDGE_TRIGGER_DISABL),1 (VADC_DONE_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_HIGH                       = " "0 (IADC_DONE_INT_RISING_EDGE_TRIGGER_DISABL),1 (IADC_DONE_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "PADC1_USR_INT_POLARITY_LOW"
      sgroup "PADC1_USR_INT_POLARITY_LOW (at 0x3013)"
        set &access:&cmd_addr %l (0x8030130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_LOW                        = " "0 (VADC_DONE_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VADC_DONE_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_LOW                        = " "0 (IADC_DONE_INT_FALLING_EDGE_TRIGGER_DISABL),1 (IADC_DONE_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "PADC1_USR_INT_LATCHED_CLR"
      sgroup "PADC1_USR_INT_LATCHED_CLR (at 0x3014)"
        set &access:&cmd_addr %l (0x8030140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_LATCHED_CLR                = " "0, 1"
    tree.end
    tree "PADC1_USR_INT_EN_SET"
      sgroup "PADC1_USR_INT_EN_SET (at 0x3015)"
        set &access:&cmd_addr %l (0x8030150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_EN_SET                     = " "0 (VADC_DONE_INT_DISABLE),1 (VADC_DONE_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_EN_SET                     = " "0 (IADC_DONE_INT_DISABLE),1 (IADC_DONE_INT_ENABLE)"
    tree.end
    tree "PADC1_USR_INT_EN_CLR"
      sgroup "PADC1_USR_INT_EN_CLR (at 0x3016)"
        set &access:&cmd_addr %l (0x8030160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_EN_CLR                     = " "0 (VADC_DONE_INT_DISABLE),1 (VADC_DONE_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_EN_CLR                     = " "0 (IADC_DONE_INT_DISABLE),1 (IADC_DONE_INT_ENABLE)"
    tree.end
    tree "PADC1_USR_INT_LATCHED_STS"
      sgroup "PADC1_USR_INT_LATCHED_STS (at 0x3018)"
        set &access:&cmd_addr %l (0x8030180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_LATCHED_STS                = " "0 (VADC_DONE_INT_NOT_TRIGGERED),1 (VADC_DONE_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_LATCHED_STS                = " "0 (IADC_DONE_INT_NOT_TRIGGERED),1 (IADC_DONE_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "PADC1_USR_INT_PENDING_STS"
      sgroup "PADC1_USR_INT_PENDING_STS (at 0x3019)"
        set &access:&cmd_addr %l (0x8030190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_PENDING_STS                = " "0 (VADC_DONE_INT_NOT_PENDING),1 (VADC_DONE_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_PENDING_STS                = " "0 (IADC_DONE_INT_NOT_PENDING),1 (IADC_DONE_INT_PENDING)"
    tree.end
    tree "PADC1_USR_INT_MID_SEL"
      sgroup "PADC1_USR_INT_MID_SEL (at 0x301a)"
        set &access:&cmd_addr %l (0x80301a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x301a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "PADC1_USR_INT_PRIORITY"
      sgroup "PADC1_USR_INT_PRIORITY (at 0x301b)"
        set &access:&cmd_addr %l (0x80301b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x301b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR_0),1 (INT_PRIORITY_A_1)"
    tree.end
    tree "PADC1_USR_EN_CTL1"
      sgroup "PADC1_USR_EN_CTL1 (at 0x3046)"
        set &access:&cmd_addr %l (0x8030460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLE),1 (ADC_ENABLE)"
    tree.end
    tree "PADC1_USR_ADC_LEGACY1"
      sgroup "PADC1_USR_ADC_LEGACY1 (at 0x3050)"
        set &access:&cmd_addr %l (0x8030500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   IADC_TIMER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   VADC_BIT_SEL                             = " "0 (VADC_15BIT),1 (VADC_14BIT),2 (VADC_13BIT),3 (VADC_12BIT),4 (VADC_11BIT),5 (VADC_10BIT),6 (VADC_09BIT),7 (VADC_08BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IADC_BIT_SEL                             = " "0 (IADC_15BIT),1 (IADC_14BIT),2 (IADC_13BIT),3 (IADC_12BIT),4 (IADC_11BIT),5 (IADC_10BIT),6 (IADC_09BIT),7 (IADC_08BIT)"
    tree.end
    tree "PADC1_USR_ADC_LEGACY2"
      sgroup "PADC1_USR_ADC_LEGACY2 (at 0x3051)"
        set &access:&cmd_addr %l (0x8030510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   V_ADC_OE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   I_ADC_OE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   I_ADC_SLOW_MODE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   I_ADC_SLOW_MODE_FAST_CLK                 = " "0, 1"
    tree.end
    tree "PADC1_USR_ADC_LEGACY3"
      sgroup "PADC1_USR_ADC_LEGACY3 (at 0x3052)"
        set &access:&cmd_addr %l (0x8030520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADC_BYTE_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   V_BCL_CONV                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   I_BCL_CONV                               = " "0, 1"
    tree.end
    tree "PADC1_USR_VADC_DATA0"
      sgroup "PADC1_USR_VADC_DATA0 (at 0x3054)"
        set &access:&cmd_addr %l (0x8030540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "PADC1_USR_VADC_DATA1"
      sgroup "PADC1_USR_VADC_DATA1 (at 0x3055)"
        set &access:&cmd_addr %l (0x8030550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "PADC1_USR_IADC_DATA0"
      sgroup "PADC1_USR_IADC_DATA0 (at 0x3056)"
        set &access:&cmd_addr %l (0x8030560|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30560|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "PADC1_USR_IADC_DATA1"
      sgroup "PADC1_USR_IADC_DATA1 (at 0x3057)"
        set &access:&cmd_addr %l (0x8030570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "PADC1_USR_BCL_VDATA"
      sgroup "PADC1_USR_BCL_VDATA (at 0x3058)"
        set &access:&cmd_addr %l (0x8030580|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30580|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "PADC1_USR_BCL_IDATA"
      sgroup "PADC1_USR_BCL_IDATA (at 0x3059)"
        set &access:&cmd_addr %l (0x8030590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "PADC1_USR_SEC_ACCESS"
      sgroup "PADC1_USR_SEC_ACCESS (at 0x30d0)"
        set &access:&cmd_addr %l (0x8030d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PADC1_USR_PERPH_RESET_CTL1"
      sgroup "PADC1_USR_PERPH_RESET_CTL1 (at 0x30d8)"
        set &access:&cmd_addr %l (0x8030d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "PADC1_USR_PERPH_RESET_CTL2"
      sgroup "PADC1_USR_PERPH_RESET_CTL2 (at 0x30d9)"
        set &access:&cmd_addr %l (0x8030d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PADC1_USR_PERPH_RESET_CTL3"
      sgroup "PADC1_USR_PERPH_RESET_CTL3 (at 0x30da)"
        set &access:&cmd_addr %l (0x8030da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PADC1_USR_PERPH_RESET_CTL4"
      sgroup "PADC1_USR_PERPH_RESET_CTL4 (at 0x30db)"
        set &access:&cmd_addr %l (0x8030db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "PADC1_USR_INT_TEST1"
      sgroup "PADC1_USR_INT_TEST1 (at 0x30e0)"
        set &access:&cmd_addr %l (0x8030e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "PADC1_USR_INT_TEST_VAL"
      sgroup "PADC1_USR_INT_TEST_VAL (at 0x30e1)"
        set &access:&cmd_addr %l (0x8030e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_DONE_INT_TEST_VAL                   = " "0 (VADC_DONE_INT_TEST_VAL_0),1 (VADC_DONE_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_DONE_INT_TEST_VAL                   = " "0 (IADC_DONE_INT_TEST_VAL_0),1 (IADC_DONE_INT_TEST_VAL_1)"
    tree.end
    tree "PADC1_USR_PADC_ATEST"
      sgroup "PADC1_USR_PADC_ATEST (at 0x30e2)"
        set &access:&cmd_addr %l (0x8030e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NORMAL),1 (ATEST2_INPUT_VADC_INM3),2 (ATEST2_INPUT_VADC_ALTREFLNM),3 (ATEST2_INPUT_IADC_CALINP2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NORMAL),1 (ATEST1_INPUT_VADC_INP3),2 (ATEST1_INPUT_VADC_ALTREFLNP),3 (ATEST1_INPUT_IADC_CALINP1)"
    tree.end
    tree "PADC1_USR_PADC_DTEST"
      sgroup "PADC1_USR_PADC_DTEST (at 0x30e3)"
        set &access:&cmd_addr %l (0x8030e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PADC_DTEST                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PADC1_USR_ADC_TST1"
      sgroup "PADC1_USR_ADC_TST1 (at 0x30e4)"
        set &access:&cmd_addr %l (0x8030e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TSEL_DAT_IADC                            = " "0 (TSEL_DAT_IADC_FALSE),1 (TEST_DAT_IADC_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TSEL_DAT_VADC                            = " "0 (TSEL_DAT_VADC_FALSE),1 (TEST_DAT_VADC_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TDAT_LOAD_IADC                           = " "0 (TDAT_LOAD_IADC_FALSE),1 (TDAT_LOAD_IADC_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TDAT_LOAD_VADC                           = " "0 (TDAT_LOAD_VADC_FALSE),1 (TDAT_LOAD_VADC_TRUE)"
    tree.end
    tree "PADC1_USR_ADC_TST2"
      sgroup "PADC1_USR_ADC_TST2 (at 0x30e5)"
        set &access:&cmd_addr %l (0x8030e50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "PADC1_USR_ADC_TST3"
      sgroup "PADC1_USR_ADC_TST3 (at 0x30e6)"
        set &access:&cmd_addr %l (0x8030e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "PADC1_USR_ADC_TST4"
      sgroup "PADC1_USR_ADC_TST4 (at 0x30e7)"
        set &access:&cmd_addr %l (0x8030e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "PADC1_USR_ADC_TST5"
      sgroup "PADC1_USR_ADC_TST5 (at 0x30e8)"
        set &access:&cmd_addr %l (0x8030e80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "PADC1_USR_ADC_TST6"
      sgroup "PADC1_USR_ADC_TST6 (at 0x30e9)"
        set &access:&cmd_addr %l (0x8030e90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30e90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "PADC1_USR_ADC_TST7"
      sgroup "PADC1_USR_ADC_TST7 (at 0x30ea)"
        set &access:&cmd_addr %l (0x8030ea0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30ea0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   VSRC_SEL                                 = " "0 (VSRC_SEL_VIN),1 (VSRC_SEL_VOUT_PCB),2 (VSRC_SEL_VTHERM),3 (VSRC_SEL_VOUT_CHIP),4 (VSRC_SEL_ATEST1_ATEST2_DIFFERENTIAL),5 (VSRC_SEL_VREF_FULLSCALE),6 (VSRC_SEL_VREF_OFFSET),7 (VSRC_SEL_HIZ)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISRC_SEL                                 = " "0 (ISRC_SEL_IIN),1 (ISRC_SEL_DUTY),2 (ISRC_SEL_VREF_FULLSCALE),3 (ISRC_SEL_VREF_OFFSET),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "PADC1_USR_ADC_REF_BUF_TST"
      sgroup "PADC1_USR_ADC_REF_BUF_TST (at 0x30eb)"
        set &access:&cmd_addr %l (0x8030eb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30eb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VADC_BUF_EN                              = " "0 (VADC_BUF_DISABLE),1 (VADC_BUF_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADC_REF_SEL                             = " "0 (VADC_REF_SEL_0),1 (VADC_REF_SEL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_REF_SEL                             = " "0 (IADC_REF_SEL_0),1 (IADC_REF_SEL_1)"
    tree.end
    tree "PADC1_USR_PMON_CYA_CFG"
      sgroup "PADC1_USR_PMON_CYA_CFG (at 0x30ec)"
        set &access:&cmd_addr %l (0x8030ec0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30ec0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LCSMB_TRIM                               = " "0 (DO_NOT_USE_ADC_LOW_CURRENT_MODE),1 (USE_ADC_LOW_CURRENT_MODE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   V_BCL_ADC_BIT_SEL                        = " "0 (I_BCL_ADC_7_BIT_LONG),1 (I_BCL_ADC_8_BIT_LONG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   I_BCL_ADC_BIT_SEL                        = " "0 (I_BCL_ADC_7_BIT_LONG),1 (I_BCL_ADC_8_BIT_LONG)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   V_ADC_CMP_POL_TRIM                       = " "0 (V_ADC_POS_IS_POS),1 (V_ADC_POS_IS_NEG)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   I_ADC_CMP_POL_TRIM                       = " "0 (I_ADC_DISCH_POS),1 (I_ADC_DISCH_NEG)"
    tree.end
    tree "PADC1_USR_ADC_TEST_DATA"
      sgroup "PADC1_USR_ADC_TEST_DATA (at 0x30ed)"
        set &access:&cmd_addr %l (0x8030ed0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30ed0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BYTE_7_0                                 = "
    tree.end
    tree "PADC1_USR_ADC_CLK_TEST"
      sgroup "PADC1_USR_ADC_CLK_TEST (at 0x30ee)"
        set &access:&cmd_addr %l (0x8030ee0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30ee0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLKSEL                                   = " "0 (ADC_CLK_TEST_200K),1 (ADC_CLK_TEST_100K),2 (ADC_CLK_TEST_300K),3 (ADC_CLK_TEST_400K)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CLKPHASE                                 = "
    tree.end
    tree "PADC1_USR_TRIM_NUM"
      sgroup "PADC1_USR_TRIM_NUM (at 0x30f0)"
        set &access:&cmd_addr %l (0x8030f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "PADC1_USR_TRIM_IADC1"
      sgroup "PADC1_USR_TRIM_IADC1 (at 0x30f1)"
        set &access:&cmd_addr %l (0x8030f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_TRIM1                               = "
    tree.end
    tree "PADC1_USR_TRIM_IADC2"
      sgroup "PADC1_USR_TRIM_IADC2 (at 0x30f2)"
        set &access:&cmd_addr %l (0x8030f20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30f20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_TRIM2                               = "
    tree.end
    tree "PADC1_USR_TRIM_IADC3"
      sgroup "PADC1_USR_TRIM_IADC3 (at 0x30f3)"
        set &access:&cmd_addr %l (0x8030f30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30f30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_TRIM3                               = "
    tree.end
    tree "PADC1_USR_TRIM_VADC1"
      sgroup "PADC1_USR_TRIM_VADC1 (at 0x30f4)"
        set &access:&cmd_addr %l (0x8030f40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30f40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VADC_TRIM1                               = "
    tree.end
    tree "PADC1_USR_TRIM_VADC2"
      sgroup "PADC1_USR_TRIM_VADC2 (at 0x30f5)"
        set &access:&cmd_addr %l (0x8030f50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30f50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VADC_TRIM2                               = "
    tree.end
    tree "PADC1_USR_TRIM_VADC3"
      sgroup "PADC1_USR_TRIM_VADC3 (at 0x30f6)"
        set &access:&cmd_addr %l (0x8030f60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x30f60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VADC_TRIM3                               = "
    tree.end
  tree.end
tree.end
tree "PBG"
  tree "PBG"
    tree "PBG_REVISION1"
      sgroup "PBG_REVISION1 (at 0x2d00)"
        set &access:&cmd_addr %l (0x802d000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBG_REVISION2"
      sgroup "PBG_REVISION2 (at 0x2d01)"
        set &access:&cmd_addr %l (0x802d010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBG_REVISION3"
      sgroup "PBG_REVISION3 (at 0x2d02)"
        set &access:&cmd_addr %l (0x802d020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBG_REVISION4"
      sgroup "PBG_REVISION4 (at 0x2d03)"
        set &access:&cmd_addr %l (0x802d030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBG_PERPH_TYPE"
      sgroup "PBG_PERPH_TYPE (at 0x2d04)"
        set &access:&cmd_addr %l (0x802d040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBG_PERPH_SUBTYPE"
      sgroup "PBG_PERPH_SUBTYPE (at 0x2d05)"
        set &access:&cmd_addr %l (0x802d050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBG_STATUS1"
      sgroup "PBG_STATUS1 (at 0x2d08)"
        set &access:&cmd_addr %l (0x802d080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PBG_OK                                   = " "0 (PBG_OK_FALSE),1 (PBG_OK_TRUE)"
    tree.end
    tree "PBG_EN_CTL1"
      sgroup "PBG_EN_CTL1 (at 0x2d46)"
        set &access:&cmd_addr %l (0x802d460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PBG_EN                                   = " "0 (PBG_EN_FALSE),1 (PBG_EN_TRUE)"
    tree.end
    tree "PBG_BG_CTL"
      sgroup "PBG_BG_CTL (at 0x2d51)"
        set &access:&cmd_addr %l (0x802d510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HRBG_SWITCH_ENB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   HRBG_CFG1                                = " "0 (NONE_SELECTED),1 (PVIN_SELECTED),2 (VIN_QUIET_SELECTED),3 (NOT_VALID)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HRBG_HI_CUR                              = " "0, 1"
    tree.end
    tree "PBG_POUT_CTL"
      sgroup "PBG_POUT_CTL (at 0x2d52)"
        set &access:&cmd_addr %l (0x802d520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2d520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DUTY_RST                                 = " "0 (DUTY_RST_FALSE),1 (DUTY_RST_TRUE)"
    tree.end
    tree "PBG_SEC_ACCESS"
      sgroup "PBG_SEC_ACCESS (at 0x2dd0)"
        set &access:&cmd_addr %l (0x802dd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2dd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBG_PERPH_RESET_CTL1"
      sgroup "PBG_PERPH_RESET_CTL1 (at 0x2dd8)"
        set &access:&cmd_addr %l (0x802dd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2dd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "PBG_PERPH_RESET_CTL2"
      sgroup "PBG_PERPH_RESET_CTL2 (at 0x2dd9)"
        set &access:&cmd_addr %l (0x802dd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2dd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBG_PERPH_RESET_CTL3"
      sgroup "PBG_PERPH_RESET_CTL3 (at 0x2dda)"
        set &access:&cmd_addr %l (0x802dda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2dda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBG_PERPH_RESET_CTL4"
      sgroup "PBG_PERPH_RESET_CTL4 (at 0x2ddb)"
        set &access:&cmd_addr %l (0x802ddb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2ddb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "PBG_BG_TEST"
      sgroup "PBG_BG_TEST (at 0x2de2)"
        set &access:&cmd_addr %l (0x802de20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2de20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   HRGB_TESTBG                              = " "0, 1, 2, 3"
    tree.end
    tree "PBG_DUTY_TEST"
      sgroup "PBG_DUTY_TEST (at 0x2de4)"
        set &access:&cmd_addr %l (0x802de40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2de40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DUTY_TEST_EN                             = " "0 (DUTY_TEST_EN_FALSE),1 (DUTY_TEST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DUTY_BIAS_2X                             = " "0 (DUTY_BIAS_2X_FALSE),1 (DUTY_BIAS_2X_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DUTY_CAL_EN                              = " "0 (DUTY_CAL_EN_FALSE),1 (DUTY_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SWLOSS_EN                                = " "0 (SWLOSS_EN_FALSE),1 (SWLOSS_EN_TRUE)"
    tree.end
    tree "PBG_ADC_REF_TEST"
      sgroup "PBG_ADC_REF_TEST (at 0x2de5)"
        set &access:&cmd_addr %l (0x802de50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2de50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADRF_ENCC_TRIM                           = " "0, 1"
    tree.end
    tree "PBG_PBG_ATEST"
      sgroup "PBG_PBG_ATEST (at 0x2def)"
        set &access:&cmd_addr %l (0x802def0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2def0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ATEST3                                   = " "0 (PBG_ATEST3_NORMAL),1 (PBG_ATEST3_VTHERM_PADR),2 (PBG_ATEST3_ADRG_REF_1P1),3 (PBG_ATEST3_DUTY_OUT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (PBG_ATEST2_NORMAL),1 (PBG_ATEST2_ADC_REF),2 (PBG_ATEST2_VBG),3 (PBG_ATEST2_INVALID)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (PBG_ATEST1_NORMAL),1 (PBG_ATEST1_IREF_5UA_TRIM),2 (PBG_ATEST1_ISRC_1UA_TLOOP),3 (PBG_ATEST1_BGDATA)"
    tree.end
    tree "PBG_TRIM_NUM"
      sgroup "PBG_TRIM_NUM (at 0x2df0)"
        set &access:&cmd_addr %l (0x802df00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "PBG_TRIM_IZTC"
      sgroup "PBG_TRIM_IZTC (at 0x2df1)"
        set &access:&cmd_addr %l (0x802df10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRIM_IZTC_EN                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_IZTC                                = "
    tree.end
    tree "PBG_TRIM_IZTC_TC"
      sgroup "PBG_TRIM_IZTC_TC (at 0x2df2)"
        set &access:&cmd_addr %l (0x802df20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_IZTC_TC                             = "
    tree.end
    tree "PBG_TRIM_HRBG_TR"
      sgroup "PBG_TRIM_HRBG_TR (at 0x2df3)"
        set &access:&cmd_addr %l (0x802df30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_HRBG_TR                             = "
    tree.end
    tree "PBG_TRIM_HRGB_BGFT"
      sgroup "PBG_TRIM_HRGB_BGFT (at 0x2df4)"
        set &access:&cmd_addr %l (0x802df40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_HRGB_BGFT                           = "
    tree.end
    tree "PBG_TRIM_I_TRS"
      sgroup "PBG_TRIM_I_TRS (at 0x2df5)"
        set &access:&cmd_addr %l (0x802df50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRS_TRIM                                 = "
    tree.end
    tree "PBG_TRIM_I_TRA_B"
      sgroup "PBG_TRIM_I_TRA_B (at 0x2df6)"
        set &access:&cmd_addr %l (0x802df60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRA_B_TRIM                               = "
    tree.end
    tree "PBG_TRIM_I_TRB_B"
      sgroup "PBG_TRIM_I_TRB_B (at 0x2df7)"
        set &access:&cmd_addr %l (0x802df70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRB_B_TRIM                               = "
    tree.end
    tree "PBG_TRIM_I_TR"
      sgroup "PBG_TRIM_I_TR (at 0x2df8)"
        set &access:&cmd_addr %l (0x802df80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2df80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_TRIM                                  = "
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&cmd_addr %l (0x8071000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&cmd_addr %l (0x8071010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&cmd_addr %l (0x8071020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&cmd_addr %l (0x8071030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&cmd_addr %l (0x8071040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&cmd_addr %l (0x8071050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&cmd_addr %l (0x8071080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&cmd_addr %l (0x8071090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&cmd_addr %l (0x8071100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&cmd_addr %l (0x8071110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&cmd_addr %l (0x8071120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&cmd_addr %l (0x8071130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&cmd_addr %l (0x8071140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&cmd_addr %l (0x8071150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&cmd_addr %l (0x8071160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&cmd_addr %l (0x8071180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&cmd_addr %l (0x8071190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&cmd_addr %l (0x80711a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x711a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&cmd_addr %l (0x80711b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x711b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&cmd_addr %l (0x8071400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&cmd_addr %l (0x8071420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&cmd_addr %l (0x8071460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&cmd_addr %l (0x8071d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&cmd_addr %l (0x8071d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&cmd_addr %l (0x8071d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&cmd_addr %l (0x8071da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&cmd_addr %l (0x8071db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&cmd_addr %l (0x8071e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&cmd_addr %l (0x8071e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&cmd_addr %l (0x8072000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&cmd_addr %l (0x8072010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&cmd_addr %l (0x8072020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&cmd_addr %l (0x8072030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&cmd_addr %l (0x8072040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&cmd_addr %l (0x8072050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&cmd_addr %l (0x8072080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&cmd_addr %l (0x8072090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&cmd_addr %l (0x8072100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&cmd_addr %l (0x8072110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&cmd_addr %l (0x8072120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&cmd_addr %l (0x8072130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&cmd_addr %l (0x8072140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&cmd_addr %l (0x8072150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&cmd_addr %l (0x8072160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&cmd_addr %l (0x8072180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&cmd_addr %l (0x8072190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&cmd_addr %l (0x80721a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x721a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&cmd_addr %l (0x80721b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x721b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&cmd_addr %l (0x8072400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&cmd_addr %l (0x8072420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&cmd_addr %l (0x8072460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&cmd_addr %l (0x8072d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&cmd_addr %l (0x8072d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&cmd_addr %l (0x8072d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&cmd_addr %l (0x8072da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&cmd_addr %l (0x8072db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&cmd_addr %l (0x8072e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&cmd_addr %l (0x8072e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&cmd_addr %l (0x8073000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&cmd_addr %l (0x8073010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&cmd_addr %l (0x8073020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&cmd_addr %l (0x8073030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&cmd_addr %l (0x8073040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&cmd_addr %l (0x8073050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&cmd_addr %l (0x8073080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&cmd_addr %l (0x8073090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&cmd_addr %l (0x8073100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&cmd_addr %l (0x8073110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&cmd_addr %l (0x8073120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&cmd_addr %l (0x8073130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&cmd_addr %l (0x8073140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&cmd_addr %l (0x8073150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&cmd_addr %l (0x8073160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&cmd_addr %l (0x8073180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&cmd_addr %l (0x8073190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&cmd_addr %l (0x80731a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x731a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&cmd_addr %l (0x80731b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x731b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      sgroup "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
        set &access:&cmd_addr %l (0x8073400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&cmd_addr %l (0x8073420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&cmd_addr %l (0x8073460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&cmd_addr %l (0x8073d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&cmd_addr %l (0x8073d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&cmd_addr %l (0x8073d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&cmd_addr %l (0x8073da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&cmd_addr %l (0x8073db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&cmd_addr %l (0x8073e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&cmd_addr %l (0x8073e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&cmd_addr %l (0x8074000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&cmd_addr %l (0x8074010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&cmd_addr %l (0x8074020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&cmd_addr %l (0x8074030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&cmd_addr %l (0x8074040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&cmd_addr %l (0x8074050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&cmd_addr %l (0x8074080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&cmd_addr %l (0x8074090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&cmd_addr %l (0x8074100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&cmd_addr %l (0x8074110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&cmd_addr %l (0x8074120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&cmd_addr %l (0x8074130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&cmd_addr %l (0x8074140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&cmd_addr %l (0x8074150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&cmd_addr %l (0x8074160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&cmd_addr %l (0x8074180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&cmd_addr %l (0x8074190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&cmd_addr %l (0x80741a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x741a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&cmd_addr %l (0x80741b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x741b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      sgroup "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
        set &access:&cmd_addr %l (0x8074400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&cmd_addr %l (0x8074420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&cmd_addr %l (0x8074460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&cmd_addr %l (0x8074d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&cmd_addr %l (0x8074d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&cmd_addr %l (0x8074d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&cmd_addr %l (0x8074da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&cmd_addr %l (0x8074db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&cmd_addr %l (0x8074e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&cmd_addr %l (0x8074e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      sgroup "PBS_CLIENT4_REVISION1 (at 0x7500)"
        set &access:&cmd_addr %l (0x8075000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      sgroup "PBS_CLIENT4_REVISION2 (at 0x7501)"
        set &access:&cmd_addr %l (0x8075010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      sgroup "PBS_CLIENT4_REVISION3 (at 0x7502)"
        set &access:&cmd_addr %l (0x8075020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      sgroup "PBS_CLIENT4_REVISION4 (at 0x7503)"
        set &access:&cmd_addr %l (0x8075030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      sgroup "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
        set &access:&cmd_addr %l (0x8075040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
        set &access:&cmd_addr %l (0x8075050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      sgroup "PBS_CLIENT4_STATUS0 (at 0x7508)"
        set &access:&cmd_addr %l (0x8075080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      sgroup "PBS_CLIENT4_STATUS1 (at 0x7509)"
        set &access:&cmd_addr %l (0x8075090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      sgroup "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
        set &access:&cmd_addr %l (0x8075100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      sgroup "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
        set &access:&cmd_addr %l (0x8075110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
        set &access:&cmd_addr %l (0x8075120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
        set &access:&cmd_addr %l (0x8075130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
        set &access:&cmd_addr %l (0x8075140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      sgroup "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
        set &access:&cmd_addr %l (0x8075150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      sgroup "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
        set &access:&cmd_addr %l (0x8075160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      sgroup "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
        set &access:&cmd_addr %l (0x8075180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      sgroup "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
        set &access:&cmd_addr %l (0x8075190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      sgroup "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
        set &access:&cmd_addr %l (0x80751a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x751a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      sgroup "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
        set &access:&cmd_addr %l (0x80751b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x751b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      sgroup "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
        set &access:&cmd_addr %l (0x8075400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      sgroup "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
        set &access:&cmd_addr %l (0x8075420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      sgroup "PBS_CLIENT4_EN_CTL (at 0x7546)"
        set &access:&cmd_addr %l (0x8075460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      sgroup "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
        set &access:&cmd_addr %l (0x8075d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
        set &access:&cmd_addr %l (0x8075d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
        set &access:&cmd_addr %l (0x8075d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
        set &access:&cmd_addr %l (0x8075da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
        set &access:&cmd_addr %l (0x8075db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      sgroup "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
        set &access:&cmd_addr %l (0x8075e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      sgroup "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
        set &access:&cmd_addr %l (0x8075e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      sgroup "PBS_CLIENT5_REVISION1 (at 0x7600)"
        set &access:&cmd_addr %l (0x8076000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      sgroup "PBS_CLIENT5_REVISION2 (at 0x7601)"
        set &access:&cmd_addr %l (0x8076010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      sgroup "PBS_CLIENT5_REVISION3 (at 0x7602)"
        set &access:&cmd_addr %l (0x8076020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      sgroup "PBS_CLIENT5_REVISION4 (at 0x7603)"
        set &access:&cmd_addr %l (0x8076030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      sgroup "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
        set &access:&cmd_addr %l (0x8076040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
        set &access:&cmd_addr %l (0x8076050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      sgroup "PBS_CLIENT5_STATUS0 (at 0x7608)"
        set &access:&cmd_addr %l (0x8076080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      sgroup "PBS_CLIENT5_STATUS1 (at 0x7609)"
        set &access:&cmd_addr %l (0x8076090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      sgroup "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
        set &access:&cmd_addr %l (0x8076100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      sgroup "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
        set &access:&cmd_addr %l (0x8076110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
        set &access:&cmd_addr %l (0x8076120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
        set &access:&cmd_addr %l (0x8076130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
        set &access:&cmd_addr %l (0x8076140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      sgroup "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
        set &access:&cmd_addr %l (0x8076150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      sgroup "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
        set &access:&cmd_addr %l (0x8076160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      sgroup "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
        set &access:&cmd_addr %l (0x8076180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      sgroup "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
        set &access:&cmd_addr %l (0x8076190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      sgroup "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
        set &access:&cmd_addr %l (0x80761a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x761a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      sgroup "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
        set &access:&cmd_addr %l (0x80761b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x761b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      sgroup "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
        set &access:&cmd_addr %l (0x8076400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      sgroup "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
        set &access:&cmd_addr %l (0x8076420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      sgroup "PBS_CLIENT5_EN_CTL (at 0x7646)"
        set &access:&cmd_addr %l (0x8076460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      sgroup "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
        set &access:&cmd_addr %l (0x8076d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
        set &access:&cmd_addr %l (0x8076d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
        set &access:&cmd_addr %l (0x8076d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
        set &access:&cmd_addr %l (0x8076da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
        set &access:&cmd_addr %l (0x8076db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      sgroup "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
        set &access:&cmd_addr %l (0x8076e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      sgroup "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
        set &access:&cmd_addr %l (0x8076e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      sgroup "PBS_CLIENT6_REVISION1 (at 0x7700)"
        set &access:&cmd_addr %l (0x8077000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      sgroup "PBS_CLIENT6_REVISION2 (at 0x7701)"
        set &access:&cmd_addr %l (0x8077010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      sgroup "PBS_CLIENT6_REVISION3 (at 0x7702)"
        set &access:&cmd_addr %l (0x8077020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      sgroup "PBS_CLIENT6_REVISION4 (at 0x7703)"
        set &access:&cmd_addr %l (0x8077030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      sgroup "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
        set &access:&cmd_addr %l (0x8077040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
        set &access:&cmd_addr %l (0x8077050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      sgroup "PBS_CLIENT6_STATUS0 (at 0x7708)"
        set &access:&cmd_addr %l (0x8077080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      sgroup "PBS_CLIENT6_STATUS1 (at 0x7709)"
        set &access:&cmd_addr %l (0x8077090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      sgroup "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
        set &access:&cmd_addr %l (0x8077100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      sgroup "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
        set &access:&cmd_addr %l (0x8077110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
        set &access:&cmd_addr %l (0x8077120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
        set &access:&cmd_addr %l (0x8077130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
        set &access:&cmd_addr %l (0x8077140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      sgroup "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
        set &access:&cmd_addr %l (0x8077150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      sgroup "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
        set &access:&cmd_addr %l (0x8077160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      sgroup "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
        set &access:&cmd_addr %l (0x8077180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      sgroup "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
        set &access:&cmd_addr %l (0x8077190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      sgroup "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
        set &access:&cmd_addr %l (0x80771a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x771a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      sgroup "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
        set &access:&cmd_addr %l (0x80771b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x771b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      sgroup "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
        set &access:&cmd_addr %l (0x8077400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      sgroup "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
        set &access:&cmd_addr %l (0x8077420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      sgroup "PBS_CLIENT6_EN_CTL (at 0x7746)"
        set &access:&cmd_addr %l (0x8077460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      sgroup "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
        set &access:&cmd_addr %l (0x8077d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
        set &access:&cmd_addr %l (0x8077d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
        set &access:&cmd_addr %l (0x8077d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
        set &access:&cmd_addr %l (0x8077da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
        set &access:&cmd_addr %l (0x8077db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      sgroup "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
        set &access:&cmd_addr %l (0x8077e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      sgroup "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
        set &access:&cmd_addr %l (0x8077e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      sgroup "PBS_CLIENT7_REVISION1 (at 0x7800)"
        set &access:&cmd_addr %l (0x8078000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      sgroup "PBS_CLIENT7_REVISION2 (at 0x7801)"
        set &access:&cmd_addr %l (0x8078010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      sgroup "PBS_CLIENT7_REVISION3 (at 0x7802)"
        set &access:&cmd_addr %l (0x8078020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      sgroup "PBS_CLIENT7_REVISION4 (at 0x7803)"
        set &access:&cmd_addr %l (0x8078030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      sgroup "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
        set &access:&cmd_addr %l (0x8078040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
        set &access:&cmd_addr %l (0x8078050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      sgroup "PBS_CLIENT7_STATUS0 (at 0x7808)"
        set &access:&cmd_addr %l (0x8078080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_STATUS1"
      sgroup "PBS_CLIENT7_STATUS1 (at 0x7809)"
        set &access:&cmd_addr %l (0x8078090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      sgroup "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
        set &access:&cmd_addr %l (0x8078100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      sgroup "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
        set &access:&cmd_addr %l (0x8078110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
        set &access:&cmd_addr %l (0x8078120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
        set &access:&cmd_addr %l (0x8078130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
        set &access:&cmd_addr %l (0x8078140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      sgroup "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
        set &access:&cmd_addr %l (0x8078150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      sgroup "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
        set &access:&cmd_addr %l (0x8078160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      sgroup "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
        set &access:&cmd_addr %l (0x8078180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      sgroup "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
        set &access:&cmd_addr %l (0x8078190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      sgroup "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
        set &access:&cmd_addr %l (0x80781a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x781a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      sgroup "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
        set &access:&cmd_addr %l (0x80781b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x781b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      sgroup "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
        set &access:&cmd_addr %l (0x8078400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      sgroup "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
        set &access:&cmd_addr %l (0x8078420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      sgroup "PBS_CLIENT7_EN_CTL (at 0x7846)"
        set &access:&cmd_addr %l (0x8078460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      sgroup "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
        set &access:&cmd_addr %l (0x8078d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
        set &access:&cmd_addr %l (0x8078d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
        set &access:&cmd_addr %l (0x8078d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
        set &access:&cmd_addr %l (0x8078da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
        set &access:&cmd_addr %l (0x8078db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      sgroup "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
        set &access:&cmd_addr %l (0x8078e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      sgroup "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
        set &access:&cmd_addr %l (0x8078e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT8"
  tree "PBS_CLIENT8"
    tree "PBS_CLIENT8_REVISION1"
      sgroup "PBS_CLIENT8_REVISION1 (at 0x7900)"
        set &access:&cmd_addr %l (0x8079000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION2"
      sgroup "PBS_CLIENT8_REVISION2 (at 0x7901)"
        set &access:&cmd_addr %l (0x8079010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION3"
      sgroup "PBS_CLIENT8_REVISION3 (at 0x7902)"
        set &access:&cmd_addr %l (0x8079020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION4"
      sgroup "PBS_CLIENT8_REVISION4 (at 0x7903)"
        set &access:&cmd_addr %l (0x8079030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_PERPH_TYPE"
      sgroup "PBS_CLIENT8_PERPH_TYPE (at 0x7904)"
        set &access:&cmd_addr %l (0x8079040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT8_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT8_PERPH_SUBTYPE (at 0x7905)"
        set &access:&cmd_addr %l (0x8079050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT8_STATUS0"
      sgroup "PBS_CLIENT8_STATUS0 (at 0x7908)"
        set &access:&cmd_addr %l (0x8079080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_STATUS1"
      sgroup "PBS_CLIENT8_STATUS1 (at 0x7909)"
        set &access:&cmd_addr %l (0x8079090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT8_INT_RT_STS"
      sgroup "PBS_CLIENT8_INT_RT_STS (at 0x7910)"
        set &access:&cmd_addr %l (0x8079100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT8_INT_SET_TYPE"
      sgroup "PBS_CLIENT8_INT_SET_TYPE (at 0x7911)"
        set &access:&cmd_addr %l (0x8079110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT8_INT_POLARITY_HIGH (at 0x7912)"
        set &access:&cmd_addr %l (0x8079120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT8_INT_POLARITY_LOW (at 0x7913)"
        set &access:&cmd_addr %l (0x8079130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT8_INT_LATCHED_CLR (at 0x7914)"
        set &access:&cmd_addr %l (0x8079140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_INT_EN_SET"
      sgroup "PBS_CLIENT8_INT_EN_SET (at 0x7915)"
        set &access:&cmd_addr %l (0x8079150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_EN_CLR"
      sgroup "PBS_CLIENT8_INT_EN_CLR (at 0x7916)"
        set &access:&cmd_addr %l (0x8079160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_STS"
      sgroup "PBS_CLIENT8_INT_LATCHED_STS (at 0x7918)"
        set &access:&cmd_addr %l (0x8079180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT8_INT_PENDING_STS"
      sgroup "PBS_CLIENT8_INT_PENDING_STS (at 0x7919)"
        set &access:&cmd_addr %l (0x8079190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT8_INT_MID_SEL"
      sgroup "PBS_CLIENT8_INT_MID_SEL (at 0x791a)"
        set &access:&cmd_addr %l (0x80791a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x791a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT8_INT_PRIORITY"
      sgroup "PBS_CLIENT8_INT_PRIORITY (at 0x791b)"
        set &access:&cmd_addr %l (0x80791b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x791b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_TRIG_CFG"
      sgroup "PBS_CLIENT8_TRIG_CFG (at 0x7940)"
        set &access:&cmd_addr %l (0x8079400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT8_TRIG_CTL"
      sgroup "PBS_CLIENT8_TRIG_CTL (at 0x7942)"
        set &access:&cmd_addr %l (0x8079420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_EN_CTL"
      sgroup "PBS_CLIENT8_EN_CTL (at 0x7946)"
        set &access:&cmd_addr %l (0x8079460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_SEC_ACCESS"
      sgroup "PBS_CLIENT8_SEC_ACCESS (at 0x79d0)"
        set &access:&cmd_addr %l (0x8079d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL1 (at 0x79d8)"
        set &access:&cmd_addr %l (0x8079d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL2 (at 0x79d9)"
        set &access:&cmd_addr %l (0x8079d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL3 (at 0x79da)"
        set &access:&cmd_addr %l (0x8079da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL4 (at 0x79db)"
        set &access:&cmd_addr %l (0x8079db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST1"
      sgroup "PBS_CLIENT8_INT_TEST1 (at 0x79e0)"
        set &access:&cmd_addr %l (0x8079e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST_VAL"
      sgroup "PBS_CLIENT8_INT_TEST_VAL (at 0x79e1)"
        set &access:&cmd_addr %l (0x8079e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&cmd_addr %l (0x8070000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&cmd_addr %l (0x8070010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&cmd_addr %l (0x8070020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&cmd_addr %l (0x8070030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&cmd_addr %l (0x8070040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&cmd_addr %l (0x8070050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&cmd_addr %l (0x8070080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      sgroup "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
        set &access:&cmd_addr %l (0x8070090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&cmd_addr %l (0x80700a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&cmd_addr %l (0x80700b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&cmd_addr %l (0x80700c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&cmd_addr %l (0x80700d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&cmd_addr %l (0x80700e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&cmd_addr %l (0x80700f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&cmd_addr %l (0x8070400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&cmd_addr %l (0x8070410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&cmd_addr %l (0x8070420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&cmd_addr %l (0x8070430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&cmd_addr %l (0x8070480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&cmd_addr %l (0x8070490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&cmd_addr %l (0x80704a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&cmd_addr %l (0x80704b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&cmd_addr %l (0x80704c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&cmd_addr %l (0x80704d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&cmd_addr %l (0x80704e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&cmd_addr %l (0x80704f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
        set &access:&cmd_addr %l (0x8070500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
        set &access:&cmd_addr %l (0x8070510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
        set &access:&cmd_addr %l (0x8070540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
        set &access:&cmd_addr %l (0x8070550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
        set &access:&cmd_addr %l (0x8070580|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70580|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
        set &access:&cmd_addr %l (0x8070590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
        set &access:&cmd_addr %l (0x80705c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x705c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
        set &access:&cmd_addr %l (0x80705d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x705d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
        set &access:&cmd_addr %l (0x8070600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
        set &access:&cmd_addr %l (0x8070610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
        set &access:&cmd_addr %l (0x8070640|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70640|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
        set &access:&cmd_addr %l (0x8070650|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70650|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
        set &access:&cmd_addr %l (0x8070680|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70680|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
        set &access:&cmd_addr %l (0x8070690|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70690|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
        set &access:&cmd_addr %l (0x80706c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x706c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
        set &access:&cmd_addr %l (0x80706d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x706d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
        set &access:&cmd_addr %l (0x8070700|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70700|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
        set &access:&cmd_addr %l (0x8070710|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70710|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
        set &access:&cmd_addr %l (0x8070740|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70740|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
        set &access:&cmd_addr %l (0x8070750|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70750|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
        set &access:&cmd_addr %l (0x8070780|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70780|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
        set &access:&cmd_addr %l (0x8070790|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70790|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
        set &access:&cmd_addr %l (0x80707c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x707c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
        set &access:&cmd_addr %l (0x80707d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x707d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
        set &access:&cmd_addr %l (0x8070800|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70800|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
        set &access:&cmd_addr %l (0x8070810|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70810|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
        set &access:&cmd_addr %l (0x8070840|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70840|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
        set &access:&cmd_addr %l (0x8070850|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70850|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
        set &access:&cmd_addr %l (0x8070880|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70880|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
        set &access:&cmd_addr %l (0x8070890|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70890|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
        set &access:&cmd_addr %l (0x80708c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x708c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
        set &access:&cmd_addr %l (0x80708d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x708d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&cmd_addr %l (0x8070900|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70900|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&cmd_addr %l (0x8070910|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70910|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&cmd_addr %l (0x8070920|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70920|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&cmd_addr %l (0x8070930|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70930|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&cmd_addr %l (0x8070940|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70940|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&cmd_addr %l (0x8070950|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70950|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&cmd_addr %l (0x8070960|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70960|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&cmd_addr %l (0x8070970|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70970|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&cmd_addr %l (0x8070d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&cmd_addr %l (0x8070d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&cmd_addr %l (0x8070da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&cmd_addr %l (0x8070db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&cmd_addr %l (0x8070e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&cmd_addr %l (0x8070e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&cmd_addr %l (0x8070e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&cmd_addr %l (0x8070e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&cmd_addr %l (0x8070e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PMON"
  tree "PMON"
    tree "PMON_REVISION1"
      sgroup "PMON_REVISION1 (at 0x3b00)"
        set &access:&cmd_addr %l (0x803b000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PMON_REVISION2"
      sgroup "PMON_REVISION2 (at 0x3b01)"
        set &access:&cmd_addr %l (0x803b010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PMON_PERPH_TYPE"
      sgroup "PMON_PERPH_TYPE (at 0x3b04)"
        set &access:&cmd_addr %l (0x803b040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PMON_PERPH_SUBTYPE"
      sgroup "PMON_PERPH_SUBTYPE (at 0x3b05)"
        set &access:&cmd_addr %l (0x803b050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PMON_STATUS1"
      sgroup "PMON_STATUS1 (at 0x3b08)"
        set &access:&cmd_addr %l (0x803b080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PBG_ERROR                                = " "0 (PBG_ERROR_FALSE),1 (PBG_ERROR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TEMP_UPDATED                             = " "0 (TEMP_UPDATED_FALSE),1 (TEMP_UPDATED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DUTY_CYCLE_UPDATED                       = " "0 (DUTY_CYCLE_UPDATED_FALSE),1 (DUTY_CYCLE_UPDATED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IIN_UPDATED                              = " "0 (IIN_UPDATED_FALSE),1 (IIN_UPDATED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VOUT_UPDATED                             = " "0 (VOUT_UPDATED_FALSE),1 (VOUT_UPDATED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VIN_UPDATED                              = " "0 (VIN_UPDATED_FALSE),1 (VIN_UPDATED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (ADC_CONVERSION_OCCURRING),1 (ADC_CONVERSION_COMPLETED)"
    tree.end
    tree "PMON_STATUS2"
      sgroup "PMON_STATUS2 (at 0x3b09)"
        set &access:&cmd_addr %l (0x803b090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FSM                                      = "
    tree.end
    tree "PMON_INT_RT_STS"
      sgroup "PMON_INT_RT_STS (at 0x3b10)"
        set &access:&cmd_addr %l (0x803b100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (EOC_INT_FALSE),1 (EOC_INT_TRUE)"
    tree.end
    tree "PMON_INT_SET_TYPE"
      sgroup "PMON_INT_SET_TYPE (at 0x3b11)"
        set &access:&cmd_addr %l (0x803b110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_INT_LEVEL_TRIGGERED),1 (EOC_INT_EDGE_TRIGGERED)"
    tree.end
    tree "PMON_INT_POLARITY_HIGH"
      sgroup "PMON_INT_POLARITY_HIGH (at 0x3b12)"
        set &access:&cmd_addr %l (0x803b120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_RISING_EDGE_TRIGGER_DISABL),1 (EOC_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "PMON_INT_POLARITY_LOW"
      sgroup "PMON_INT_POLARITY_LOW (at 0x3b13)"
        set &access:&cmd_addr %l (0x803b130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_FALLING_EDGE_TRIGGER_DISABL),1 (EOC_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "PMON_INT_LATCHED_CLR"
      sgroup "PMON_INT_LATCHED_CLR (at 0x3b14)"
        set &access:&cmd_addr %l (0x803b140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "PMON_INT_EN_SET"
      sgroup "PMON_INT_EN_SET (at 0x3b15)"
        set &access:&cmd_addr %l (0x803b150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLE),1 (EOC_INT_ENABLE)"
    tree.end
    tree "PMON_INT_EN_CLR"
      sgroup "PMON_INT_EN_CLR (at 0x3b16)"
        set &access:&cmd_addr %l (0x803b160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLE),1 (EOC_INT_ENABLE)"
    tree.end
    tree "PMON_INT_LATCHED_STS"
      sgroup "PMON_INT_LATCHED_STS (at 0x3b18)"
        set &access:&cmd_addr %l (0x803b180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_NOT_TRIGGERED),1 (EOC_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "PMON_INT_PENDING_STS"
      sgroup "PMON_INT_PENDING_STS (at 0x3b19)"
        set &access:&cmd_addr %l (0x803b190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_NOT_PENDING),1 (EOC_INT_PENDING)"
    tree.end
    tree "PMON_INT_MID_SEL"
      sgroup "PMON_INT_MID_SEL (at 0x3b1a)"
        set &access:&cmd_addr %l (0x803b1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "PMON_INT_PRIORITY"
      sgroup "PMON_INT_PRIORITY (at 0x3b1b)"
        set &access:&cmd_addr %l (0x803b1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR_0),1 (INT_PRIORITY_A_1)"
    tree.end
    tree "PMON_EN_CTL1"
      sgroup "PMON_EN_CTL1 (at 0x3b46)"
        set &access:&cmd_addr %l (0x803b460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMON_EN                                  = " "0 (PMON_DISABLE),1 (PMON_ENABLE)"
    tree.end
    tree "PMON_HW_SETTLE_DELAY"
      sgroup "PMON_HW_SETTLE_DELAY (at 0x3b51)"
        set &access:&cmd_addr %l (0x803b510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "PMON_CONV_REQ"
      sgroup "PMON_CONV_REQ (at 0x3b52)"
        set &access:&cmd_addr %l (0x803b520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MEASURE_TEMPERATURE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MEASURE_DUTY_CYCLE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEASURE_IIN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEASURE_VOUT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MEASURE_VIN                              = " "0, 1"
    tree.end
    tree "PMON_AVG_CTL"
      sgroup "PMON_AVG_CTL (at 0x3b5a)"
        set &access:&cmd_addr %l (0x803b5a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b5a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVG_SAMPLES                              = "
    tree.end
    tree "PMON_VIN_LO"
      sgroup "PMON_VIN_LO (at 0x3b60)"
        set &access:&cmd_addr %l (0x803b600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VIN_7_0                                  = "
    tree.end
    tree "PMON_VIN_HI"
      sgroup "PMON_VIN_HI (at 0x3b61)"
        set &access:&cmd_addr %l (0x803b610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VIN_15_8                                 = "
    tree.end
    tree "PMON_VOUT_LO"
      sgroup "PMON_VOUT_LO (at 0x3b62)"
        set &access:&cmd_addr %l (0x803b620|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b620|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_7_0                                 = "
    tree.end
    tree "PMON_VOUT_HI"
      sgroup "PMON_VOUT_HI (at 0x3b63)"
        set &access:&cmd_addr %l (0x803b630|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b630|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_15_8                                = "
    tree.end
    tree "PMON_IIN_LO"
      sgroup "PMON_IIN_LO (at 0x3b64)"
        set &access:&cmd_addr %l (0x803b640|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b640|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IIN_7_0                                  = "
    tree.end
    tree "PMON_IIN_HI"
      sgroup "PMON_IIN_HI (at 0x3b65)"
        set &access:&cmd_addr %l (0x803b650|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b650|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IIN_15_8                                 = "
    tree.end
    tree "PMON_DUTY_CYCLE_LO"
      sgroup "PMON_DUTY_CYCLE_LO (at 0x3b66)"
        set &access:&cmd_addr %l (0x803b660|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b660|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DUTY_CYCLE_7_0                           = "
    tree.end
    tree "PMON_DUTY_CYCLE_HI"
      sgroup "PMON_DUTY_CYCLE_HI (at 0x3b67)"
        set &access:&cmd_addr %l (0x803b670|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b670|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DUTY_CYCLE_15_8                          = "
    tree.end
    tree "PMON_TEMP_LO"
      sgroup "PMON_TEMP_LO (at 0x3b68)"
        set &access:&cmd_addr %l (0x803b680|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b680|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEMP_7_0                                 = "
    tree.end
    tree "PMON_TEMP_HI"
      sgroup "PMON_TEMP_HI (at 0x3b69)"
        set &access:&cmd_addr %l (0x803b690|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3b690|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEMP_15_8                                = "
    tree.end
    tree "PMON_SEC_ACCESS"
      sgroup "PMON_SEC_ACCESS (at 0x3bd0)"
        set &access:&cmd_addr %l (0x803bd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PMON_PERPH_RESET_CTL1"
      sgroup "PMON_PERPH_RESET_CTL1 (at 0x3bd8)"
        set &access:&cmd_addr %l (0x803bd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "PMON_PERPH_RESET_CTL2"
      sgroup "PMON_PERPH_RESET_CTL2 (at 0x3bd9)"
        set &access:&cmd_addr %l (0x803bd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PMON_PERPH_RESET_CTL3"
      sgroup "PMON_PERPH_RESET_CTL3 (at 0x3bda)"
        set &access:&cmd_addr %l (0x803bda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PMON_PERPH_RESET_CTL4"
      sgroup "PMON_PERPH_RESET_CTL4 (at 0x3bdb)"
        set &access:&cmd_addr %l (0x803bdb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bdb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "PMON_INT_TEST1"
      sgroup "PMON_INT_TEST1 (at 0x3be0)"
        set &access:&cmd_addr %l (0x803be00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3be00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "PMON_INT_TEST_VAL"
      sgroup "PMON_INT_TEST_VAL (at 0x3be1)"
        set &access:&cmd_addr %l (0x803be10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3be10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_INT_TEST_VAL_0),1 (EOC_INT_TEST_VAL_1)"
    tree.end
    tree "PMON_ATEST"
      sgroup "PMON_ATEST (at 0x3be3)"
        set &access:&cmd_addr %l (0x803be30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3be30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PMON_ATEST3                              = " "0 (ATEST3_NORMAL),1 (ATEST3_DUTYCYCLECOMPOUT),2 (ATEST3_TESTCLKIN),3 (ATEST3_SWLOSS_SWITCHNODEOUT)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PMON_ATEST2                              = " "0 (ATEST2_NORMAL),1 (ATEST2_DUTYCYCLETRIPPOINT),2 (ATEST2_SWLOSS_COMPTRIP),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PMON_ATEST1                              = " "0 (ATEST1_NORMAL),1 (ATEST1_DUTYCYCLEFILTEROUT),2 (ATEST1_EXTCURRENTSRCIN),3 (reserved)"
    tree.end
    tree "PMON_DTEST"
      sgroup "PMON_DTEST (at 0x3be4)"
        set &access:&cmd_addr %l (0x803be40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3be40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_SEL                                = "
    tree.end
    tree "PMON_TRIM_NUM"
      sgroup "PMON_TRIM_NUM (at 0x3bf0)"
        set &access:&cmd_addr %l (0x803bf00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "PMON_TRIM_DUTY2"
      sgroup "PMON_TRIM_DUTY2 (at 0x3bf1)"
        set &access:&cmd_addr %l (0x803bf10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DUTY_TRIM2                               = "
    tree.end
    tree "PMON_TRIM_DUTY1"
      sgroup "PMON_TRIM_DUTY1 (at 0x3bf2)"
        set &access:&cmd_addr %l (0x803bf20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DUTY_TRIM1                               = "
    tree.end
    tree "PMON_TRIM_TEMPC2"
      sgroup "PMON_TRIM_TEMPC2 (at 0x3bf3)"
        set &access:&cmd_addr %l (0x803bf30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEMPC_TRIM2                              = "
    tree.end
    tree "PMON_TRIM_TEMPC1"
      sgroup "PMON_TRIM_TEMPC1 (at 0x3bf4)"
        set &access:&cmd_addr %l (0x803bf40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEMPC_TRIM1                              = "
    tree.end
    tree "PMON_TRIM_SWCL"
      sgroup "PMON_TRIM_SWCL (at 0x3bf5)"
        set &access:&cmd_addr %l (0x803bf50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SWCL_TRIM                                = "
    tree.end
    tree "PMON_TRIM_SW_CAL"
      sgroup "PMON_TRIM_SW_CAL (at 0x3bf6)"
        set &access:&cmd_addr %l (0x803bf60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SWLOSS_CAL                               = "
    tree.end
    tree "PMON_TRIM_DUTY_CAL"
      sgroup "PMON_TRIM_DUTY_CAL (at 0x3bf7)"
        set &access:&cmd_addr %l (0x803bf70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x3bf70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_DUTY_REF                            = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&cmd_addr %l (0x8008000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&cmd_addr %l (0x8008010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&cmd_addr %l (0x8008020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&cmd_addr %l (0x8008030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&cmd_addr %l (0x8008040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&cmd_addr %l (0x8008050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&cmd_addr %l (0x8008070|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8070|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REG_WRITE_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_RESET_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REG_SYNC_ERROR                           = " "0, 1"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x808)"
        set &access:&cmd_addr %l (0x8008080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x80a)"
        set &access:&cmd_addr %l (0x80080a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      sgroup "PON_WARM_RESET_REASON2 (at 0x80b)"
        set &access:&cmd_addr %l (0x80080b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x80c)"
        set &access:&cmd_addr %l (0x80080c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      sgroup "PON_POFF_REASON2 (at 0x80d)"
        set &access:&cmd_addr %l (0x80080d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x80e)"
        set &access:&cmd_addr %l (0x80080e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      sgroup "PON_SOFT_RESET_REASON2 (at 0x80f)"
        set &access:&cmd_addr %l (0x80080f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&cmd_addr %l (0x8008100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&cmd_addr %l (0x8008110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&cmd_addr %l (0x8008120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&cmd_addr %l (0x8008130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&cmd_addr %l (0x8008140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&cmd_addr %l (0x8008150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&cmd_addr %l (0x8008160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&cmd_addr %l (0x8008180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&cmd_addr %l (0x8008190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&cmd_addr %l (0x80081a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x81a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&cmd_addr %l (0x80081b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x81b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&cmd_addr %l (0x8008400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&cmd_addr %l (0x8008410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&cmd_addr %l (0x8008420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&cmd_addr %l (0x8008430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&cmd_addr %l (0x8008440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&cmd_addr %l (0x8008450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&cmd_addr %l (0x8008460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&cmd_addr %l (0x8008470|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8470|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&cmd_addr %l (0x8008480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&cmd_addr %l (0x8008490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&cmd_addr %l (0x80084a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&cmd_addr %l (0x80084b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&cmd_addr %l (0x80084c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&cmd_addr %l (0x80084d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&cmd_addr %l (0x80084e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&cmd_addr %l (0x80084f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&cmd_addr %l (0x8008500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&cmd_addr %l (0x8008510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&cmd_addr %l (0x8008520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&cmd_addr %l (0x8008530|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8530|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&cmd_addr %l (0x8008540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&cmd_addr %l (0x8008550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&cmd_addr %l (0x8008560|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8560|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&cmd_addr %l (0x8008570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&cmd_addr %l (0x8008580|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8580|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&cmd_addr %l (0x80085a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x85a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&cmd_addr %l (0x80085b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x85b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&cmd_addr %l (0x8008620|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8620|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&cmd_addr %l (0x8008630|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8630|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&cmd_addr %l (0x8008640|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8640|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      sgroup "PON_OVERTEMP_RESET_CTL (at 0x866)"
        set &access:&cmd_addr %l (0x8008660|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8660|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      sgroup "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
        set &access:&cmd_addr %l (0x8008670|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8670|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      sgroup "PON_TFT_RESET_CTL (at 0x86a)"
        set &access:&cmd_addr %l (0x80086a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x86a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      sgroup "PON_TFT_RESET_CTL2 (at 0x86b)"
        set &access:&cmd_addr %l (0x80086b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x86b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&cmd_addr %l (0x8008700|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8700|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&cmd_addr %l (0x8008710|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8710|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&cmd_addr %l (0x8008740|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8740|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&cmd_addr %l (0x8008750|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8750|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&cmd_addr %l (0x8008800|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8800|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&cmd_addr %l (0x8008820|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8820|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLOCK_50K_EN                             = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBG_EN                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_PWR_EN                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      sgroup "PON_WATCHDOG_LOCK (at 0x883)"
        set &access:&cmd_addr %l (0x8008830|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8830|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      sgroup "PON_UVLO (at 0x888)"
        set &access:&cmd_addr %l (0x8008880|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8880|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      sgroup "PON_AVDD_VPH (at 0x88a)"
        set &access:&cmd_addr %l (0x80088a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_HPM_EN                              = " "0 (LPM),1 (HPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&cmd_addr %l (0x80088c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&cmd_addr %l (0x80088d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&cmd_addr %l (0x80088e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&cmd_addr %l (0x80088f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      sgroup "PON_PON1_INTERFACE (at 0x890)"
        set &access:&cmd_addr %l (0x8008900|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8900|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&cmd_addr %l (0x8008910|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8910|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_FSM_CTL"
      sgroup "PON_FSM_CTL (at 0x894)"
        set &access:&cmd_addr %l (0x8008940|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8940|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_FSM                                  = "
    tree.end
    tree "PON_FSM_STATUS"
      sgroup "PON_FSM_STATUS (at 0x895)"
        set &access:&cmd_addr %l (0x8008950|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8950|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FSM_STATE                                = "
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&cmd_addr %l (0x8008d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&cmd_addr %l (0x8008d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&cmd_addr %l (0x8008da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&cmd_addr %l (0x8008db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&cmd_addr %l (0x8008e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&cmd_addr %l (0x8008e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&cmd_addr %l (0x8008e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&cmd_addr %l (0x8008e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&cmd_addr %l (0x8008e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USE_MSME_FOR_DVDD                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      sgroup "PON_TEST4 (at 0x8e5)"
        set &access:&cmd_addr %l (0x8008e50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_ATEST1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&cmd_addr %l (0x8008e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      sgroup "PON_VMAX_SEL (at 0x8e7)"
        set &access:&cmd_addr %l (0x8008e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&cmd_addr %l (0x8008f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      sgroup "PON_PON_TRIM (at 0x8f1)"
        set &access:&cmd_addr %l (0x8008f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      sgroup "PON_PON_CNTL_2_TRIM (at 0x8f2)"
        set &access:&cmd_addr %l (0x8008f20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8f20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
    tree "PON_PON_CNTL_3_TRIM"
      sgroup "PON_PON_CNTL_3_TRIM (at 0x8f3)"
        set &access:&cmd_addr %l (0x8008f30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8f30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&cmd_addr %l (0x8001000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&cmd_addr %l (0x8001010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&cmd_addr %l (0x8001020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&cmd_addr %l (0x8001030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&cmd_addr %l (0x8001040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&cmd_addr %l (0x8001050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      sgroup "REVID_STATUS1 (at 0x108)"
        set &access:&cmd_addr %l (0x8001080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OP4                                      = " "0 (ALWAYS_ON_OVP_NOT_TRIPPING_FAULT_N),1 (ALWAYS_ON_OVP_TRIPPING_FAULT_N),2 (ALWAYS_ON_OVP_NOT_TRIPPINGS_FAULT_N),3 (ALWAYS_ON_OVP_TRIPPINGS_FAULT_N)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OP3                                      = " "0 (OP3_GND),1 (reserved),2 (OP3_HIZ),3 (OP3_VDD)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OP2                                      = " "0 (OP2_GND),1 (reserved),2 (OP2_HIZ),3 (OP2_VDD)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OP1                                      = " "0 (OP1_GND),1 (reserved),2 (OP1_HIZ),3 (OP1_VDD)"
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&cmd_addr %l (0x8001d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      sgroup "REVID_TEST1 (at 0x1e0)"
        set &access:&cmd_addr %l (0x8001e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0 (FORCE_ON_DISABLED),1 (FORCE_ON_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (DTEST_DISABLED),1 (DTEST_OPT1),2 (DTEST_OPT2),3 (DTEST_OPT3),4 (DTEST_OPT4),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      sgroup "S1_CTRL_REVISION1 (at 0x11400)"
        set &access:&cmd_addr %l (0x8014000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      sgroup "S1_CTRL_REVISION2 (at 0x11401)"
        set &access:&cmd_addr %l (0x8014010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      sgroup "S1_CTRL_REVISION3 (at 0x11402)"
        set &access:&cmd_addr %l (0x8014020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      sgroup "S1_CTRL_REVISION4 (at 0x11403)"
        set &access:&cmd_addr %l (0x8014030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      sgroup "S1_CTRL_PERPH_TYPE (at 0x11404)"
        set &access:&cmd_addr %l (0x8014040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      sgroup "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
        set &access:&cmd_addr %l (0x8014050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS_1"
      sgroup "S1_CTRL_STATUS_1 (at 0x11408)"
        set &access:&cmd_addr %l (0x8014080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY_FLAG                          = " "0 (VREG_READY_FLAG_FALSE),1 (VREG_READY_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_ERROR_FLAG                          = " "0 (VREG_ERROR_FLAG_FALSE),1 (VREG_ERROR_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_SHED_FLAG                             = " "0 (FET_SHED_FALSE),1 (FET_SHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS_2"
      sgroup "S1_CTRL_STATUS_2 (at 0x11409)"
        set &access:&cmd_addr %l (0x8014090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OVP_FLAG                            = " "0 (VREG_OVP_FLAG_FALSE),1 (VREG_OVP_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      sgroup "S1_CTRL_INT_RT_STS (at 0x11410)"
        set &access:&cmd_addr %l (0x8014100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_FALSE),1 (VREG_OVP_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_FALSE),1 (VREG_READY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALSE),1 (VREG_ERROR_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      sgroup "S1_CTRL_INT_SET_TYPE (at 0x11411)"
        set &access:&cmd_addr %l (0x8014110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_LEVEL_TRIGGERED),1 (VREG_OVP_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_LEVEL_TRIGGERED),1 (VREG_READY_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_LEVEL_TRIGGERED),1 (VREG_ERROR_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      sgroup "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
        set &access:&cmd_addr %l (0x8014120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_OVP_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_READY_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      sgroup "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
        set &access:&cmd_addr %l (0x8014130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_OVP_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_READY_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_ERROR_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      sgroup "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
        set &access:&cmd_addr %l (0x8014140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      sgroup "S1_CTRL_INT_EN_SET (at 0x11415)"
        set &access:&cmd_addr %l (0x8014150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_DISABL),1 (VREG_OVP_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_DISABL),1 (VREG_READY_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      sgroup "S1_CTRL_INT_EN_CLR (at 0x11416)"
        set &access:&cmd_addr %l (0x8014160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_DISABL),1 (VREG_OVP_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_DISABL),1 (VREG_READY_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_DISABL),1 (VREG_ERROR_INT_ENABL)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      sgroup "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
        set &access:&cmd_addr %l (0x8014180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_NOT_TRIGGERED),1 (VREG_OVP_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_NOT_TRIGGERED),1 (VREG_READY_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_TRIGGERED),1 (VREG_ERROR_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      sgroup "S1_CTRL_INT_PENDING_STS (at 0x11419)"
        set &access:&cmd_addr %l (0x8014190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT                             = " "0 (VREG_OVP_INT_NOT_PENDING),1 (VREG_OVP_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT                           = " "0 (VREG_READY_INT_NOT_PENDING),1 (VREG_READY_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT                           = " "0 (VREG_ERROR_INT_NOT_PENDING),1 (VREG_ERROR_INT_PENDING)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      sgroup "S1_CTRL_INT_MID_SEL (at 0x1141a)"
        set &access:&cmd_addr %l (0x80141a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x141a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      sgroup "S1_CTRL_INT_PRIORITY (at 0x1141b)"
        set &access:&cmd_addr %l (0x80141b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x141b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "S1_CTRL_INT_DELAY_TIMER"
      sgroup "S1_CTRL_INT_DELAY_TIMER (at 0x11440)"
        set &access:&cmd_addr %l (0x8014400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_DELAY_EN                            = " "0 (NO_DELAY_FOR_VREG_ERROR),1 (DELAY_100US_FOR_VREG_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_DEL_SEL                              = " "0 (INT_DEL_SEL_0US),1 (INT_DEL_SEL_30US),2 (INT_DEL_SEL_60US),3 (INT_DEL_SEL_90US)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      sgroup "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
        set &access:&cmd_addr %l (0x8014410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_VSET_VALID"
      sgroup "S1_CTRL_VSET_VALID (at 0x11442)"
        set &access:&cmd_addr %l (0x8014420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S1_CTRL_EN_CTL"
      sgroup "S1_CTRL_EN_CTL (at 0x11446)"
        set &access:&cmd_addr %l (0x8014460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      sgroup "S1_CTRL_PD_CTL (at 0x11448)"
        set &access:&cmd_addr %l (0x8014480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_HPBUCK_IS_DISABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_ALWAYS_OFF),1 (WEAK_PD_ON_WHEN_HPBUCK_IS_DISABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_ALWAYS_OFF),1 (WEAK_PD_ON_WHEN_HPBUCK_IS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S1_CTRL_COMP_CAP_CTL"
      sgroup "S1_CTRL_COMP_CAP_CTL (at 0x11451)"
        set &access:&cmd_addr %l (0x8014510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_60PF),1 (CZ_CAP_120PF),2 (CZ_CAP_240PF),3 (CZ_CAP_480PF)"
    tree.end
    tree "S1_CTRL_GM_CTL"
      sgroup "S1_CTRL_GM_CTL (at 0x11452)"
        set &access:&cmd_addr %l (0x8014520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S1_CTRL_RZ_CTL"
      sgroup "S1_CTRL_RZ_CTL (at 0x11453)"
        set &access:&cmd_addr %l (0x8014530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S1_CTRL_SAW_CTL"
      sgroup "S1_CTRL_SAW_CTL (at 0x11456)"
        set &access:&cmd_addr %l (0x8014560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_0P5UA),1 (SAW_CURRENT_CTRL_1P0UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      sgroup "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
        set &access:&cmd_addr %l (0x8014600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_2_CLK_CYCLES_104P16NS),1 (DELAY_4_CLK_CYCLES_208P33NS),2 (DELAY_8_CLK_CYCLES_416P66NS),3 (DELAY_16_CLK_CYCLES_833P33NS),4 (DELAY_32_CLK_CYCLES_1666P66NS),5 (DELAY_64_CLK_CYLES_3333P33NS),6 (DELAY_128_CLK_CYCLES_666P66NS),7 (DELAY_256_CLK_CYCLES_13333P33NS)"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      sgroup "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
        set &access:&cmd_addr %l (0x8014610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_2_CLK_CYCLES_104P16NS),1 (DELAY_4_CLK_CYCLES_208P33NS),2 (DELAY_8_CLK_CYCLES_416P66NS),3 (DELAY_16_CLK_CYCLES_833P33NS),4 (DELAY_32_CLK_CYCLES_1666P66NS),5 (DELAY_64_CLK_CYLES_3333P33NS),6 (DELAY_128_CLK_CYCLES_6666P66NS),7 (DELAY_256_CLK_CYCLES_13333P33NS)"
    tree.end
    tree "S1_CTRL_FT_CTL"
      sgroup "S1_CTRL_FT_CTL (at 0x11462)"
        set &access:&cmd_addr %l (0x8014620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S1_CTRL_UL_CTRL"
      sgroup "S1_CTRL_UL_CTRL (at 0x11468)"
        set &access:&cmd_addr %l (0x8014680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_EN_FALSE),1 (UL_EN_TRUE)"
    tree.end
    tree "S1_CTRL_UL_VOLTAGE"
      sgroup "S1_CTRL_UL_VOLTAGE (at 0x11469)"
        set &access:&cmd_addr %l (0x8014690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VLIMIT_STOP                              = "
    tree.end
    tree "S1_CTRL_VREG_OK_CTRL"
      sgroup "S1_CTRL_VREG_OK_CTRL (at 0x11479)"
        set &access:&cmd_addr %l (0x8014790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_VREG_OK_COMP                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VREG_OK_DELAY                            = " "0 (VREG_OK_DELAY_100NS),1 (VREG_OK_DELAY_500NS),2 (VREG_OK_DELAY_1000NS),3 (VREG_OK_DELAY_3000NS)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VREG_OK_OFFSET                           = "
    tree.end
    tree "S1_CTRL_OOB_POS_OFFSET"
      sgroup "S1_CTRL_OOB_POS_OFFSET (at 0x1147b)"
        set &access:&cmd_addr %l (0x80147b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x147b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_OOB_POS                           = " "0 (OOB_POSITIVE_DISABLE),1 (OOB_POSITIVE_ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   OOB_POS_OFFSET                           = "
    tree.end
    tree "S1_CTRL_OOB_NEG_OFFSET"
      sgroup "S1_CTRL_OOB_NEG_OFFSET (at 0x1147c)"
        set &access:&cmd_addr %l (0x80147c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x147c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_OOB_NEG                           = " "0 (OOB_NEGATIVE_DISABLE),1 (OOB_NEGATIVE_ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   OOB_NEG_OFFSET                           = "
    tree.end
    tree "S1_CTRL_CFB_RSLPF"
      sgroup "S1_CTRL_CFB_RSLPF (at 0x1147d)"
        set &access:&cmd_addr %l (0x80147d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x147d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFB_FILT_SET                             = "
    tree.end
    tree "S1_CTRL_RFB_RSLPF"
      sgroup "S1_CTRL_RFB_RSLPF (at 0x1147e)"
        set &access:&cmd_addr %l (0x80147e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x147e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RFB_FILT_SET                             = "
    tree.end
    tree "S1_CTRL_RGND_RSLPF"
      sgroup "S1_CTRL_RGND_RSLPF (at 0x1147f)"
        set &access:&cmd_addr %l (0x80147f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x147f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RGND_FILT_SET                            = "
    tree.end
    tree "S1_CTRL_MISC_FUNCTION"
      sgroup "S1_CTRL_MISC_FUNCTION (at 0x11483)"
        set &access:&cmd_addr %l (0x8014830|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14830|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RMTFILT_SINGLE_SEL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EAMP_IN_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_SLOPECOMP                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPARE1                                   = "
    tree.end
    tree "S1_CTRL_SPARE2"
      sgroup "S1_CTRL_SPARE2 (at 0x11484)"
        set &access:&cmd_addr %l (0x8014840|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14840|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE2                                   = "
    tree.end
    tree "S1_CTRL_SPARE4"
      sgroup "S1_CTRL_SPARE4 (at 0x11486)"
        set &access:&cmd_addr %l (0x8014860|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14860|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE4                                   = "
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      sgroup "S1_CTRL_SEC_ACCESS (at 0x114d0)"
        set &access:&cmd_addr %l (0x8014d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      sgroup "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
        set &access:&cmd_addr %l (0x8014d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      sgroup "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
        set &access:&cmd_addr %l (0x8014d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      sgroup "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
        set &access:&cmd_addr %l (0x8014da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      sgroup "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
        set &access:&cmd_addr %l (0x8014db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      sgroup "S1_CTRL_INT_TEST1 (at 0x114e0)"
        set &access:&cmd_addr %l (0x8014e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      sgroup "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
        set &access:&cmd_addr %l (0x8014e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OVP_INT_TEST_VAL                    = " "0 (VREG_OVP_INT_TEST_VAL_0),1 (VREG_OVP_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT_TEST_VAL                  = " "0 (VREG_READY_INT_TEST_VAL_0),1 (VREG_READY_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_ERROR_INT_TEST_VAL                  = " "0 (VREG_ERROR_INT_TEST_VAL_0),1 (VREG_ERROR_INT_TEST_VAL_1)"
    tree.end
    tree "S1_CTRL_CTRL_TEST"
      sgroup "S1_CTRL_CTRL_TEST (at 0x114e2)"
        set &access:&cmd_addr %l (0x8014e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_OOB_LOWER_VTH_ATEST2_VREF_OK_VTH),2 (ATEST_SEL_ATEST1_OOB_UPPER_VTH_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VSAW_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_IRAMP_PWM_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_ERRAMP_OUT_ATEST2_AVSS),6 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS),7 (ATEST_SEL_ATEST1_OVP_VTHRES_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_PWM_CLK),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_1P2M_CLK),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_NC3_DVSS),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_NC4_DVSS),5 (DTEST_SEL_DTEST1_MODE_DTEST2_NC5_DVSS),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_NC6_DVSS),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_NC7_DVSS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_CTRL_CTRL_TEST_2"
      sgroup "S1_CTRL_CTRL_TEST_2 (at 0x114e3)"
        set &access:&cmd_addr %l (0x8014e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
    tree.end
    tree "S1_CTRL_REF_TRIM_ON"
      sgroup "S1_CTRL_REF_TRIM_ON (at 0x114e4)"
        set &access:&cmd_addr %l (0x8014e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_VREFDAC_TRIM                          = " "0 (VREF_TRIM_DIS),1 (VREF_TRIM_EN)"
    tree.end
    tree "S1_CTRL_OVP_CTRL"
      sgroup "S1_CTRL_OVP_CTRL (at 0x114e6)"
        set &access:&cmd_addr %l (0x8014e60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_OVP                                   = " "0 (OVP_DISABLE),1 (OVP_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVP_SENSE_SEL                            = " "0 (OVP_SENSE_VREG),1 (OVP_SENSE_VMON_OUT)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SET_OVP_THRES                            = " "0 (OVP_THRESH_1110MV),1 (OVP_THRESH_1145MV),2 (OVP_THRESH_1180MV),3 (OVP_THRESH_1215MV),4 (OVP_THRESH_1250MV),5 (OVP_THRESH_1285MV),6 (OVP_THRESH_1320MV),7 (OVP_THRESH_1355MV)"
    tree.end
    tree "S1_CTRL_EXT_VREF"
      sgroup "S1_CTRL_EXT_VREF (at 0x114e7)"
        set &access:&cmd_addr %l (0x8014e70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VMON_REF                                 = " "0 (VMON_EXT_VREF_DISABLED),1 (VMON_EXT_VREF_ENABLED)"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      sgroup "S1_CTRL_TRIM_NUM (at 0x114f0)"
        set &access:&cmd_addr %l (0x8014f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      sgroup "S1_CTRL_CTL_TRIM1 (at 0x114f1)"
        set &access:&cmd_addr %l (0x8014f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
    tree.end
    tree "S1_CTRL_REF_TRIM"
      sgroup "S1_CTRL_REF_TRIM (at 0x114f2)"
        set &access:&cmd_addr %l (0x8014f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VREF_TRIM                                = "
    tree.end
    tree "S1_CTRL_OOB_UPPER_TRIM"
      sgroup "S1_CTRL_OOB_UPPER_TRIM (at 0x114f3)"
        set &access:&cmd_addr %l (0x8014f30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   UPPER_OOB_TRIM                           = "
    tree.end
    tree "S1_CTRL_OOB_LOWER_TRIM"
      sgroup "S1_CTRL_OOB_LOWER_TRIM (at 0x114f4)"
        set &access:&cmd_addr %l (0x8014f40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOWER_OOB_TRIM                           = "
    tree.end
    tree "S1_CTRL_VREG_OK_TRIM"
      sgroup "S1_CTRL_VREG_OK_TRIM (at 0x114f5)"
        set &access:&cmd_addr %l (0x8014f50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VREG_OK_TRIM                             = "
    tree.end
    tree "S1_CTRL_OVP_TRIM"
      sgroup "S1_CTRL_OVP_TRIM (at 0x114f6)"
        set &access:&cmd_addr %l (0x8014f60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OVP_TRIM                                 = "
    tree.end
    tree "S1_CTRL_SPARE3"
      sgroup "S1_CTRL_SPARE3 (at 0x114f7)"
        set &access:&cmd_addr %l (0x8014f70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE3                                   = "
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      sgroup "S1_FREQ_REVISION1 (at 0x11600)"
        set &access:&cmd_addr %l (0x8016000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      sgroup "S1_FREQ_REVISION2 (at 0x11601)"
        set &access:&cmd_addr %l (0x8016010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_REVISION3"
      sgroup "S1_FREQ_REVISION3 (at 0x11602)"
        set &access:&cmd_addr %l (0x8016020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION4"
      sgroup "S1_FREQ_REVISION4 (at 0x11603)"
        set &access:&cmd_addr %l (0x8016030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      sgroup "S1_FREQ_PERPH_TYPE (at 0x11604)"
        set &access:&cmd_addr %l (0x8016040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      sgroup "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
        set &access:&cmd_addr %l (0x8016050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_DIV"
      sgroup "S1_FREQ_CLK_DIV (at 0x11650)"
        set &access:&cmd_addr %l (0x8016500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_SYNC_EN"
      sgroup "S1_FREQ_SYNC_EN (at 0x11660)"
        set &access:&cmd_addr %l (0x8016600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_ENABLE                              = " "0, 1"
    tree.end
    tree "S1_FREQ_SYNC_PHASE"
      sgroup "S1_FREQ_SYNC_PHASE (at 0x11661)"
        set &access:&cmd_addr %l (0x8016610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASTER                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CLK_PHASE                                = " "0 (CLK_PHASE_0),1 (CLK_PHASE_45DEG),2 (CLK_PHASE_90DEG),3 (CLK_PHASE_135DEG),4 (CLK_PHASE_180DEG),5 (CLK_PHASE_225DEG),6 (CLK_PHASE_270DEG),7 (CLK_PHASE_315DEG)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      sgroup "S1_FREQ_SEC_ACCESS (at 0x116d0)"
        set &access:&cmd_addr %l (0x8016d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      sgroup "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
        set &access:&cmd_addr %l (0x8016d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      sgroup "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
        set &access:&cmd_addr %l (0x8016da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      sgroup "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
        set &access:&cmd_addr %l (0x8016db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      sgroup "S1_PS_REVISION1 (at 0x11500)"
        set &access:&cmd_addr %l (0x8015000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      sgroup "S1_PS_REVISION2 (at 0x11501)"
        set &access:&cmd_addr %l (0x8015010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      sgroup "S1_PS_REVISION3 (at 0x11502)"
        set &access:&cmd_addr %l (0x8015020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      sgroup "S1_PS_REVISION4 (at 0x11503)"
        set &access:&cmd_addr %l (0x8015030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      sgroup "S1_PS_PERPH_TYPE (at 0x11504)"
        set &access:&cmd_addr %l (0x8015040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      sgroup "S1_PS_PERPH_SUBTYPE (at 0x11505)"
        set &access:&cmd_addr %l (0x8015050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_CURRENT_LIM_CTL_1"
      sgroup "S1_PS_CURRENT_LIM_CTL_1 (at 0x1154a)"
        set &access:&cmd_addr %l (0x80154a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x154a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ILIMIT                                = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   ILIMIT_SEL                               = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_NMOS_ILIM                            = " "0 (DISABLE_NMOS_ILIMIT_FALSE),1 (DISABLE_NMOS_ILIMIT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COUNT_FOLDBACK_LEVEL_SEL                 = " "0 (CURRENT_FOLDBACK_NONE),1 (CURRENT_FOLDBACK_75PERCENT_OF_ILIM),2 (CURRENT_FOLDBACK_50PERCENT_OF_ILIM),3 (CURRENT_FOLDBACK_25PERCENT_OF_ILIM)"
    tree.end
    tree "S1_PS_CURRENT_LIM_CTL_2"
      sgroup "S1_PS_CURRENT_LIM_CTL_2 (at 0x1154b)"
        set &access:&cmd_addr %l (0x80154b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x154b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FOLDBACK_COUNT_SEL                       = " "0 (FOLDBACK_CYCLE_COUNT_4),1 (FOLDBACK_CYCLE_COUNT_6),2 (FOLDBACK_CYCLE_COUNT_10),3 (FOLDBACK_CYCLE_COUNT_18)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_FOLDBACK                           = " "0 (FORCE_FOLDBACK_FALSE),1 (FORCE_FOLDBACK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STARTUP_FOLDBACK_LEVEL_SEL               = " "0 (STARTUP_FOLDBACK_LEVEL_75PERCENT),1 (STARTUP_FOLDBACK_LEVEL_50PERCENT),2 (STARTUP_FOLDBACK_LEVEL_25PERCENT),3 (STARTUP_FOLDBACK_LEVEL_NONE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LONG_FOLDBACK_TIME                       = " "0 (LONG_FOLDBACK_INFINITE),1 (LONG_FOLDBACK_80US)"
    tree.end
    tree "S1_PS_SHED_CTL"
      sgroup "S1_PS_SHED_CTL (at 0x11570)"
        set &access:&cmd_addr %l (0x8015700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIS_SHED                                 = " "0 (SHEDDING_ENABLED),1 (SHEDDING_DISABLED)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   SHED_SEL                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_SHED                               = " "0 (AUTOMATIC_SHED),1 (FORCE_SHED)"
    tree.end
    tree "S1_PS_ZX_CTRL"
      sgroup "S1_PS_ZX_CTRL (at 0x11573)"
        set &access:&cmd_addr %l (0x8015730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_OFFSET                                = "
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      sgroup "S1_PS_BLNK_TIME_CTL (at 0x11574)"
        set &access:&cmd_addr %l (0x8015740|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15740|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RAMP_GAIN                                = " "0 (RAMP_GAIN_53MOHM),1 (RAMP_GAIN_40MOHM),2 (RAMP_GAIN_32MOHM),3 (RAMP_GAIN_27MOHM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_MIN_PON                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   PMIN_ON                                  = " "0 (MIN_PON_PLUS_0NS),1 (MIN_PON_PLUS_10NS),2 (MIN_PON_PLUS_11NS),3 (MIN_PON_PLUS_20NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_20NS),1 (ISNS_BLNK_TIME_10NS)"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      sgroup "S1_PS_PWR_STG_MISC (at 0x11579)"
        set &access:&cmd_addr %l (0x8015790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0 (VREG_OK_NO_EFFECT_ON_CL_FB),1 (VREG_OK_PREVENTS_CL_FB)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0 (TWELVE_CYCLE_SHED),1 (SIX_CYCLE_SHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0 (NORMAL_MODE),1 (TEST_MIN_ON_TIME)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0 (DEFAULT_DTEST),1 (ALTERNATE_DTEST)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0 (NORMAL_OPERATION),1 (TEST_ILIM_FOLDBACK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0 (SWITCH_50_PERCENT_DUTY),1 (NORMAL_OPERATION)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (NORMAL_OPERATION),1 (TEST_SHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_NMOS_ILIM_EN                       = " "0, 1"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      sgroup "S1_PS_SEC_ACCESS (at 0x115d0)"
        set &access:&cmd_addr %l (0x8015d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      sgroup "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
        set &access:&cmd_addr %l (0x8015d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      sgroup "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
        set &access:&cmd_addr %l (0x8015da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      sgroup "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
        set &access:&cmd_addr %l (0x8015db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_PS_FORCE_FET_TEST_1"
      sgroup "S1_PS_FORCE_FET_TEST_1 (at 0x115e0)"
        set &access:&cmd_addr %l (0x8015e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KELVIN_SENSING_TEST_EN                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FET_SEL_SW0                              = "
    tree.end
    tree "S1_PS_FORCE_FET_TEST_2"
      sgroup "S1_PS_FORCE_FET_TEST_2 (at 0x115e1)"
        set &access:&cmd_addr %l (0x8015e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ZX_EN                                    = " "0 (FORCE_FET_ZX_EN_FALSE),1 (FORCE_FET_ZX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRISTATE_FORCE                           = " "0 (FORCE_FET_TRISTATE_FORCE_FALSE),1 (FORCE_FET_TRISTATE_FORCE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FET_SEL_SW1                              = "
    tree.end
    tree "S1_PS_PWR_STG_TEST_1"
      sgroup "S1_PS_PWR_STG_TEST_1 (at 0x115e2)"
        set &access:&cmd_addr %l (0x8015e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_TRIM_CALIB_EN                         = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S1_PS_PWR_STG_TEST_2"
      sgroup "S1_PS_PWR_STG_TEST_2 (at 0x115e3)"
        set &access:&cmd_addr %l (0x8015e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SEL_VSW                                  = " "0 (TEST_2_SEL_VSW0),1 (TEST_2_SEL_VSW1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SEL_PVDD                                 = " "0 (TEST_2_SEL_PVDD0),1 (TEST_2_SEL_PVDD1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SEL_RON_N                                = " "0 (TEST_2_SEL_RON_N_NOT_TESTED),1 (TEST_2_SEL_RON_N_VSW_TO_ATEST1_AND_PGND_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SEL_RON_P                                = " "0 (TEST_2_SEL_RON_P_NOT_TESTED),1 (TEST_2_SEL_RON_P_VSW_TO_ATEST2_AND_PVDD_TO_ATEST1)"
    tree.end
    tree "S1_PS_TRIM_NUM"
      sgroup "S1_PS_TRIM_NUM (at 0x115f0)"
        set &access:&cmd_addr %l (0x8015f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      sgroup "S1_PS_PS_TRIM1 (at 0x115f1)"
        set &access:&cmd_addr %l (0x8015f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ILIMIT_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   NMOS_ILIMIT_TRIM                         = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      sgroup "S1_PS_PS_TRIM2 (at 0x115f2)"
        set &access:&cmd_addr %l (0x8015f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DT_NMOS                                  = " "0 (DT_NMOS_DEL_0N),1 (DT_NMOS_DEL_1N),2 (DT_NMOS_DEL_2N),3 (DT_NMOS_DEL_3N),4 (DT_NMOS_DEL_4N),5 (DT_NMOS_DEL_5N),6 (DT_NMOS_DEL_6N),7 (DT_NMOS_DEL_7N)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DT_PMOS                                  = " "0 (DT_PMOS_DEL_0N),1 (DT_PMOS_DEL_1N),2 (DT_PMOS_DEL_2N),3 (DT_PMOS_DEL_3N),4 (DT_PMOS_DEL_4N),5 (DT_PMOS_DEL_5N),6 (DT_PMOS_DEL_6N),7 (DT_PMOS_DEL_7N)"
    tree.end
    tree "S1_PS_ZX_TRIM"
      sgroup "S1_PS_ZX_TRIM (at 0x115f3)"
        set &access:&cmd_addr %l (0x8015f30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_TRIM                                  = "
    tree.end
    tree "S1_PS_SHED_TRIM"
      sgroup "S1_PS_SHED_TRIM (at 0x115f4)"
        set &access:&cmd_addr %l (0x8015f40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   SHED_TRIM                                = "
    tree.end
    tree "S1_PS_RAMP_TRIM"
      sgroup "S1_PS_RAMP_TRIM (at 0x115f5)"
        set &access:&cmd_addr %l (0x8015f50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ILIM_PRESET                              = "
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   RAMP_TRIM                                = " "0 (RAMP_TRIM_0),1 (RAMP_TRIM_1),2 (RAMP_TRIM_2),3 (RAMP_TRIM_3),4 (RAMP_TRIM_4),5 (RAMP_TRIM_5),6 (RAMP_TRIM_6),7 (RAMP_TRIM_7)"
    tree.end
    tree "S1_PS_PS_SPARES"
      sgroup "S1_PS_PS_SPARES (at 0x115f6)"
        set &access:&cmd_addr %l (0x8015f60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   SPARES                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SHED_GAIN_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&cmd_addr %l (0x8006000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&cmd_addr %l (0x8006010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&cmd_addr %l (0x8006020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&cmd_addr %l (0x8006030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&cmd_addr %l (0x8006040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&cmd_addr %l (0x8006050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&cmd_addr %l (0x8006080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&cmd_addr %l (0x80060b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&cmd_addr %l (0x80060c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&cmd_addr %l (0x80060d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&cmd_addr %l (0x80060e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&cmd_addr %l (0x8006100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&cmd_addr %l (0x8006110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&cmd_addr %l (0x8006120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&cmd_addr %l (0x8006130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&cmd_addr %l (0x8006140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&cmd_addr %l (0x8006150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&cmd_addr %l (0x8006160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&cmd_addr %l (0x8006180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&cmd_addr %l (0x8006190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&cmd_addr %l (0x80061a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&cmd_addr %l (0x80061b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&cmd_addr %l (0x8006400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      sgroup "SPMI_SSC_DETECT_CFG (at 0x641)"
        set &access:&cmd_addr %l (0x8006410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&cmd_addr %l (0x8006d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&cmd_addr %l (0x8006d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&cmd_addr %l (0x8006da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&cmd_addr %l (0x8006db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&cmd_addr %l (0x8006e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&cmd_addr %l (0x8006e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&cmd_addr %l (0x8006e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      sgroup "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
        set &access:&cmd_addr %l (0x8006430|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6430|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&cmd_addr %l (0x8006440|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6440|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&cmd_addr %l (0x8006450|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6450|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&cmd_addr %l (0x8006460|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6460|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&cmd_addr %l (0x8006470|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6470|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      sgroup "TEMP_ALARM_REVISION1 (at 0x2400)"
        set &access:&cmd_addr %l (0x8024000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      sgroup "TEMP_ALARM_REVISION2 (at 0x2401)"
        set &access:&cmd_addr %l (0x8024010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      sgroup "TEMP_ALARM_REVISION3 (at 0x2402)"
        set &access:&cmd_addr %l (0x8024020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      sgroup "TEMP_ALARM_REVISION4 (at 0x2403)"
        set &access:&cmd_addr %l (0x8024030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      sgroup "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
        set &access:&cmd_addr %l (0x8024040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      sgroup "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
        set &access:&cmd_addr %l (0x8024050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      sgroup "TEMP_ALARM_STATUS1 (at 0x2408)"
        set &access:&cmd_addr %l (0x8024080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0 (STAGE_0),1 (STAGE_1),2 (STAGE_2),3 (STAGE_3)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      sgroup "TEMP_ALARM_INT_RT_STS (at 0x2410)"
        set &access:&cmd_addr %l (0x8024100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      sgroup "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
        set &access:&cmd_addr %l (0x8024110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      sgroup "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
        set &access:&cmd_addr %l (0x8024120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      sgroup "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
        set &access:&cmd_addr %l (0x8024130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      sgroup "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
        set &access:&cmd_addr %l (0x8024140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      sgroup "TEMP_ALARM_INT_EN_SET (at 0x2415)"
        set &access:&cmd_addr %l (0x8024150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      sgroup "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
        set &access:&cmd_addr %l (0x8024160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      sgroup "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
        set &access:&cmd_addr %l (0x8024180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      sgroup "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
        set &access:&cmd_addr %l (0x8024190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      sgroup "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
        set &access:&cmd_addr %l (0x80241a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x241a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      sgroup "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
        set &access:&cmd_addr %l (0x80241b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x241b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
        set &access:&cmd_addr %l (0x8024400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
        set &access:&cmd_addr %l (0x8024420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      sgroup "TEMP_ALARM_EN_CTL1 (at 0x2446)"
        set &access:&cmd_addr %l (0x8024460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      sgroup "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
        set &access:&cmd_addr %l (0x8024d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
        set &access:&cmd_addr %l (0x8024d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
        set &access:&cmd_addr %l (0x8024d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
        set &access:&cmd_addr %l (0x8024da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
        set &access:&cmd_addr %l (0x8024db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      sgroup "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
        set &access:&cmd_addr %l (0x8024e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      sgroup "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
        set &access:&cmd_addr %l (0x8024e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TEST1"
      sgroup "TEMP_ALARM_TEST1 (at 0x24e2)"
        set &access:&cmd_addr %l (0x8024e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST1_UPR_STAT_I_DTEST2_LWR_STAT_I)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0 (USE_INTERNAL_VTEMP),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0 (OFF),1 (ATEST_VTEMP_BUF),2 (ATEST_UPR_DAC),3 (ATEST_LWR_DAC)"
    tree.end
    tree "TEMP_ALARM_TEST2"
      sgroup "TEMP_ALARM_TEST2 (at 0x24e3)"
        set &access:&cmd_addr %l (0x8024e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0 (BUFFERED),1 (UNBUFFERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST2_DTEST1_TEMP_STATUS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0 (NORMAL_OPERATION),1 (USE_ATEST_FOR_THRESHOLDS)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      sgroup "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
        set &access:&cmd_addr %l (0x8024f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      sgroup "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
        set &access:&cmd_addr %l (0x8024f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&cmd_addr %l (0x80fe000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&cmd_addr %l (0x80fe010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&cmd_addr %l (0x80fe020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&cmd_addr %l (0x80fe030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&cmd_addr %l (0x80fe040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&cmd_addr %l (0x80fe050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&cmd_addr %l (0x80fe080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&cmd_addr %l (0x80fe090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&cmd_addr %l (0x80fe0a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe0a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&cmd_addr %l (0x80fe0b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe0b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&cmd_addr %l (0x80fed00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfed00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&cmd_addr %l (0x80fed90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfed90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&cmd_addr %l (0x80feda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfeda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&cmd_addr %l (0x80fedb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfedb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&cmd_addr %l (0x80fee00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&cmd_addr %l (0x80fee10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&cmd_addr %l (0x80fee20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&cmd_addr %l (0x80fee30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&cmd_addr %l (0x80fee40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&cmd_addr %l (0x80fee50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&cmd_addr %l (0x80fee60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end

