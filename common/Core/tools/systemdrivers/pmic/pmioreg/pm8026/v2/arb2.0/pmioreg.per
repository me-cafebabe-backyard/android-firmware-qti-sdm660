      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_OFFSET_ILED1                        = "
    tree.end
    tree "WLED1_TRIM_OFFSET_ILED2"
      sgroup "WLED1_TRIM_OFFSET_ILED2 (at 0x1d8f5)"
        set &access:&cmd_addr %l (0x80d8f50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_OFFSET_ILED2                        = "
    tree.end
    tree "WLED1_TRIM_OFFSET_ILED3"
      sgroup "WLED1_TRIM_OFFSET_ILED3 (at 0x1d8f6)"
        set &access:&cmd_addr %l (0x80d8f60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_OFFSET_ILED3                        = "
    tree.end
    tree "WLED1_TRIM_ILIM"
      sgroup "WLED1_TRIM_ILIM (at 0x1d8f7)"
        set &access:&cmd_addr %l (0x80d8f70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_ILIM                                = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      sgroup "XO_REVISION1 (at 0x5000)"
        set &access:&cmd_addr %l (0x8050000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      sgroup "XO_REVISION2 (at 0x5001)"
        set &access:&cmd_addr %l (0x8050010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      sgroup "XO_REVISION3 (at 0x5002)"
        set &access:&cmd_addr %l (0x8050020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      sgroup "XO_REVISION4 (at 0x5003)"
        set &access:&cmd_addr %l (0x8050030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      sgroup "XO_PERPH_TYPE (at 0x5004)"
        set &access:&cmd_addr %l (0x8050040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      sgroup "XO_PERPH_SUBTYPE (at 0x5005)"
        set &access:&cmd_addr %l (0x8050050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      sgroup "XO_STATUS1 (at 0x5008)"
        set &access:&cmd_addr %l (0x8050080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_OK                                = " "0 (XO19M_OFF),1 (XO19M_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SLEEP_B                                  = " "0 (PMIC_SLEEP),1 (PMIC_AWAKE)"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      sgroup "XO_VOLTAGE_CTL1 (at 0x5040)"
        set &access:&cmd_addr %l (0x8050400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0 (AUTO),1 (VREG_XO),2 (VREG_SMPS),3 (XVDD)"
    tree.end
    tree "XO_MODE_CTL1"
      sgroup "XO_MODE_CTL1 (at 0x5044)"
        set &access:&cmd_addr %l (0x8050440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RF_PREBUFF_MODE                          = " "0 (VLPM),1 (LPM),2 (NPM),3 (HPM)"
    tree.end
    tree "XO_EN_CTL"
      sgroup "XO_EN_CTL (at 0x5046)"
        set &access:&cmd_addr %l (0x8050460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0 (XO19M_NOT_FORCED),1 (XO19M_FORCED_ON)"
    tree.end
    tree "XO_XO_TIMER1"
      sgroup "XO_XO_TIMER1 (at 0x504c)"
        set &access:&cmd_addr %l (0x80504c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x504c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   XO_TIMER_LSB                             = "
    tree.end
    tree "XO_XO_TIMER2"
      sgroup "XO_XO_TIMER2 (at 0x504d)"
        set &access:&cmd_addr %l (0x80504d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x504d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   XO_TIMER_MSB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "XO_XO_STEPPER"
      sgroup "XO_XO_STEPPER (at 0x505a)"
        set &access:&cmd_addr %l (0x80505a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x505a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_SS_DELAY_EN                           = " "0 (XO_FASTSTART_DIS),1 (XO_FAST_START_EN)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_SS_DELAY                              = "
    tree.end
    tree "XO_XO_ADJ_FINE"
      sgroup "XO_XO_ADJ_FINE (at 0x505c)"
        set &access:&cmd_addr %l (0x80505c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x505c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   XO_ADJUST_CAP                            = "
    tree.end
    tree "XO_XO_ADJ_COARSE"
      sgroup "XO_XO_ADJ_COARSE (at 0x505b)"
        set &access:&cmd_addr %l (0x80505b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x505b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_FIXED_CAP_EN1                         = " "0 (FIX_CAP1_DIS),1 (FIX_CAP1_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XO_FIXED_CAP_EN2                         = " "0 (FIX_CAP2_DIS),1 (FIX_CAP2_EN)"
    tree.end
    tree "XO_XO_CTL"
      sgroup "XO_XO_CTL (at 0x505e)"
        set &access:&cmd_addr %l (0x80505e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x505e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICTL3                                    = " "0 (XO_BIAS3_DIS),1 (XO_BIAS3_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ICTL2                                    = " "0 (XO_BIAS2_DIS),1 (XO_BIAS2_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ICTL1                                    = " "0 (XO_BIAS1_DIS),1 (XO_BIAS1_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_RATE                                  = " "0 (TCXO_DIV_8),1 (TCXO_DIV_16),2 (TCXO_DIV_128),3 (TCXO_DIV_256)"
    tree.end
    tree "XO_SEC_ACCESS"
      sgroup "XO_SEC_ACCESS (at 0x50d0)"
        set &access:&cmd_addr %l (0x8050d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "XO_PERPH_RESET_CTL2"
      sgroup "XO_PERPH_RESET_CTL2 (at 0x50d9)"
        set &access:&cmd_addr %l (0x8050d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL3"
      sgroup "XO_PERPH_RESET_CTL3 (at 0x50da)"
        set &access:&cmd_addr %l (0x8050da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL4"
      sgroup "XO_PERPH_RESET_CTL4 (at 0x50db)"
        set &access:&cmd_addr %l (0x8050db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "XO_TEST1"
      sgroup "XO_TEST1 (at 0x50e2)"
        set &access:&cmd_addr %l (0x8050e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST1_SEL                               = " "0 (HIZ),1 (XO19M),2 (OUTBUG_EN),3 (OUTBUFF_EN_DLY),4 (STEPPER_DONE),5 (SLEEP_B),6 (RESERVED),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   XO_AGC_TEST_EN                           = " "0 (NORMAL),1 (XO_AGC_ON_ATEST)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADJ_CODE_TEST                            = " "0 (GRAY_CODE),1 (BINARY_CODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SS_RESET                                 = " "0 (NORMAL),1 (RESET_STEPPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUF_FOLLOW_BB                      = " "0 (RFPREBUFF_NOT_FOLLOW_BB),1 (RFPREBUFF_FOLLOW_BB)"
    tree.end
    tree "XO_TEST2"
      sgroup "XO_TEST2 (at 0x50e4)"
        set &access:&cmd_addr %l (0x8050e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x50e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RF_OUT_DTEST                             = " "0 (NORMAL),1 (DRIVE_RF_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RF_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BB_OUT_DTEST                             = " "0 (NORMAL),1 (DRIVE_BB_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BB_OUT_TEST                              = " "0 (NORMAL),1 (DISABLED),2 (reserved),3 (reserved)"
    tree.end
  tree.end
tree.end

