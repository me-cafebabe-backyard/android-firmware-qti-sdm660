      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO27_VOLTAGE_CTL1"
      sgroup "LDO27_VOLTAGE_CTL1 (at 0x15a40)"
        set &access:&cmd_addr %l (0x805a400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO27_VOLTAGE_CTL2"
      sgroup "LDO27_VOLTAGE_CTL2 (at 0x15a41)"
        set &access:&cmd_addr %l (0x805a410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO27_MODE_CTL2"
      sgroup "LDO27_MODE_CTL2 (at 0x15a45)"
        set &access:&cmd_addr %l (0x805a450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO27_EN_CTL"
      sgroup "LDO27_EN_CTL (at 0x15a46)"
        set &access:&cmd_addr %l (0x805a460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO27_PD_CTL"
      sgroup "LDO27_PD_CTL (at 0x15a48)"
        set &access:&cmd_addr %l (0x805a480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO27_CURRENT_LIM_CTL"
      sgroup "LDO27_CURRENT_LIM_CTL (at 0x15a4a)"
        set &access:&cmd_addr %l (0x805a4a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a4a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO27_SOFT_START_CTL"
      sgroup "LDO27_SOFT_START_CTL (at 0x15a4c)"
        set &access:&cmd_addr %l (0x805a4c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a4c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO27_CONFIG_CTL"
      sgroup "LDO27_CONFIG_CTL (at 0x15a52)"
        set &access:&cmd_addr %l (0x805a520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO27_LL_VOLTAGE_CTL1"
      sgroup "LDO27_LL_VOLTAGE_CTL1 (at 0x15a68)"
        set &access:&cmd_addr %l (0x805a680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO27_LL_VOLTAGE_CTL2"
      sgroup "LDO27_LL_VOLTAGE_CTL2 (at 0x15a69)"
        set &access:&cmd_addr %l (0x805a690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO27_UL_VOLTAGE_CTL1"
      sgroup "LDO27_UL_VOLTAGE_CTL1 (at 0x15a6a)"
        set &access:&cmd_addr %l (0x805a6a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a6a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO27_UL_VOLTAGE_CTL2"
      sgroup "LDO27_UL_VOLTAGE_CTL2 (at 0x15a6b)"
        set &access:&cmd_addr %l (0x805a6b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a6b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO27_SEC_ACCESS"
      sgroup "LDO27_SEC_ACCESS (at 0x15ad0)"
        set &access:&cmd_addr %l (0x805ad00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ad00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO27_PERPH_RESET_CTL1"
      sgroup "LDO27_PERPH_RESET_CTL1 (at 0x15ad8)"
        set &access:&cmd_addr %l (0x805ad80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ad80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO27_PERPH_RESET_CTL2"
      sgroup "LDO27_PERPH_RESET_CTL2 (at 0x15ad9)"
        set &access:&cmd_addr %l (0x805ad90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ad90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO27_PERPH_RESET_CTL3"
      sgroup "LDO27_PERPH_RESET_CTL3 (at 0x15ada)"
        set &access:&cmd_addr %l (0x805ada0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ada0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO27_PERPH_RESET_CTL4"
      sgroup "LDO27_PERPH_RESET_CTL4 (at 0x15adb)"
        set &access:&cmd_addr %l (0x805adb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5adb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO27_INT_TEST1"
      sgroup "LDO27_INT_TEST1 (at 0x15ae0)"
        set &access:&cmd_addr %l (0x805ae00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ae00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO27_INT_TEST_VAL"
      sgroup "LDO27_INT_TEST_VAL (at 0x15ae1)"
        set &access:&cmd_addr %l (0x805ae10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ae10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO27_TEST1"
      sgroup "LDO27_TEST1 (at 0x15ae2)"
        set &access:&cmd_addr %l (0x805ae20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ae20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO27_TEST2"
      sgroup "LDO27_TEST2 (at 0x15ae3)"
        set &access:&cmd_addr %l (0x805ae30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ae30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO27_TRIM_NUM"
      sgroup "LDO27_TRIM_NUM (at 0x15af0)"
        set &access:&cmd_addr %l (0x805af00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5af00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO27_TRIM_CTRL"
      sgroup "LDO27_TRIM_CTRL (at 0x15af1)"
        set &access:&cmd_addr %l (0x805af10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5af10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO28"
  tree "LDO28"
    tree "LDO28_REVISION1"
      sgroup "LDO28_REVISION1 (at 0x15b00)"
        set &access:&cmd_addr %l (0x805b000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO28_REVISION2"
      sgroup "LDO28_REVISION2 (at 0x15b01)"
        set &access:&cmd_addr %l (0x805b010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO28_REVISION3"
      sgroup "LDO28_REVISION3 (at 0x15b02)"
        set &access:&cmd_addr %l (0x805b020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO28_REVISION4"
      sgroup "LDO28_REVISION4 (at 0x15b03)"
        set &access:&cmd_addr %l (0x805b030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO28_PERPH_TYPE"
      sgroup "LDO28_PERPH_TYPE (at 0x15b04)"
        set &access:&cmd_addr %l (0x805b040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO28_PERPH_SUBTYPE"
      sgroup "LDO28_PERPH_SUBTYPE (at 0x15b05)"
        set &access:&cmd_addr %l (0x805b050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO28_STATUS1"
      sgroup "LDO28_STATUS1 (at 0x15b08)"
        set &access:&cmd_addr %l (0x805b080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO28_STATUS2"
      sgroup "LDO28_STATUS2 (at 0x15b09)"
        set &access:&cmd_addr %l (0x805b090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO28_STATUS3"
      sgroup "LDO28_STATUS3 (at 0x15b0a)"
        set &access:&cmd_addr %l (0x805b0a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b0a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO28_INT_RT_STS"
      sgroup "LDO28_INT_RT_STS (at 0x15b10)"
        set &access:&cmd_addr %l (0x805b100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO28_INT_SET_TYPE"
      sgroup "LDO28_INT_SET_TYPE (at 0x15b11)"
        set &access:&cmd_addr %l (0x805b110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO28_INT_POLARITY_HIGH"
      sgroup "LDO28_INT_POLARITY_HIGH (at 0x15b12)"
        set &access:&cmd_addr %l (0x805b120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO28_INT_POLARITY_LOW"
      sgroup "LDO28_INT_POLARITY_LOW (at 0x15b13)"
        set &access:&cmd_addr %l (0x805b130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO28_INT_LATCHED_CLR"
      sgroup "LDO28_INT_LATCHED_CLR (at 0x15b14)"
        set &access:&cmd_addr %l (0x805b140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO28_INT_EN_SET"
      sgroup "LDO28_INT_EN_SET (at 0x15b15)"
        set &access:&cmd_addr %l (0x805b150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO28_INT_EN_CLR"
      sgroup "LDO28_INT_EN_CLR (at 0x15b16)"
        set &access:&cmd_addr %l (0x805b160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO28_INT_LATCHED_STS"
      sgroup "LDO28_INT_LATCHED_STS (at 0x15b18)"
        set &access:&cmd_addr %l (0x805b180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO28_INT_PENDING_STS"
      sgroup "LDO28_INT_PENDING_STS (at 0x15b19)"
        set &access:&cmd_addr %l (0x805b190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO28_INT_MID_SEL"
      sgroup "LDO28_INT_MID_SEL (at 0x15b1a)"
        set &access:&cmd_addr %l (0x805b1a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b1a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO28_INT_PRIORITY"
      sgroup "LDO28_INT_PRIORITY (at 0x15b1b)"
        set &access:&cmd_addr %l (0x805b1b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b1b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO28_VOLTAGE_CTL1"
      sgroup "LDO28_VOLTAGE_CTL1 (at 0x15b40)"
        set &access:&cmd_addr %l (0x805b400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO28_VOLTAGE_CTL2"
      sgroup "LDO28_VOLTAGE_CTL2 (at 0x15b41)"
        set &access:&cmd_addr %l (0x805b410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO28_MODE_CTL2"
      sgroup "LDO28_MODE_CTL2 (at 0x15b45)"
        set &access:&cmd_addr %l (0x805b450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO28_EN_CTL"
      sgroup "LDO28_EN_CTL (at 0x15b46)"
        set &access:&cmd_addr %l (0x805b460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO28_PD_CTL"
      sgroup "LDO28_PD_CTL (at 0x15b48)"
        set &access:&cmd_addr %l (0x805b480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO28_CURRENT_LIM_CTL"
      sgroup "LDO28_CURRENT_LIM_CTL (at 0x15b4a)"
        set &access:&cmd_addr %l (0x805b4a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b4a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO28_SOFT_START_CTL"
      sgroup "LDO28_SOFT_START_CTL (at 0x15b4c)"
        set &access:&cmd_addr %l (0x805b4c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b4c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO28_CONFIG_CTL"
      sgroup "LDO28_CONFIG_CTL (at 0x15b52)"
        set &access:&cmd_addr %l (0x805b520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO28_LL_VOLTAGE_CTL1"
      sgroup "LDO28_LL_VOLTAGE_CTL1 (at 0x15b68)"
        set &access:&cmd_addr %l (0x805b680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO28_LL_VOLTAGE_CTL2"
      sgroup "LDO28_LL_VOLTAGE_CTL2 (at 0x15b69)"
        set &access:&cmd_addr %l (0x805b690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO28_UL_VOLTAGE_CTL1"
      sgroup "LDO28_UL_VOLTAGE_CTL1 (at 0x15b6a)"
        set &access:&cmd_addr %l (0x805b6a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b6a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO28_UL_VOLTAGE_CTL2"
      sgroup "LDO28_UL_VOLTAGE_CTL2 (at 0x15b6b)"
        set &access:&cmd_addr %l (0x805b6b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5b6b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO28_SEC_ACCESS"
      sgroup "LDO28_SEC_ACCESS (at 0x15bd0)"
        set &access:&cmd_addr %l (0x805bd00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5bd00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO28_PERPH_RESET_CTL1"
      sgroup "LDO28_PERPH_RESET_CTL1 (at 0x15bd8)"
        set &access:&cmd_addr %l (0x805bd80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5bd80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO28_PERPH_RESET_CTL2"
      sgroup "LDO28_PERPH_RESET_CTL2 (at 0x15bd9)"
        set &access:&cmd_addr %l (0x805bd90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5bd90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO28_PERPH_RESET_CTL3"
      sgroup "LDO28_PERPH_RESET_CTL3 (at 0x15bda)"
        set &access:&cmd_addr %l (0x805bda0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5bda0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO28_PERPH_RESET_CTL4"
      sgroup "LDO28_PERPH_RESET_CTL4 (at 0x15bdb)"
        set &access:&cmd_addr %l (0x805bdb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5bdb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO28_INT_TEST1"
      sgroup "LDO28_INT_TEST1 (at 0x15be0)"
        set &access:&cmd_addr %l (0x805be00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5be00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO28_INT_TEST_VAL"
      sgroup "LDO28_INT_TEST_VAL (at 0x15be1)"
        set &access:&cmd_addr %l (0x805be10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5be10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO28_TEST1"
      sgroup "LDO28_TEST1 (at 0x15be2)"
        set &access:&cmd_addr %l (0x805be20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5be20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO28_TEST2"
      sgroup "LDO28_TEST2 (at 0x15be3)"
        set &access:&cmd_addr %l (0x805be30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5be30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO28_TRIM_NUM"
      sgroup "LDO28_TRIM_NUM (at 0x15bf0)"
        set &access:&cmd_addr %l (0x805bf00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5bf00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO28_TRIM_CTRL"
      sgroup "LDO28_TRIM_CTRL (at 0x15bf1)"
        set &access:&cmd_addr %l (0x805bf10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5bf10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO3"
  tree "LDO3"
    tree "LDO3_REVISION1"
      sgroup "LDO3_REVISION1 (at 0x14200)"
        set &access:&cmd_addr %l (0x8042000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO3_REVISION2"
      sgroup "LDO3_REVISION2 (at 0x14201)"
        set &access:&cmd_addr %l (0x8042010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO3_REVISION3"
      sgroup "LDO3_REVISION3 (at 0x14202)"
        set &access:&cmd_addr %l (0x8042020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO3_REVISION4"
      sgroup "LDO3_REVISION4 (at 0x14203)"
        set &access:&cmd_addr %l (0x8042030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO3_PERPH_TYPE"
      sgroup "LDO3_PERPH_TYPE (at 0x14204)"
        set &access:&cmd_addr %l (0x8042040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO3_PERPH_SUBTYPE"
      sgroup "LDO3_PERPH_SUBTYPE (at 0x14205)"
        set &access:&cmd_addr %l (0x8042050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO3_STATUS1"
      sgroup "LDO3_STATUS1 (at 0x14208)"
        set &access:&cmd_addr %l (0x8042080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO3_STATUS2"
      sgroup "LDO3_STATUS2 (at 0x14209)"
        set &access:&cmd_addr %l (0x8042090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO3_STATUS3"
      sgroup "LDO3_STATUS3 (at 0x1420a)"
        set &access:&cmd_addr %l (0x80420a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x420a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO3_INT_RT_STS"
      sgroup "LDO3_INT_RT_STS (at 0x14210)"
        set &access:&cmd_addr %l (0x8042100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_SET_TYPE"
      sgroup "LDO3_INT_SET_TYPE (at 0x14211)"
        set &access:&cmd_addr %l (0x8042110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_HIGH"
      sgroup "LDO3_INT_POLARITY_HIGH (at 0x14212)"
        set &access:&cmd_addr %l (0x8042120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO3_INT_POLARITY_LOW"
      sgroup "LDO3_INT_POLARITY_LOW (at 0x14213)"
        set &access:&cmd_addr %l (0x8042130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO3_INT_LATCHED_CLR"
      sgroup "LDO3_INT_LATCHED_CLR (at 0x14214)"
        set &access:&cmd_addr %l (0x8042140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO3_INT_EN_SET"
      sgroup "LDO3_INT_EN_SET (at 0x14215)"
        set &access:&cmd_addr %l (0x8042150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_EN_CLR"
      sgroup "LDO3_INT_EN_CLR (at 0x14216)"
        set &access:&cmd_addr %l (0x8042160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO3_INT_LATCHED_STS"
      sgroup "LDO3_INT_LATCHED_STS (at 0x14218)"
        set &access:&cmd_addr %l (0x8042180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO3_INT_PENDING_STS"
      sgroup "LDO3_INT_PENDING_STS (at 0x14219)"
        set &access:&cmd_addr %l (0x8042190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO3_INT_MID_SEL"
      sgroup "LDO3_INT_MID_SEL (at 0x1421a)"
        set &access:&cmd_addr %l (0x80421a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x421a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO3_INT_PRIORITY"
      sgroup "LDO3_INT_PRIORITY (at 0x1421b)"
        set &access:&cmd_addr %l (0x80421b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x421b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO3_VOLTAGE_CTL1"
      sgroup "LDO3_VOLTAGE_CTL1 (at 0x14240)"
        set &access:&cmd_addr %l (0x8042400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_VOLTAGE_CTL2"
      sgroup "LDO3_VOLTAGE_CTL2 (at 0x14241)"
        set &access:&cmd_addr %l (0x8042410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO3_MODE_CTL2"
      sgroup "LDO3_MODE_CTL2 (at 0x14245)"
        set &access:&cmd_addr %l (0x8042450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_EN_CTL"
      sgroup "LDO3_EN_CTL (at 0x14246)"
        set &access:&cmd_addr %l (0x8042460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO3_PD_CTL"
      sgroup "LDO3_PD_CTL (at 0x14248)"
        set &access:&cmd_addr %l (0x8042480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO3_CURRENT_LIM_CTL"
      sgroup "LDO3_CURRENT_LIM_CTL (at 0x1424a)"
        set &access:&cmd_addr %l (0x80424a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x424a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO3_SOFT_START_CTL"
      sgroup "LDO3_SOFT_START_CTL (at 0x1424c)"
        set &access:&cmd_addr %l (0x80424c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x424c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO3_CONFIG_CTL"
      sgroup "LDO3_CONFIG_CTL (at 0x14252)"
        set &access:&cmd_addr %l (0x8042520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO3_VS_CTL"
      sgroup "LDO3_VS_CTL (at 0x14261)"
        set &access:&cmd_addr %l (0x8042610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (DELAY_1_20),1 (DELAY_1_40),2 (DELAY_1_80),3 (DELAY_1_160),4 (DELAY_1_320),5 (DELAY_1_640),6 (DELAY_1_1280),7 (DELAY_1_2560)"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL1"
      sgroup "LDO3_LL_VOLTAGE_CTL1 (at 0x14268)"
        set &access:&cmd_addr %l (0x8042680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_LL_VOLTAGE_CTL2"
      sgroup "LDO3_LL_VOLTAGE_CTL2 (at 0x14269)"
        set &access:&cmd_addr %l (0x8042690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL1"
      sgroup "LDO3_UL_VOLTAGE_CTL1 (at 0x1426a)"
        set &access:&cmd_addr %l (0x80426a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x426a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO3_UL_VOLTAGE_CTL2"
      sgroup "LDO3_UL_VOLTAGE_CTL2 (at 0x1426b)"
        set &access:&cmd_addr %l (0x80426b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x426b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO3_SEC_ACCESS"
      sgroup "LDO3_SEC_ACCESS (at 0x142d0)"
        set &access:&cmd_addr %l (0x8042d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO3_PERPH_RESET_CTL1"
      sgroup "LDO3_PERPH_RESET_CTL1 (at 0x142d8)"
        set &access:&cmd_addr %l (0x8042d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL2"
      sgroup "LDO3_PERPH_RESET_CTL2 (at 0x142d9)"
        set &access:&cmd_addr %l (0x8042d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL3"
      sgroup "LDO3_PERPH_RESET_CTL3 (at 0x142da)"
        set &access:&cmd_addr %l (0x8042da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO3_PERPH_RESET_CTL4"
      sgroup "LDO3_PERPH_RESET_CTL4 (at 0x142db)"
        set &access:&cmd_addr %l (0x8042db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO3_INT_TEST1"
      sgroup "LDO3_INT_TEST1 (at 0x142e0)"
        set &access:&cmd_addr %l (0x8042e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO3_INT_TEST_VAL"
      sgroup "LDO3_INT_TEST_VAL (at 0x142e1)"
        set &access:&cmd_addr %l (0x8042e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO3_TEST1"
      sgroup "LDO3_TEST1 (at 0x142e2)"
        set &access:&cmd_addr %l (0x8042e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO3_TEST2"
      sgroup "LDO3_TEST2 (at 0x142e3)"
        set &access:&cmd_addr %l (0x8042e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO3_TRIM_NUM"
      sgroup "LDO3_TRIM_NUM (at 0x142f0)"
        set &access:&cmd_addr %l (0x8042f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO3_TRIM_CTRL"
      sgroup "LDO3_TRIM_CTRL (at 0x142f1)"
        set &access:&cmd_addr %l (0x8042f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x42f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO4"
  tree "LDO4"
    tree "LDO4_REVISION1"
      sgroup "LDO4_REVISION1 (at 0x14300)"
        set &access:&cmd_addr %l (0x8043000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO4_REVISION2"
      sgroup "LDO4_REVISION2 (at 0x14301)"
        set &access:&cmd_addr %l (0x8043010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO4_REVISION3"
      sgroup "LDO4_REVISION3 (at 0x14302)"
        set &access:&cmd_addr %l (0x8043020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO4_REVISION4"
      sgroup "LDO4_REVISION4 (at 0x14303)"
        set &access:&cmd_addr %l (0x8043030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO4_PERPH_TYPE"
      sgroup "LDO4_PERPH_TYPE (at 0x14304)"
        set &access:&cmd_addr %l (0x8043040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO4_PERPH_SUBTYPE"
      sgroup "LDO4_PERPH_SUBTYPE (at 0x14305)"
        set &access:&cmd_addr %l (0x8043050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO4_STATUS1"
      sgroup "LDO4_STATUS1 (at 0x14308)"
        set &access:&cmd_addr %l (0x8043080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO4_STATUS2"
      sgroup "LDO4_STATUS2 (at 0x14309)"
        set &access:&cmd_addr %l (0x8043090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO4_STATUS3"
      sgroup "LDO4_STATUS3 (at 0x1430a)"
        set &access:&cmd_addr %l (0x80430a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x430a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO4_INT_RT_STS"
      sgroup "LDO4_INT_RT_STS (at 0x14310)"
        set &access:&cmd_addr %l (0x8043100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_SET_TYPE"
      sgroup "LDO4_INT_SET_TYPE (at 0x14311)"
        set &access:&cmd_addr %l (0x8043110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_HIGH"
      sgroup "LDO4_INT_POLARITY_HIGH (at 0x14312)"
        set &access:&cmd_addr %l (0x8043120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO4_INT_POLARITY_LOW"
      sgroup "LDO4_INT_POLARITY_LOW (at 0x14313)"
        set &access:&cmd_addr %l (0x8043130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO4_INT_LATCHED_CLR"
      sgroup "LDO4_INT_LATCHED_CLR (at 0x14314)"
        set &access:&cmd_addr %l (0x8043140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO4_INT_EN_SET"
      sgroup "LDO4_INT_EN_SET (at 0x14315)"
        set &access:&cmd_addr %l (0x8043150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_EN_CLR"
      sgroup "LDO4_INT_EN_CLR (at 0x14316)"
        set &access:&cmd_addr %l (0x8043160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO4_INT_LATCHED_STS"
      sgroup "LDO4_INT_LATCHED_STS (at 0x14318)"
        set &access:&cmd_addr %l (0x8043180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO4_INT_PENDING_STS"
      sgroup "LDO4_INT_PENDING_STS (at 0x14319)"
        set &access:&cmd_addr %l (0x8043190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO4_INT_MID_SEL"
      sgroup "LDO4_INT_MID_SEL (at 0x1431a)"
        set &access:&cmd_addr %l (0x80431a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x431a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO4_INT_PRIORITY"
      sgroup "LDO4_INT_PRIORITY (at 0x1431b)"
        set &access:&cmd_addr %l (0x80431b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x431b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO4_VOLTAGE_CTL1"
      sgroup "LDO4_VOLTAGE_CTL1 (at 0x14340)"
        set &access:&cmd_addr %l (0x8043400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_VOLTAGE_CTL2"
      sgroup "LDO4_VOLTAGE_CTL2 (at 0x14341)"
        set &access:&cmd_addr %l (0x8043410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO4_MODE_CTL2"
      sgroup "LDO4_MODE_CTL2 (at 0x14345)"
        set &access:&cmd_addr %l (0x8043450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_EN_CTL"
      sgroup "LDO4_EN_CTL (at 0x14346)"
        set &access:&cmd_addr %l (0x8043460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO4_PD_CTL"
      sgroup "LDO4_PD_CTL (at 0x14348)"
        set &access:&cmd_addr %l (0x8043480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO4_CURRENT_LIM_CTL"
      sgroup "LDO4_CURRENT_LIM_CTL (at 0x1434a)"
        set &access:&cmd_addr %l (0x80434a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x434a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO4_SOFT_START_CTL"
      sgroup "LDO4_SOFT_START_CTL (at 0x1434c)"
        set &access:&cmd_addr %l (0x80434c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x434c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO4_CONFIG_CTL"
      sgroup "LDO4_CONFIG_CTL (at 0x14352)"
        set &access:&cmd_addr %l (0x8043520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL1"
      sgroup "LDO4_LL_VOLTAGE_CTL1 (at 0x14368)"
        set &access:&cmd_addr %l (0x8043680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_LL_VOLTAGE_CTL2"
      sgroup "LDO4_LL_VOLTAGE_CTL2 (at 0x14369)"
        set &access:&cmd_addr %l (0x8043690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL1"
      sgroup "LDO4_UL_VOLTAGE_CTL1 (at 0x1436a)"
        set &access:&cmd_addr %l (0x80436a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x436a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO4_UL_VOLTAGE_CTL2"
      sgroup "LDO4_UL_VOLTAGE_CTL2 (at 0x1436b)"
        set &access:&cmd_addr %l (0x80436b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x436b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO4_SEC_ACCESS"
      sgroup "LDO4_SEC_ACCESS (at 0x143d0)"
        set &access:&cmd_addr %l (0x8043d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO4_PERPH_RESET_CTL1"
      sgroup "LDO4_PERPH_RESET_CTL1 (at 0x143d8)"
        set &access:&cmd_addr %l (0x8043d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL2"
      sgroup "LDO4_PERPH_RESET_CTL2 (at 0x143d9)"
        set &access:&cmd_addr %l (0x8043d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL3"
      sgroup "LDO4_PERPH_RESET_CTL3 (at 0x143da)"
        set &access:&cmd_addr %l (0x8043da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO4_PERPH_RESET_CTL4"
      sgroup "LDO4_PERPH_RESET_CTL4 (at 0x143db)"
        set &access:&cmd_addr %l (0x8043db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO4_INT_TEST1"
      sgroup "LDO4_INT_TEST1 (at 0x143e0)"
        set &access:&cmd_addr %l (0x8043e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO4_INT_TEST_VAL"
      sgroup "LDO4_INT_TEST_VAL (at 0x143e1)"
        set &access:&cmd_addr %l (0x8043e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO4_TEST1"
      sgroup "LDO4_TEST1 (at 0x143e2)"
        set &access:&cmd_addr %l (0x8043e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO4_TEST2"
      sgroup "LDO4_TEST2 (at 0x143e3)"
        set &access:&cmd_addr %l (0x8043e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO4_TRIM_NUM"
      sgroup "LDO4_TRIM_NUM (at 0x143f0)"
        set &access:&cmd_addr %l (0x8043f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO4_TRIM_CTRL"
      sgroup "LDO4_TRIM_CTRL (at 0x143f1)"
        set &access:&cmd_addr %l (0x8043f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x43f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO5"
  tree "LDO5"
    tree "LDO5_REVISION1"
      sgroup "LDO5_REVISION1 (at 0x14400)"
        set &access:&cmd_addr %l (0x8044000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO5_REVISION2"
      sgroup "LDO5_REVISION2 (at 0x14401)"
        set &access:&cmd_addr %l (0x8044010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO5_REVISION3"
      sgroup "LDO5_REVISION3 (at 0x14402)"
        set &access:&cmd_addr %l (0x8044020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO5_REVISION4"
      sgroup "LDO5_REVISION4 (at 0x14403)"
        set &access:&cmd_addr %l (0x8044030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO5_PERPH_TYPE"
      sgroup "LDO5_PERPH_TYPE (at 0x14404)"
        set &access:&cmd_addr %l (0x8044040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO5_PERPH_SUBTYPE"
      sgroup "LDO5_PERPH_SUBTYPE (at 0x14405)"
        set &access:&cmd_addr %l (0x8044050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO5_STATUS1"
      sgroup "LDO5_STATUS1 (at 0x14408)"
        set &access:&cmd_addr %l (0x8044080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO5_STATUS2"
      sgroup "LDO5_STATUS2 (at 0x14409)"
        set &access:&cmd_addr %l (0x8044090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO5_STATUS3"
      sgroup "LDO5_STATUS3 (at 0x1440a)"
        set &access:&cmd_addr %l (0x80440a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x440a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO5_INT_RT_STS"
      sgroup "LDO5_INT_RT_STS (at 0x14410)"
        set &access:&cmd_addr %l (0x8044100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_SET_TYPE"
      sgroup "LDO5_INT_SET_TYPE (at 0x14411)"
        set &access:&cmd_addr %l (0x8044110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_HIGH"
      sgroup "LDO5_INT_POLARITY_HIGH (at 0x14412)"
        set &access:&cmd_addr %l (0x8044120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO5_INT_POLARITY_LOW"
      sgroup "LDO5_INT_POLARITY_LOW (at 0x14413)"
        set &access:&cmd_addr %l (0x8044130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO5_INT_LATCHED_CLR"
      sgroup "LDO5_INT_LATCHED_CLR (at 0x14414)"
        set &access:&cmd_addr %l (0x8044140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO5_INT_EN_SET"
      sgroup "LDO5_INT_EN_SET (at 0x14415)"
        set &access:&cmd_addr %l (0x8044150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_EN_CLR"
      sgroup "LDO5_INT_EN_CLR (at 0x14416)"
        set &access:&cmd_addr %l (0x8044160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO5_INT_LATCHED_STS"
      sgroup "LDO5_INT_LATCHED_STS (at 0x14418)"
        set &access:&cmd_addr %l (0x8044180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO5_INT_PENDING_STS"
      sgroup "LDO5_INT_PENDING_STS (at 0x14419)"
        set &access:&cmd_addr %l (0x8044190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO5_INT_MID_SEL"
      sgroup "LDO5_INT_MID_SEL (at 0x1441a)"
        set &access:&cmd_addr %l (0x80441a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x441a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO5_INT_PRIORITY"
      sgroup "LDO5_INT_PRIORITY (at 0x1441b)"
        set &access:&cmd_addr %l (0x80441b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x441b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO5_VOLTAGE_CTL1"
      sgroup "LDO5_VOLTAGE_CTL1 (at 0x14440)"
        set &access:&cmd_addr %l (0x8044400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_VOLTAGE_CTL2"
      sgroup "LDO5_VOLTAGE_CTL2 (at 0x14441)"
        set &access:&cmd_addr %l (0x8044410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO5_MODE_CTL2"
      sgroup "LDO5_MODE_CTL2 (at 0x14445)"
        set &access:&cmd_addr %l (0x8044450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO5_EN_CTL"
      sgroup "LDO5_EN_CTL (at 0x14446)"
        set &access:&cmd_addr %l (0x8044460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO5_PD_CTL"
      sgroup "LDO5_PD_CTL (at 0x14448)"
        set &access:&cmd_addr %l (0x8044480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO5_CURRENT_LIM_CTL"
      sgroup "LDO5_CURRENT_LIM_CTL (at 0x1444a)"
        set &access:&cmd_addr %l (0x80444a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x444a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO5_SOFT_START_CTL"
      sgroup "LDO5_SOFT_START_CTL (at 0x1444c)"
        set &access:&cmd_addr %l (0x80444c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x444c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO5_CONFIG_CTL"
      sgroup "LDO5_CONFIG_CTL (at 0x14452)"
        set &access:&cmd_addr %l (0x8044520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO5_LL_VOLTAGE_CTL1"
      sgroup "LDO5_LL_VOLTAGE_CTL1 (at 0x14468)"
        set &access:&cmd_addr %l (0x8044680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_LL_VOLTAGE_CTL2"
      sgroup "LDO5_LL_VOLTAGE_CTL2 (at 0x14469)"
        set &access:&cmd_addr %l (0x8044690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO5_UL_VOLTAGE_CTL1"
      sgroup "LDO5_UL_VOLTAGE_CTL1 (at 0x1446a)"
        set &access:&cmd_addr %l (0x80446a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x446a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO5_UL_VOLTAGE_CTL2"
      sgroup "LDO5_UL_VOLTAGE_CTL2 (at 0x1446b)"
        set &access:&cmd_addr %l (0x80446b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x446b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO5_SEC_ACCESS"
      sgroup "LDO5_SEC_ACCESS (at 0x144d0)"
        set &access:&cmd_addr %l (0x8044d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO5_PERPH_RESET_CTL1"
      sgroup "LDO5_PERPH_RESET_CTL1 (at 0x144d8)"
        set &access:&cmd_addr %l (0x8044d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL2"
      sgroup "LDO5_PERPH_RESET_CTL2 (at 0x144d9)"
        set &access:&cmd_addr %l (0x8044d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL3"
      sgroup "LDO5_PERPH_RESET_CTL3 (at 0x144da)"
        set &access:&cmd_addr %l (0x8044da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO5_PERPH_RESET_CTL4"
      sgroup "LDO5_PERPH_RESET_CTL4 (at 0x144db)"
        set &access:&cmd_addr %l (0x8044db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO5_INT_TEST1"
      sgroup "LDO5_INT_TEST1 (at 0x144e0)"
        set &access:&cmd_addr %l (0x8044e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO5_INT_TEST_VAL"
      sgroup "LDO5_INT_TEST_VAL (at 0x144e1)"
        set &access:&cmd_addr %l (0x8044e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO5_TEST1"
      sgroup "LDO5_TEST1 (at 0x144e2)"
        set &access:&cmd_addr %l (0x8044e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO5_TEST2"
      sgroup "LDO5_TEST2 (at 0x144e3)"
        set &access:&cmd_addr %l (0x8044e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO5_TRIM_NUM"
      sgroup "LDO5_TRIM_NUM (at 0x144f0)"
        set &access:&cmd_addr %l (0x8044f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO5_TRIM_CTRL"
      sgroup "LDO5_TRIM_CTRL (at 0x144f1)"
        set &access:&cmd_addr %l (0x8044f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x44f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO6"
  tree "LDO6"
    tree "LDO6_REVISION1"
      sgroup "LDO6_REVISION1 (at 0x14500)"
        set &access:&cmd_addr %l (0x8045000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO6_REVISION2"
      sgroup "LDO6_REVISION2 (at 0x14501)"
        set &access:&cmd_addr %l (0x8045010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO6_REVISION3"
      sgroup "LDO6_REVISION3 (at 0x14502)"
        set &access:&cmd_addr %l (0x8045020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO6_REVISION4"
      sgroup "LDO6_REVISION4 (at 0x14503)"
        set &access:&cmd_addr %l (0x8045030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO6_PERPH_TYPE"
      sgroup "LDO6_PERPH_TYPE (at 0x14504)"
        set &access:&cmd_addr %l (0x8045040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO6_PERPH_SUBTYPE"
      sgroup "LDO6_PERPH_SUBTYPE (at 0x14505)"
        set &access:&cmd_addr %l (0x8045050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO6_STATUS1"
      sgroup "LDO6_STATUS1 (at 0x14508)"
        set &access:&cmd_addr %l (0x8045080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO6_STATUS2"
      sgroup "LDO6_STATUS2 (at 0x14509)"
        set &access:&cmd_addr %l (0x8045090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO6_STATUS3"
      sgroup "LDO6_STATUS3 (at 0x1450a)"
        set &access:&cmd_addr %l (0x80450a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x450a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO6_INT_RT_STS"
      sgroup "LDO6_INT_RT_STS (at 0x14510)"
        set &access:&cmd_addr %l (0x8045100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_SET_TYPE"
      sgroup "LDO6_INT_SET_TYPE (at 0x14511)"
        set &access:&cmd_addr %l (0x8045110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_HIGH"
      sgroup "LDO6_INT_POLARITY_HIGH (at 0x14512)"
        set &access:&cmd_addr %l (0x8045120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO6_INT_POLARITY_LOW"
      sgroup "LDO6_INT_POLARITY_LOW (at 0x14513)"
        set &access:&cmd_addr %l (0x8045130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO6_INT_LATCHED_CLR"
      sgroup "LDO6_INT_LATCHED_CLR (at 0x14514)"
        set &access:&cmd_addr %l (0x8045140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO6_INT_EN_SET"
      sgroup "LDO6_INT_EN_SET (at 0x14515)"
        set &access:&cmd_addr %l (0x8045150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_EN_CLR"
      sgroup "LDO6_INT_EN_CLR (at 0x14516)"
        set &access:&cmd_addr %l (0x8045160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO6_INT_LATCHED_STS"
      sgroup "LDO6_INT_LATCHED_STS (at 0x14518)"
        set &access:&cmd_addr %l (0x8045180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO6_INT_PENDING_STS"
      sgroup "LDO6_INT_PENDING_STS (at 0x14519)"
        set &access:&cmd_addr %l (0x8045190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO6_INT_MID_SEL"
      sgroup "LDO6_INT_MID_SEL (at 0x1451a)"
        set &access:&cmd_addr %l (0x80451a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x451a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO6_INT_PRIORITY"
      sgroup "LDO6_INT_PRIORITY (at 0x1451b)"
        set &access:&cmd_addr %l (0x80451b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x451b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO6_VOLTAGE_CTL1"
      sgroup "LDO6_VOLTAGE_CTL1 (at 0x14540)"
        set &access:&cmd_addr %l (0x8045400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_VOLTAGE_CTL2"
      sgroup "LDO6_VOLTAGE_CTL2 (at 0x14541)"
        set &access:&cmd_addr %l (0x8045410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO6_MODE_CTL2"
      sgroup "LDO6_MODE_CTL2 (at 0x14545)"
        set &access:&cmd_addr %l (0x8045450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_EN_CTL"
      sgroup "LDO6_EN_CTL (at 0x14546)"
        set &access:&cmd_addr %l (0x8045460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO6_PD_CTL"
      sgroup "LDO6_PD_CTL (at 0x14548)"
        set &access:&cmd_addr %l (0x8045480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO6_CURRENT_LIM_CTL"
      sgroup "LDO6_CURRENT_LIM_CTL (at 0x1454a)"
        set &access:&cmd_addr %l (0x80454a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x454a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO6_SOFT_START_CTL"
      sgroup "LDO6_SOFT_START_CTL (at 0x1454c)"
        set &access:&cmd_addr %l (0x80454c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x454c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO6_CONFIG_CTL"
      sgroup "LDO6_CONFIG_CTL (at 0x14552)"
        set &access:&cmd_addr %l (0x8045520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL1"
      sgroup "LDO6_LL_VOLTAGE_CTL1 (at 0x14568)"
        set &access:&cmd_addr %l (0x8045680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_LL_VOLTAGE_CTL2"
      sgroup "LDO6_LL_VOLTAGE_CTL2 (at 0x14569)"
        set &access:&cmd_addr %l (0x8045690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL1"
      sgroup "LDO6_UL_VOLTAGE_CTL1 (at 0x1456a)"
        set &access:&cmd_addr %l (0x80456a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x456a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO6_UL_VOLTAGE_CTL2"
      sgroup "LDO6_UL_VOLTAGE_CTL2 (at 0x1456b)"
        set &access:&cmd_addr %l (0x80456b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x456b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO6_SEC_ACCESS"
      sgroup "LDO6_SEC_ACCESS (at 0x145d0)"
        set &access:&cmd_addr %l (0x8045d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO6_PERPH_RESET_CTL1"
      sgroup "LDO6_PERPH_RESET_CTL1 (at 0x145d8)"
        set &access:&cmd_addr %l (0x8045d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL2"
      sgroup "LDO6_PERPH_RESET_CTL2 (at 0x145d9)"
        set &access:&cmd_addr %l (0x8045d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL3"
      sgroup "LDO6_PERPH_RESET_CTL3 (at 0x145da)"
        set &access:&cmd_addr %l (0x8045da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO6_PERPH_RESET_CTL4"
      sgroup "LDO6_PERPH_RESET_CTL4 (at 0x145db)"
        set &access:&cmd_addr %l (0x8045db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO6_INT_TEST1"
      sgroup "LDO6_INT_TEST1 (at 0x145e0)"
        set &access:&cmd_addr %l (0x8045e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO6_INT_TEST_VAL"
      sgroup "LDO6_INT_TEST_VAL (at 0x145e1)"
        set &access:&cmd_addr %l (0x8045e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO6_TEST1"
      sgroup "LDO6_TEST1 (at 0x145e2)"
        set &access:&cmd_addr %l (0x8045e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO6_TEST2"
      sgroup "LDO6_TEST2 (at 0x145e3)"
        set &access:&cmd_addr %l (0x8045e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO6_TRIM_NUM"
      sgroup "LDO6_TRIM_NUM (at 0x145f0)"
        set &access:&cmd_addr %l (0x8045f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO6_TRIM_CTRL"
      sgroup "LDO6_TRIM_CTRL (at 0x145f1)"
        set &access:&cmd_addr %l (0x8045f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x45f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO7"
  tree "LDO7"
    tree "LDO7_REVISION1"
      sgroup "LDO7_REVISION1 (at 0x14600)"
        set &access:&cmd_addr %l (0x8046000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO7_REVISION2"
      sgroup "LDO7_REVISION2 (at 0x14601)"
        set &access:&cmd_addr %l (0x8046010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO7_REVISION3"
      sgroup "LDO7_REVISION3 (at 0x14602)"
        set &access:&cmd_addr %l (0x8046020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO7_REVISION4"
      sgroup "LDO7_REVISION4 (at 0x14603)"
        set &access:&cmd_addr %l (0x8046030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO7_PERPH_TYPE"
      sgroup "LDO7_PERPH_TYPE (at 0x14604)"
        set &access:&cmd_addr %l (0x8046040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO7_PERPH_SUBTYPE"
      sgroup "LDO7_PERPH_SUBTYPE (at 0x14605)"
        set &access:&cmd_addr %l (0x8046050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO7_STATUS1"
      sgroup "LDO7_STATUS1 (at 0x14608)"
        set &access:&cmd_addr %l (0x8046080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO7_STATUS2"
      sgroup "LDO7_STATUS2 (at 0x14609)"
        set &access:&cmd_addr %l (0x8046090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO7_STATUS3"
      sgroup "LDO7_STATUS3 (at 0x1460a)"
        set &access:&cmd_addr %l (0x80460a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x460a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO7_INT_RT_STS"
      sgroup "LDO7_INT_RT_STS (at 0x14610)"
        set &access:&cmd_addr %l (0x8046100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_SET_TYPE"
      sgroup "LDO7_INT_SET_TYPE (at 0x14611)"
        set &access:&cmd_addr %l (0x8046110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_HIGH"
      sgroup "LDO7_INT_POLARITY_HIGH (at 0x14612)"
        set &access:&cmd_addr %l (0x8046120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO7_INT_POLARITY_LOW"
      sgroup "LDO7_INT_POLARITY_LOW (at 0x14613)"
        set &access:&cmd_addr %l (0x8046130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO7_INT_LATCHED_CLR"
      sgroup "LDO7_INT_LATCHED_CLR (at 0x14614)"
        set &access:&cmd_addr %l (0x8046140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO7_INT_EN_SET"
      sgroup "LDO7_INT_EN_SET (at 0x14615)"
        set &access:&cmd_addr %l (0x8046150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_EN_CLR"
      sgroup "LDO7_INT_EN_CLR (at 0x14616)"
        set &access:&cmd_addr %l (0x8046160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO7_INT_LATCHED_STS"
      sgroup "LDO7_INT_LATCHED_STS (at 0x14618)"
        set &access:&cmd_addr %l (0x8046180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO7_INT_PENDING_STS"
      sgroup "LDO7_INT_PENDING_STS (at 0x14619)"
        set &access:&cmd_addr %l (0x8046190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO7_INT_MID_SEL"
      sgroup "LDO7_INT_MID_SEL (at 0x1461a)"
        set &access:&cmd_addr %l (0x80461a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x461a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO7_INT_PRIORITY"
      sgroup "LDO7_INT_PRIORITY (at 0x1461b)"
        set &access:&cmd_addr %l (0x80461b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x461b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO7_VOLTAGE_CTL1"
      sgroup "LDO7_VOLTAGE_CTL1 (at 0x14640)"
        set &access:&cmd_addr %l (0x8046400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_VOLTAGE_CTL2"
      sgroup "LDO7_VOLTAGE_CTL2 (at 0x14641)"
        set &access:&cmd_addr %l (0x8046410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO7_MODE_CTL2"
      sgroup "LDO7_MODE_CTL2 (at 0x14645)"
        set &access:&cmd_addr %l (0x8046450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO7_EN_CTL"
      sgroup "LDO7_EN_CTL (at 0x14646)"
        set &access:&cmd_addr %l (0x8046460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO7_PD_CTL"
      sgroup "LDO7_PD_CTL (at 0x14648)"
        set &access:&cmd_addr %l (0x8046480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO7_CURRENT_LIM_CTL"
      sgroup "LDO7_CURRENT_LIM_CTL (at 0x1464a)"
        set &access:&cmd_addr %l (0x80464a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x464a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO7_SOFT_START_CTL"
      sgroup "LDO7_SOFT_START_CTL (at 0x1464c)"
        set &access:&cmd_addr %l (0x80464c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x464c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO7_CONFIG_CTL"
      sgroup "LDO7_CONFIG_CTL (at 0x14652)"
        set &access:&cmd_addr %l (0x8046520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO7_LL_VOLTAGE_CTL1"
      sgroup "LDO7_LL_VOLTAGE_CTL1 (at 0x14668)"
        set &access:&cmd_addr %l (0x8046680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_LL_VOLTAGE_CTL2"
      sgroup "LDO7_LL_VOLTAGE_CTL2 (at 0x14669)"
        set &access:&cmd_addr %l (0x8046690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO7_UL_VOLTAGE_CTL1"
      sgroup "LDO7_UL_VOLTAGE_CTL1 (at 0x1466a)"
        set &access:&cmd_addr %l (0x80466a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x466a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO7_UL_VOLTAGE_CTL2"
      sgroup "LDO7_UL_VOLTAGE_CTL2 (at 0x1466b)"
        set &access:&cmd_addr %l (0x80466b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x466b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO7_SEC_ACCESS"
      sgroup "LDO7_SEC_ACCESS (at 0x146d0)"
        set &access:&cmd_addr %l (0x8046d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO7_PERPH_RESET_CTL1"
      sgroup "LDO7_PERPH_RESET_CTL1 (at 0x146d8)"
        set &access:&cmd_addr %l (0x8046d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL2"
      sgroup "LDO7_PERPH_RESET_CTL2 (at 0x146d9)"
        set &access:&cmd_addr %l (0x8046d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL3"
      sgroup "LDO7_PERPH_RESET_CTL3 (at 0x146da)"
        set &access:&cmd_addr %l (0x8046da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO7_PERPH_RESET_CTL4"
      sgroup "LDO7_PERPH_RESET_CTL4 (at 0x146db)"
        set &access:&cmd_addr %l (0x8046db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO7_INT_TEST1"
      sgroup "LDO7_INT_TEST1 (at 0x146e0)"
        set &access:&cmd_addr %l (0x8046e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO7_INT_TEST_VAL"
      sgroup "LDO7_INT_TEST_VAL (at 0x146e1)"
        set &access:&cmd_addr %l (0x8046e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO7_TEST1"
      sgroup "LDO7_TEST1 (at 0x146e2)"
        set &access:&cmd_addr %l (0x8046e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO7_TEST2"
      sgroup "LDO7_TEST2 (at 0x146e3)"
        set &access:&cmd_addr %l (0x8046e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO7_TRIM_NUM"
      sgroup "LDO7_TRIM_NUM (at 0x146f0)"
        set &access:&cmd_addr %l (0x8046f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO7_TRIM_CTRL"
      sgroup "LDO7_TRIM_CTRL (at 0x146f1)"
        set &access:&cmd_addr %l (0x8046f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x46f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO8"
  tree "LDO8"
    tree "LDO8_REVISION1"
      sgroup "LDO8_REVISION1 (at 0x14700)"
        set &access:&cmd_addr %l (0x8047000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO8_REVISION2"
      sgroup "LDO8_REVISION2 (at 0x14701)"
        set &access:&cmd_addr %l (0x8047010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO8_REVISION3"
      sgroup "LDO8_REVISION3 (at 0x14702)"
        set &access:&cmd_addr %l (0x8047020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO8_REVISION4"
      sgroup "LDO8_REVISION4 (at 0x14703)"
        set &access:&cmd_addr %l (0x8047030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO8_PERPH_TYPE"
      sgroup "LDO8_PERPH_TYPE (at 0x14704)"
        set &access:&cmd_addr %l (0x8047040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO8_PERPH_SUBTYPE"
      sgroup "LDO8_PERPH_SUBTYPE (at 0x14705)"
        set &access:&cmd_addr %l (0x8047050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO8_STATUS1"
      sgroup "LDO8_STATUS1 (at 0x14708)"
        set &access:&cmd_addr %l (0x8047080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO8_STATUS2"
      sgroup "LDO8_STATUS2 (at 0x14709)"
        set &access:&cmd_addr %l (0x8047090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO8_STATUS3"
      sgroup "LDO8_STATUS3 (at 0x1470a)"
        set &access:&cmd_addr %l (0x80470a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x470a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO8_INT_RT_STS"
      sgroup "LDO8_INT_RT_STS (at 0x14710)"
        set &access:&cmd_addr %l (0x8047100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_SET_TYPE"
      sgroup "LDO8_INT_SET_TYPE (at 0x14711)"
        set &access:&cmd_addr %l (0x8047110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_HIGH"
      sgroup "LDO8_INT_POLARITY_HIGH (at 0x14712)"
        set &access:&cmd_addr %l (0x8047120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO8_INT_POLARITY_LOW"
      sgroup "LDO8_INT_POLARITY_LOW (at 0x14713)"
        set &access:&cmd_addr %l (0x8047130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO8_INT_LATCHED_CLR"
      sgroup "LDO8_INT_LATCHED_CLR (at 0x14714)"
        set &access:&cmd_addr %l (0x8047140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO8_INT_EN_SET"
      sgroup "LDO8_INT_EN_SET (at 0x14715)"
        set &access:&cmd_addr %l (0x8047150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_EN_CLR"
      sgroup "LDO8_INT_EN_CLR (at 0x14716)"
        set &access:&cmd_addr %l (0x8047160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO8_INT_LATCHED_STS"
      sgroup "LDO8_INT_LATCHED_STS (at 0x14718)"
        set &access:&cmd_addr %l (0x8047180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO8_INT_PENDING_STS"
      sgroup "LDO8_INT_PENDING_STS (at 0x14719)"
        set &access:&cmd_addr %l (0x8047190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO8_INT_MID_SEL"
      sgroup "LDO8_INT_MID_SEL (at 0x1471a)"
        set &access:&cmd_addr %l (0x80471a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x471a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO8_INT_PRIORITY"
      sgroup "LDO8_INT_PRIORITY (at 0x1471b)"
        set &access:&cmd_addr %l (0x80471b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x471b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO8_VOLTAGE_CTL1"
      sgroup "LDO8_VOLTAGE_CTL1 (at 0x14740)"
        set &access:&cmd_addr %l (0x8047400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_VOLTAGE_CTL2"
      sgroup "LDO8_VOLTAGE_CTL2 (at 0x14741)"
        set &access:&cmd_addr %l (0x8047410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO8_MODE_CTL2"
      sgroup "LDO8_MODE_CTL2 (at 0x14745)"
        set &access:&cmd_addr %l (0x8047450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_EN_CTL"
      sgroup "LDO8_EN_CTL (at 0x14746)"
        set &access:&cmd_addr %l (0x8047460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO8_PD_CTL"
      sgroup "LDO8_PD_CTL (at 0x14748)"
        set &access:&cmd_addr %l (0x8047480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO8_CURRENT_LIM_CTL"
      sgroup "LDO8_CURRENT_LIM_CTL (at 0x1474a)"
        set &access:&cmd_addr %l (0x80474a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x474a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO8_SOFT_START_CTL"
      sgroup "LDO8_SOFT_START_CTL (at 0x1474c)"
        set &access:&cmd_addr %l (0x80474c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x474c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO8_CONFIG_CTL"
      sgroup "LDO8_CONFIG_CTL (at 0x14752)"
        set &access:&cmd_addr %l (0x8047520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL1"
      sgroup "LDO8_LL_VOLTAGE_CTL1 (at 0x14768)"
        set &access:&cmd_addr %l (0x8047680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_LL_VOLTAGE_CTL2"
      sgroup "LDO8_LL_VOLTAGE_CTL2 (at 0x14769)"
        set &access:&cmd_addr %l (0x8047690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL1"
      sgroup "LDO8_UL_VOLTAGE_CTL1 (at 0x1476a)"
        set &access:&cmd_addr %l (0x80476a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x476a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO8_UL_VOLTAGE_CTL2"
      sgroup "LDO8_UL_VOLTAGE_CTL2 (at 0x1476b)"
        set &access:&cmd_addr %l (0x80476b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x476b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO8_SEC_ACCESS"
      sgroup "LDO8_SEC_ACCESS (at 0x147d0)"
        set &access:&cmd_addr %l (0x8047d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO8_PERPH_RESET_CTL1"
      sgroup "LDO8_PERPH_RESET_CTL1 (at 0x147d8)"
        set &access:&cmd_addr %l (0x8047d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL2"
      sgroup "LDO8_PERPH_RESET_CTL2 (at 0x147d9)"
        set &access:&cmd_addr %l (0x8047d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL3"
      sgroup "LDO8_PERPH_RESET_CTL3 (at 0x147da)"
        set &access:&cmd_addr %l (0x8047da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO8_PERPH_RESET_CTL4"
      sgroup "LDO8_PERPH_RESET_CTL4 (at 0x147db)"
        set &access:&cmd_addr %l (0x8047db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO8_INT_TEST1"
      sgroup "LDO8_INT_TEST1 (at 0x147e0)"
        set &access:&cmd_addr %l (0x8047e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO8_INT_TEST_VAL"
      sgroup "LDO8_INT_TEST_VAL (at 0x147e1)"
        set &access:&cmd_addr %l (0x8047e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO8_TEST1"
      sgroup "LDO8_TEST1 (at 0x147e2)"
        set &access:&cmd_addr %l (0x8047e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO8_TEST2"
      sgroup "LDO8_TEST2 (at 0x147e3)"
        set &access:&cmd_addr %l (0x8047e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO8_TRIM_NUM"
      sgroup "LDO8_TRIM_NUM (at 0x147f0)"
        set &access:&cmd_addr %l (0x8047f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO8_TRIM_CTRL"
      sgroup "LDO8_TRIM_CTRL (at 0x147f1)"
        set &access:&cmd_addr %l (0x8047f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x47f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO9"
  tree "LDO9"
    tree "LDO9_REVISION1"
      sgroup "LDO9_REVISION1 (at 0x14800)"
        set &access:&cmd_addr %l (0x8048000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO9_REVISION2"
      sgroup "LDO9_REVISION2 (at 0x14801)"
        set &access:&cmd_addr %l (0x8048010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO9_REVISION3"
      sgroup "LDO9_REVISION3 (at 0x14802)"
        set &access:&cmd_addr %l (0x8048020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO9_REVISION4"
      sgroup "LDO9_REVISION4 (at 0x14803)"
        set &access:&cmd_addr %l (0x8048030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO9_PERPH_TYPE"
      sgroup "LDO9_PERPH_TYPE (at 0x14804)"
        set &access:&cmd_addr %l (0x8048040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO9_PERPH_SUBTYPE"
      sgroup "LDO9_PERPH_SUBTYPE (at 0x14805)"
        set &access:&cmd_addr %l (0x8048050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO9_STATUS1"
      sgroup "LDO9_STATUS1 (at 0x14808)"
        set &access:&cmd_addr %l (0x8048080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (LDO_VOLTAGE_LOW),1 (LDO_VOLTAGE_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0 (UPPER_LIMIT_SETTING_OK),1 (UPPER_LIMIT_SETTING_ERR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_OVERLIMIT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NOT_NPM_OR_VOLTAGE_NOT_OK),1 (NPM_VOLTAGE_OK)"
    tree.end
    tree "LDO9_STATUS2"
      sgroup "LDO9_STATUS2 (at 0x14809)"
        set &access:&cmd_addr %l (0x8048090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0 (SOFTSTART_NOT_DONE),1 (SOFTSTART_DONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0 (NO_OVER_CURRENT_DETECTED),1 (OVER_CURRENT_DETECTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0 (LDO_OFF),1 (LDO_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0 (LDO_RANGE_NOT_EXTENDED),1 (LDO_RANGE_EXTENDED)"
    tree.end
    tree "LDO9_STATUS3"
      sgroup "LDO9_STATUS3 (at 0x1480a)"
        set &access:&cmd_addr %l (0x80480a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x480a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0 (LDO_RANGE_NOT_SELECTED),1 (LDO_RANGE_SELECTED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO9_INT_RT_STS"
      sgroup "LDO9_INT_RT_STS (at 0x14810)"
        set &access:&cmd_addr %l (0x8048100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (LDO_ENABLE_ERR),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_SET_TYPE"
      sgroup "LDO9_INT_SET_TYPE (at 0x14811)"
        set &access:&cmd_addr %l (0x8048110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LIMIT_ERROR_EDGE_TRIGGERED),1 (LIMIT_ERROR_LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (VREG_OK_EDGE_TRIGGERED),1 (VREG_OK_LEVEL_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_HIGH"
      sgroup "LDO9_INT_POLARITY_HIGH (at 0x14812)"
        set &access:&cmd_addr %l (0x8048120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (LIMIT_ERROR_HIGH_DISABLED),1 (LIMIT_ERROR_HIGH_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (VREG_OK_LOW_DISABLED),1 (VREG_OK_LOW_TRIGGERED)"
    tree.end
    tree "LDO9_INT_POLARITY_LOW"
      sgroup "LDO9_INT_POLARITY_LOW (at 0x14813)"
        set &access:&cmd_addr %l (0x8048130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LIMIT_ERROR_FALLING_TRIGGERED),1 (LIMIT_ERROR_RISING_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (VREG_OK_FALLING_TRIGGERED),1 (VREG_OK_RISING_TRIGGERED)"
    tree.end
    tree "LDO9_INT_LATCHED_CLR"
      sgroup "LDO9_INT_LATCHED_CLR (at 0x14814)"
        set &access:&cmd_addr %l (0x8048140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0 (LIMIT_ERROR_NOT_REARM),1 (LIMIT_ERROR_REARM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0 (VREG_OK_ERROR_NOT_REARM),1 (VREG_OK_ERROR_REARM)"
    tree.end
    tree "LDO9_INT_EN_SET"
      sgroup "LDO9_INT_EN_SET (at 0x14815)"
        set &access:&cmd_addr %l (0x8048150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_EN_CLR"
      sgroup "LDO9_INT_EN_CLR (at 0x14816)"
        set &access:&cmd_addr %l (0x8048160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (LIMIT_ERROR_DISABLED),1 (LIMIT_ERROR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (VREG_OK_ERROR_DISABLED),1 (VREG_OK_ERROR_ENABLED)"
    tree.end
    tree "LDO9_INT_LATCHED_STS"
      sgroup "LDO9_INT_LATCHED_STS (at 0x14818)"
        set &access:&cmd_addr %l (0x8048180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (LDO_VOLTAGE_OK),1 (LDO_VOLTAGE_LOW)"
    tree.end
    tree "LDO9_INT_PENDING_STS"
      sgroup "LDO9_INT_PENDING_STS (at 0x14819)"
        set &access:&cmd_addr %l (0x8048190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (VOLTAGE_LEVEL_SETTING_OK),1 (VOLTAGE_LEVEL_SETTING_UNDERLIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (LDO_ENABLE_FALSE),1 (LDO_ENABLE_SUCCESS)"
    tree.end
    tree "LDO9_INT_MID_SEL"
      sgroup "LDO9_INT_MID_SEL (at 0x1481a)"
        set &access:&cmd_addr %l (0x80481a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x481a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO9_INT_PRIORITY"
      sgroup "LDO9_INT_PRIORITY (at 0x1481b)"
        set &access:&cmd_addr %l (0x80481b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x481b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO9_VOLTAGE_CTL1"
      sgroup "LDO9_VOLTAGE_CTL1 (at 0x14840)"
        set &access:&cmd_addr %l (0x8048400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_VOLTAGE_CTL2"
      sgroup "LDO9_VOLTAGE_CTL2 (at 0x14841)"
        set &access:&cmd_addr %l (0x8048410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO9_MODE_CTL2"
      sgroup "LDO9_MODE_CTL2 (at 0x14845)"
        set &access:&cmd_addr %l (0x8048450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (FORCED_NPM_FALSE),1 (FORCED_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0 (BYPASS_ACT_FALSE),1 (BYPASS_ACT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0 (NPM_FOLLOW_HW_EN3_FALSE),1 (NPM_FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0 (NPM_FOLLOW_HW_EN2_FALSE),1 (NPM_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0 (NPM_FOLLOW_HW_EN1_FALSE),1 (NPM_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0 (NPM_FOLLOW_HW_EN0_FALSE),1 (NPM_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_EN_CTL"
      sgroup "LDO9_EN_CTL (at 0x14846)"
        set &access:&cmd_addr %l (0x8048460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0 (FOLLOW_HW_EN3_FALSE),1 (FOLLOW_HW_EN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0 (FOLLOW_HW_EN2_FALSE),1 (FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0 (FOLLOW_HW_EN1_FALSE),1 (FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0 (FOLLOW_HW_EN0_FALSE),1 (FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO9_PD_CTL"
      sgroup "LDO9_PD_CTL (at 0x14848)"
        set &access:&cmd_addr %l (0x8048480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "LDO9_CURRENT_LIM_CTL"
      sgroup "LDO9_CURRENT_LIM_CTL (at 0x1484a)"
        set &access:&cmd_addr %l (0x80484a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x484a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_DISABLED),1 (CURRENT_LIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0 (CURRENT_LIM_TESTMODE_DISABLED),1 (CURRENT_LIM_TESTMODE_ENABLED)"
    tree.end
    tree "LDO9_SOFT_START_CTL"
      sgroup "LDO9_SOFT_START_CTL (at 0x1484c)"
        set &access:&cmd_addr %l (0x80484c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x484c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0 (SOFT_START_DISABLED),1 (SOFT_START_ENABLED)"
    tree.end
    tree "LDO9_CONFIG_CTL"
      sgroup "LDO9_CONFIG_CTL (at 0x14852)"
        set &access:&cmd_addr %l (0x8048520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0 (CLAMP_DISABLED),1 (CLAMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0 (CASCADE_FALSE),1 (CASCADE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0 (ACT_BYPASS_BUFF_DISABLED),1 (ACT_BYPASS_BUFF_ENABLED)"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL1"
      sgroup "LDO9_LL_VOLTAGE_CTL1 (at 0x14868)"
        set &access:&cmd_addr %l (0x8048680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_LL_VOLTAGE_CTL2"
      sgroup "LDO9_LL_VOLTAGE_CTL2 (at 0x14869)"
        set &access:&cmd_addr %l (0x8048690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL1"
      sgroup "LDO9_UL_VOLTAGE_CTL1 (at 0x1486a)"
        set &access:&cmd_addr %l (0x80486a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x486a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO9_UL_VOLTAGE_CTL2"
      sgroup "LDO9_UL_VOLTAGE_CTL2 (at 0x1486b)"
        set &access:&cmd_addr %l (0x80486b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x486b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO9_SEC_ACCESS"
      sgroup "LDO9_SEC_ACCESS (at 0x148d0)"
        set &access:&cmd_addr %l (0x8048d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO9_PERPH_RESET_CTL1"
      sgroup "LDO9_PERPH_RESET_CTL1 (at 0x148d8)"
        set &access:&cmd_addr %l (0x8048d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL2"
      sgroup "LDO9_PERPH_RESET_CTL2 (at 0x148d9)"
        set &access:&cmd_addr %l (0x8048d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL3"
      sgroup "LDO9_PERPH_RESET_CTL3 (at 0x148da)"
        set &access:&cmd_addr %l (0x8048da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO9_PERPH_RESET_CTL4"
      sgroup "LDO9_PERPH_RESET_CTL4 (at 0x148db)"
        set &access:&cmd_addr %l (0x8048db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO9_INT_TEST1"
      sgroup "LDO9_INT_TEST1 (at 0x148e0)"
        set &access:&cmd_addr %l (0x8048e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO9_INT_TEST_VAL"
      sgroup "LDO9_INT_TEST_VAL (at 0x148e1)"
        set &access:&cmd_addr %l (0x8048e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0 (LIMIT_ERROR_TEST_VAL_0),1 (LIMIT_ERROR_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (VREG_OK_TEST_VAL_0),1 (VREG_OK_TEST_VAL_1)"
    tree.end
    tree "LDO9_TEST1"
      sgroup "LDO9_TEST1 (at 0x148e2)"
        set &access:&cmd_addr %l (0x8048e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO9_TEST2"
      sgroup "LDO9_TEST2 (at 0x148e3)"
        set &access:&cmd_addr %l (0x8048e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO9_TRIM_NUM"
      sgroup "LDO9_TRIM_NUM (at 0x148f0)"
        set &access:&cmd_addr %l (0x8048f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO9_TRIM_CTRL"
      sgroup "LDO9_TRIM_CTRL (at 0x148f1)"
        set &access:&cmd_addr %l (0x8048f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x48f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LPG_CHAN1"
  tree "LPG_CHAN1"
    tree "LPG_CHAN1_REVISION1"
      sgroup "LPG_CHAN1_REVISION1 (at 0x1b100)"
        set &access:&cmd_addr %l (0x80b1000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN1_REVISION2"
      sgroup "LPG_CHAN1_REVISION2 (at 0x1b101)"
        set &access:&cmd_addr %l (0x80b1010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN1_PERPH_TYPE"
      sgroup "LPG_CHAN1_PERPH_TYPE (at 0x1b104)"
        set &access:&cmd_addr %l (0x80b1040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN1_PERPH_SUBTYPE"
      sgroup "LPG_CHAN1_PERPH_SUBTYPE (at 0x1b105)"
        set &access:&cmd_addr %l (0x80b1050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN1_INT_RT_STS"
      sgroup "LPG_CHAN1_INT_RT_STS (at 0x1b110)"
        set &access:&cmd_addr %l (0x80b1100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_SET_TYPE"
      sgroup "LPG_CHAN1_INT_SET_TYPE (at 0x1b111)"
        set &access:&cmd_addr %l (0x80b1110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN1_INT_POLARITY_HIGH (at 0x1b112)"
        set &access:&cmd_addr %l (0x80b1120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_LOW"
      sgroup "LPG_CHAN1_INT_POLARITY_LOW (at 0x1b113)"
        set &access:&cmd_addr %l (0x80b1130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_CLR"
      sgroup "LPG_CHAN1_INT_LATCHED_CLR (at 0x1b114)"
        set &access:&cmd_addr %l (0x80b1140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_EN_SET"
      sgroup "LPG_CHAN1_INT_EN_SET (at 0x1b115)"
        set &access:&cmd_addr %l (0x80b1150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_EN_CLR"
      sgroup "LPG_CHAN1_INT_EN_CLR (at 0x1b116)"
        set &access:&cmd_addr %l (0x80b1160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_STS"
      sgroup "LPG_CHAN1_INT_LATCHED_STS (at 0x1b118)"
        set &access:&cmd_addr %l (0x80b1180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN1_INT_PENDING_STS"
      sgroup "LPG_CHAN1_INT_PENDING_STS (at 0x1b119)"
        set &access:&cmd_addr %l (0x80b1190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN1_INT_MID_SEL"
      sgroup "LPG_CHAN1_INT_MID_SEL (at 0x1b11a)"
        set &access:&cmd_addr %l (0x80b11a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb11a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN1_INT_PRIORITY"
      sgroup "LPG_CHAN1_INT_PRIORITY (at 0x1b11b)"
        set &access:&cmd_addr %l (0x80b11b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb11b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN1_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN1_LPG_PATTERN_CONFIG (at 0x1b140)"
        set &access:&cmd_addr %l (0x80b1400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN1_LPG_PWM_SIZE_CLK (at 0x1b141)"
        set &access:&cmd_addr %l (0x80b1410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b142)"
        set &access:&cmd_addr %l (0x80b1420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN1_LPG_PWM_TYPE_CONFIG (at 0x1b143)"
        set &access:&cmd_addr %l (0x80b1430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_LSB"
      sgroup "LPG_CHAN1_PWM_VALUE_LSB (at 0x1b144)"
        set &access:&cmd_addr %l (0x80b1440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_MSB"
      sgroup "LPG_CHAN1_PWM_VALUE_MSB (at 0x1b145)"
        set &access:&cmd_addr %l (0x80b1450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN1_ENABLE_CONTROL"
      sgroup "LPG_CHAN1_ENABLE_CONTROL (at 0x1b146)"
        set &access:&cmd_addr %l (0x80b1460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN1_RAMP_STEP_DURATION_LSB (at 0x1b150)"
        set &access:&cmd_addr %l (0x80b1500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN1_RAMP_STEP_DURATION_MSB (at 0x1b151)"
        set &access:&cmd_addr %l (0x80b1510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN1_PAUSE_HI_MULTIPLIER_LSB"
      sgroup "LPG_CHAN1_PAUSE_HI_MULTIPLIER_LSB (at 0x1b152)"
        set &access:&cmd_addr %l (0x80b1520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN1_PAUSE_HI_MULTIPLIER_MSB"
      sgroup "LPG_CHAN1_PAUSE_HI_MULTIPLIER_MSB (at 0x1b153)"
        set &access:&cmd_addr %l (0x80b1530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN1_PAUSE_LO_MULTIPLIER_LSB"
      sgroup "LPG_CHAN1_PAUSE_LO_MULTIPLIER_LSB (at 0x1b154)"
        set &access:&cmd_addr %l (0x80b1540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN1_PAUSE_LO_MULTIPLIER_MSB"
      sgroup "LPG_CHAN1_PAUSE_LO_MULTIPLIER_MSB (at 0x1b155)"
        set &access:&cmd_addr %l (0x80b1550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN1_HI_INDEX"
      sgroup "LPG_CHAN1_HI_INDEX (at 0x1b156)"
        set &access:&cmd_addr %l (0x80b1560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_LO_INDEX"
      sgroup "LPG_CHAN1_LO_INDEX (at 0x1b157)"
        set &access:&cmd_addr %l (0x80b1570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_SEC_ACCESS"
      sgroup "LPG_CHAN1_SEC_ACCESS (at 0x1b1d0)"
        set &access:&cmd_addr %l (0x80b1d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN1_PERPH_RESET_CTL2 (at 0x1b1d9)"
        set &access:&cmd_addr %l (0x80b1d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN1_PERPH_RESET_CTL3 (at 0x1b1da)"
        set &access:&cmd_addr %l (0x80b1da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN1_PERPH_RESET_CTL4 (at 0x1b1db)"
        set &access:&cmd_addr %l (0x80b1db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST1"
      sgroup "LPG_CHAN1_INT_TEST1 (at 0x1b1e0)"
        set &access:&cmd_addr %l (0x80b1e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST_VAL"
      sgroup "LPG_CHAN1_INT_TEST_VAL (at 0x1b1e1)"
        set &access:&cmd_addr %l (0x80b1e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN1_TEST1"
      sgroup "LPG_CHAN1_TEST1 (at 0x1b1e2)"
        set &access:&cmd_addr %l (0x80b1e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN1_TEST2"
      sgroup "LPG_CHAN1_TEST2 (at 0x1b1e3)"
        set &access:&cmd_addr %l (0x80b1e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN1_TEST3"
      sgroup "LPG_CHAN1_TEST3 (at 0x1b1e4)"
        set &access:&cmd_addr %l (0x80b1e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN1_TEST4"
      sgroup "LPG_CHAN1_TEST4 (at 0x1b1e5)"
        set &access:&cmd_addr %l (0x80b1e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb1e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN2"
  tree "LPG_CHAN2"
    tree "LPG_CHAN2_REVISION1"
      sgroup "LPG_CHAN2_REVISION1 (at 0x1b200)"
        set &access:&cmd_addr %l (0x80b2000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN2_REVISION2"
      sgroup "LPG_CHAN2_REVISION2 (at 0x1b201)"
        set &access:&cmd_addr %l (0x80b2010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN2_PERPH_TYPE"
      sgroup "LPG_CHAN2_PERPH_TYPE (at 0x1b204)"
        set &access:&cmd_addr %l (0x80b2040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN2_PERPH_SUBTYPE"
      sgroup "LPG_CHAN2_PERPH_SUBTYPE (at 0x1b205)"
        set &access:&cmd_addr %l (0x80b2050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN2_INT_RT_STS"
      sgroup "LPG_CHAN2_INT_RT_STS (at 0x1b210)"
        set &access:&cmd_addr %l (0x80b2100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_SET_TYPE"
      sgroup "LPG_CHAN2_INT_SET_TYPE (at 0x1b211)"
        set &access:&cmd_addr %l (0x80b2110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN2_INT_POLARITY_HIGH (at 0x1b212)"
        set &access:&cmd_addr %l (0x80b2120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_LOW"
      sgroup "LPG_CHAN2_INT_POLARITY_LOW (at 0x1b213)"
        set &access:&cmd_addr %l (0x80b2130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_CLR"
      sgroup "LPG_CHAN2_INT_LATCHED_CLR (at 0x1b214)"
        set &access:&cmd_addr %l (0x80b2140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_EN_SET"
      sgroup "LPG_CHAN2_INT_EN_SET (at 0x1b215)"
        set &access:&cmd_addr %l (0x80b2150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_EN_CLR"
      sgroup "LPG_CHAN2_INT_EN_CLR (at 0x1b216)"
        set &access:&cmd_addr %l (0x80b2160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_STS"
      sgroup "LPG_CHAN2_INT_LATCHED_STS (at 0x1b218)"
        set &access:&cmd_addr %l (0x80b2180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN2_INT_PENDING_STS"
      sgroup "LPG_CHAN2_INT_PENDING_STS (at 0x1b219)"
        set &access:&cmd_addr %l (0x80b2190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN2_INT_MID_SEL"
      sgroup "LPG_CHAN2_INT_MID_SEL (at 0x1b21a)"
        set &access:&cmd_addr %l (0x80b21a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb21a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN2_INT_PRIORITY"
      sgroup "LPG_CHAN2_INT_PRIORITY (at 0x1b21b)"
        set &access:&cmd_addr %l (0x80b21b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb21b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN2_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN2_LPG_PATTERN_CONFIG (at 0x1b240)"
        set &access:&cmd_addr %l (0x80b2400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN2_LPG_PWM_SIZE_CLK (at 0x1b241)"
        set &access:&cmd_addr %l (0x80b2410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b242)"
        set &access:&cmd_addr %l (0x80b2420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN2_LPG_PWM_TYPE_CONFIG (at 0x1b243)"
        set &access:&cmd_addr %l (0x80b2430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_LSB"
      sgroup "LPG_CHAN2_PWM_VALUE_LSB (at 0x1b244)"
        set &access:&cmd_addr %l (0x80b2440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_MSB"
      sgroup "LPG_CHAN2_PWM_VALUE_MSB (at 0x1b245)"
        set &access:&cmd_addr %l (0x80b2450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN2_ENABLE_CONTROL"
      sgroup "LPG_CHAN2_ENABLE_CONTROL (at 0x1b246)"
        set &access:&cmd_addr %l (0x80b2460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN2_RAMP_STEP_DURATION_LSB (at 0x1b250)"
        set &access:&cmd_addr %l (0x80b2500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN2_RAMP_STEP_DURATION_MSB (at 0x1b251)"
        set &access:&cmd_addr %l (0x80b2510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN2_PAUSE_HI_MULTIPLIER_LSB"
      sgroup "LPG_CHAN2_PAUSE_HI_MULTIPLIER_LSB (at 0x1b252)"
        set &access:&cmd_addr %l (0x80b2520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN2_PAUSE_HI_MULTIPLIER_MSB"
      sgroup "LPG_CHAN2_PAUSE_HI_MULTIPLIER_MSB (at 0x1b253)"
        set &access:&cmd_addr %l (0x80b2530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN2_PAUSE_LO_MULTIPLIER_LSB"
      sgroup "LPG_CHAN2_PAUSE_LO_MULTIPLIER_LSB (at 0x1b254)"
        set &access:&cmd_addr %l (0x80b2540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN2_PAUSE_LO_MULTIPLIER_MSB"
      sgroup "LPG_CHAN2_PAUSE_LO_MULTIPLIER_MSB (at 0x1b255)"
        set &access:&cmd_addr %l (0x80b2550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN2_HI_INDEX"
      sgroup "LPG_CHAN2_HI_INDEX (at 0x1b256)"
        set &access:&cmd_addr %l (0x80b2560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_LO_INDEX"
      sgroup "LPG_CHAN2_LO_INDEX (at 0x1b257)"
        set &access:&cmd_addr %l (0x80b2570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_SEC_ACCESS"
      sgroup "LPG_CHAN2_SEC_ACCESS (at 0x1b2d0)"
        set &access:&cmd_addr %l (0x80b2d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN2_PERPH_RESET_CTL2 (at 0x1b2d9)"
        set &access:&cmd_addr %l (0x80b2d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN2_PERPH_RESET_CTL3 (at 0x1b2da)"
        set &access:&cmd_addr %l (0x80b2da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN2_PERPH_RESET_CTL4 (at 0x1b2db)"
        set &access:&cmd_addr %l (0x80b2db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST1"
      sgroup "LPG_CHAN2_INT_TEST1 (at 0x1b2e0)"
        set &access:&cmd_addr %l (0x80b2e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST_VAL"
      sgroup "LPG_CHAN2_INT_TEST_VAL (at 0x1b2e1)"
        set &access:&cmd_addr %l (0x80b2e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN2_TEST1"
      sgroup "LPG_CHAN2_TEST1 (at 0x1b2e2)"
        set &access:&cmd_addr %l (0x80b2e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN2_TEST2"
      sgroup "LPG_CHAN2_TEST2 (at 0x1b2e3)"
        set &access:&cmd_addr %l (0x80b2e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN2_TEST3"
      sgroup "LPG_CHAN2_TEST3 (at 0x1b2e4)"
        set &access:&cmd_addr %l (0x80b2e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN2_TEST4"
      sgroup "LPG_CHAN2_TEST4 (at 0x1b2e5)"
        set &access:&cmd_addr %l (0x80b2e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb2e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN3"
  tree "LPG_CHAN3"
    tree "LPG_CHAN3_REVISION1"
      sgroup "LPG_CHAN3_REVISION1 (at 0x1b300)"
        set &access:&cmd_addr %l (0x80b3000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN3_REVISION2"
      sgroup "LPG_CHAN3_REVISION2 (at 0x1b301)"
        set &access:&cmd_addr %l (0x80b3010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN3_PERPH_TYPE"
      sgroup "LPG_CHAN3_PERPH_TYPE (at 0x1b304)"
        set &access:&cmd_addr %l (0x80b3040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN3_PERPH_SUBTYPE"
      sgroup "LPG_CHAN3_PERPH_SUBTYPE (at 0x1b305)"
        set &access:&cmd_addr %l (0x80b3050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN3_INT_RT_STS"
      sgroup "LPG_CHAN3_INT_RT_STS (at 0x1b310)"
        set &access:&cmd_addr %l (0x80b3100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_SET_TYPE"
      sgroup "LPG_CHAN3_INT_SET_TYPE (at 0x1b311)"
        set &access:&cmd_addr %l (0x80b3110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN3_INT_POLARITY_HIGH (at 0x1b312)"
        set &access:&cmd_addr %l (0x80b3120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_LOW"
      sgroup "LPG_CHAN3_INT_POLARITY_LOW (at 0x1b313)"
        set &access:&cmd_addr %l (0x80b3130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_CLR"
      sgroup "LPG_CHAN3_INT_LATCHED_CLR (at 0x1b314)"
        set &access:&cmd_addr %l (0x80b3140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_EN_SET"
      sgroup "LPG_CHAN3_INT_EN_SET (at 0x1b315)"
        set &access:&cmd_addr %l (0x80b3150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_EN_CLR"
      sgroup "LPG_CHAN3_INT_EN_CLR (at 0x1b316)"
        set &access:&cmd_addr %l (0x80b3160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_STS"
      sgroup "LPG_CHAN3_INT_LATCHED_STS (at 0x1b318)"
        set &access:&cmd_addr %l (0x80b3180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN3_INT_PENDING_STS"
      sgroup "LPG_CHAN3_INT_PENDING_STS (at 0x1b319)"
        set &access:&cmd_addr %l (0x80b3190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN3_INT_MID_SEL"
      sgroup "LPG_CHAN3_INT_MID_SEL (at 0x1b31a)"
        set &access:&cmd_addr %l (0x80b31a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb31a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN3_INT_PRIORITY"
      sgroup "LPG_CHAN3_INT_PRIORITY (at 0x1b31b)"
        set &access:&cmd_addr %l (0x80b31b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb31b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN3_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN3_LPG_PATTERN_CONFIG (at 0x1b340)"
        set &access:&cmd_addr %l (0x80b3400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN3_LPG_PWM_SIZE_CLK (at 0x1b341)"
        set &access:&cmd_addr %l (0x80b3410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b342)"
        set &access:&cmd_addr %l (0x80b3420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN3_LPG_PWM_TYPE_CONFIG (at 0x1b343)"
        set &access:&cmd_addr %l (0x80b3430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_LSB"
      sgroup "LPG_CHAN3_PWM_VALUE_LSB (at 0x1b344)"
        set &access:&cmd_addr %l (0x80b3440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_MSB"
      sgroup "LPG_CHAN3_PWM_VALUE_MSB (at 0x1b345)"
        set &access:&cmd_addr %l (0x80b3450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN3_ENABLE_CONTROL"
      sgroup "LPG_CHAN3_ENABLE_CONTROL (at 0x1b346)"
        set &access:&cmd_addr %l (0x80b3460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN3_RAMP_STEP_DURATION_LSB (at 0x1b350)"
        set &access:&cmd_addr %l (0x80b3500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN3_RAMP_STEP_DURATION_MSB (at 0x1b351)"
        set &access:&cmd_addr %l (0x80b3510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN3_PAUSE_HI_MULTIPLIER_LSB"
      sgroup "LPG_CHAN3_PAUSE_HI_MULTIPLIER_LSB (at 0x1b352)"
        set &access:&cmd_addr %l (0x80b3520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN3_PAUSE_HI_MULTIPLIER_MSB"
      sgroup "LPG_CHAN3_PAUSE_HI_MULTIPLIER_MSB (at 0x1b353)"
        set &access:&cmd_addr %l (0x80b3530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN3_PAUSE_LO_MULTIPLIER_LSB"
      sgroup "LPG_CHAN3_PAUSE_LO_MULTIPLIER_LSB (at 0x1b354)"
        set &access:&cmd_addr %l (0x80b3540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN3_PAUSE_LO_MULTIPLIER_MSB"
      sgroup "LPG_CHAN3_PAUSE_LO_MULTIPLIER_MSB (at 0x1b355)"
        set &access:&cmd_addr %l (0x80b3550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN3_HI_INDEX"
      sgroup "LPG_CHAN3_HI_INDEX (at 0x1b356)"
        set &access:&cmd_addr %l (0x80b3560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_LO_INDEX"
      sgroup "LPG_CHAN3_LO_INDEX (at 0x1b357)"
        set &access:&cmd_addr %l (0x80b3570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_SEC_ACCESS"
      sgroup "LPG_CHAN3_SEC_ACCESS (at 0x1b3d0)"
        set &access:&cmd_addr %l (0x80b3d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN3_PERPH_RESET_CTL2 (at 0x1b3d9)"
        set &access:&cmd_addr %l (0x80b3d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN3_PERPH_RESET_CTL3 (at 0x1b3da)"
        set &access:&cmd_addr %l (0x80b3da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN3_PERPH_RESET_CTL4 (at 0x1b3db)"
        set &access:&cmd_addr %l (0x80b3db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST1"
      sgroup "LPG_CHAN3_INT_TEST1 (at 0x1b3e0)"
        set &access:&cmd_addr %l (0x80b3e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST_VAL"
      sgroup "LPG_CHAN3_INT_TEST_VAL (at 0x1b3e1)"
        set &access:&cmd_addr %l (0x80b3e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN3_TEST1"
      sgroup "LPG_CHAN3_TEST1 (at 0x1b3e2)"
        set &access:&cmd_addr %l (0x80b3e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN3_TEST2"
      sgroup "LPG_CHAN3_TEST2 (at 0x1b3e3)"
        set &access:&cmd_addr %l (0x80b3e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN3_TEST3"
      sgroup "LPG_CHAN3_TEST3 (at 0x1b3e4)"
        set &access:&cmd_addr %l (0x80b3e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN3_TEST4"
      sgroup "LPG_CHAN3_TEST4 (at 0x1b3e5)"
        set &access:&cmd_addr %l (0x80b3e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb3e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN4"
  tree "LPG_CHAN4"
    tree "LPG_CHAN4_REVISION1"
      sgroup "LPG_CHAN4_REVISION1 (at 0x1b400)"
        set &access:&cmd_addr %l (0x80b4000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN4_REVISION2"
      sgroup "LPG_CHAN4_REVISION2 (at 0x1b401)"
        set &access:&cmd_addr %l (0x80b4010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN4_PERPH_TYPE"
      sgroup "LPG_CHAN4_PERPH_TYPE (at 0x1b404)"
        set &access:&cmd_addr %l (0x80b4040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN4_PERPH_SUBTYPE"
      sgroup "LPG_CHAN4_PERPH_SUBTYPE (at 0x1b405)"
        set &access:&cmd_addr %l (0x80b4050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN4_INT_RT_STS"
      sgroup "LPG_CHAN4_INT_RT_STS (at 0x1b410)"
        set &access:&cmd_addr %l (0x80b4100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_SET_TYPE"
      sgroup "LPG_CHAN4_INT_SET_TYPE (at 0x1b411)"
        set &access:&cmd_addr %l (0x80b4110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN4_INT_POLARITY_HIGH (at 0x1b412)"
        set &access:&cmd_addr %l (0x80b4120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_LOW"
      sgroup "LPG_CHAN4_INT_POLARITY_LOW (at 0x1b413)"
        set &access:&cmd_addr %l (0x80b4130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_CLR"
      sgroup "LPG_CHAN4_INT_LATCHED_CLR (at 0x1b414)"
        set &access:&cmd_addr %l (0x80b4140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_EN_SET"
      sgroup "LPG_CHAN4_INT_EN_SET (at 0x1b415)"
        set &access:&cmd_addr %l (0x80b4150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_EN_CLR"
      sgroup "LPG_CHAN4_INT_EN_CLR (at 0x1b416)"
        set &access:&cmd_addr %l (0x80b4160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_STS"
      sgroup "LPG_CHAN4_INT_LATCHED_STS (at 0x1b418)"
        set &access:&cmd_addr %l (0x80b4180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN4_INT_PENDING_STS"
      sgroup "LPG_CHAN4_INT_PENDING_STS (at 0x1b419)"
        set &access:&cmd_addr %l (0x80b4190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN4_INT_MID_SEL"
      sgroup "LPG_CHAN4_INT_MID_SEL (at 0x1b41a)"
        set &access:&cmd_addr %l (0x80b41a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb41a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN4_INT_PRIORITY"
      sgroup "LPG_CHAN4_INT_PRIORITY (at 0x1b41b)"
        set &access:&cmd_addr %l (0x80b41b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb41b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN4_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN4_LPG_PATTERN_CONFIG (at 0x1b440)"
        set &access:&cmd_addr %l (0x80b4400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN4_LPG_PWM_SIZE_CLK (at 0x1b441)"
        set &access:&cmd_addr %l (0x80b4410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b442)"
        set &access:&cmd_addr %l (0x80b4420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN4_LPG_PWM_TYPE_CONFIG (at 0x1b443)"
        set &access:&cmd_addr %l (0x80b4430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_LSB"
      sgroup "LPG_CHAN4_PWM_VALUE_LSB (at 0x1b444)"
        set &access:&cmd_addr %l (0x80b4440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_MSB"
      sgroup "LPG_CHAN4_PWM_VALUE_MSB (at 0x1b445)"
        set &access:&cmd_addr %l (0x80b4450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN4_ENABLE_CONTROL"
      sgroup "LPG_CHAN4_ENABLE_CONTROL (at 0x1b446)"
        set &access:&cmd_addr %l (0x80b4460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN4_RAMP_STEP_DURATION_LSB (at 0x1b450)"
        set &access:&cmd_addr %l (0x80b4500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN4_RAMP_STEP_DURATION_MSB (at 0x1b451)"
        set &access:&cmd_addr %l (0x80b4510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN4_PAUSE_HI_MULTIPLIER_LSB"
      sgroup "LPG_CHAN4_PAUSE_HI_MULTIPLIER_LSB (at 0x1b452)"
        set &access:&cmd_addr %l (0x80b4520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN4_PAUSE_HI_MULTIPLIER_MSB"
      sgroup "LPG_CHAN4_PAUSE_HI_MULTIPLIER_MSB (at 0x1b453)"
        set &access:&cmd_addr %l (0x80b4530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN4_PAUSE_LO_MULTIPLIER_LSB"
      sgroup "LPG_CHAN4_PAUSE_LO_MULTIPLIER_LSB (at 0x1b454)"
        set &access:&cmd_addr %l (0x80b4540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN4_PAUSE_LO_MULTIPLIER_MSB"
      sgroup "LPG_CHAN4_PAUSE_LO_MULTIPLIER_MSB (at 0x1b455)"
        set &access:&cmd_addr %l (0x80b4550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN4_HI_INDEX"
      sgroup "LPG_CHAN4_HI_INDEX (at 0x1b456)"
        set &access:&cmd_addr %l (0x80b4560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_LO_INDEX"
      sgroup "LPG_CHAN4_LO_INDEX (at 0x1b457)"
        set &access:&cmd_addr %l (0x80b4570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_SEC_ACCESS"
      sgroup "LPG_CHAN4_SEC_ACCESS (at 0x1b4d0)"
        set &access:&cmd_addr %l (0x80b4d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN4_PERPH_RESET_CTL2 (at 0x1b4d9)"
        set &access:&cmd_addr %l (0x80b4d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN4_PERPH_RESET_CTL3 (at 0x1b4da)"
        set &access:&cmd_addr %l (0x80b4da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN4_PERPH_RESET_CTL4 (at 0x1b4db)"
        set &access:&cmd_addr %l (0x80b4db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST1"
      sgroup "LPG_CHAN4_INT_TEST1 (at 0x1b4e0)"
        set &access:&cmd_addr %l (0x80b4e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST_VAL"
      sgroup "LPG_CHAN4_INT_TEST_VAL (at 0x1b4e1)"
        set &access:&cmd_addr %l (0x80b4e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN4_TEST1"
      sgroup "LPG_CHAN4_TEST1 (at 0x1b4e2)"
        set &access:&cmd_addr %l (0x80b4e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN4_TEST2"
      sgroup "LPG_CHAN4_TEST2 (at 0x1b4e3)"
        set &access:&cmd_addr %l (0x80b4e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN4_TEST3"
      sgroup "LPG_CHAN4_TEST3 (at 0x1b4e4)"
        set &access:&cmd_addr %l (0x80b4e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN4_TEST4"
      sgroup "LPG_CHAN4_TEST4 (at 0x1b4e5)"
        set &access:&cmd_addr %l (0x80b4e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb4e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN5"
  tree "LPG_CHAN5"
    tree "LPG_CHAN5_REVISION1"
      sgroup "LPG_CHAN5_REVISION1 (at 0x1b500)"
        set &access:&cmd_addr %l (0x80b5000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN5_REVISION2"
      sgroup "LPG_CHAN5_REVISION2 (at 0x1b501)"
        set &access:&cmd_addr %l (0x80b5010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN5_PERPH_TYPE"
      sgroup "LPG_CHAN5_PERPH_TYPE (at 0x1b504)"
        set &access:&cmd_addr %l (0x80b5040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN5_PERPH_SUBTYPE"
      sgroup "LPG_CHAN5_PERPH_SUBTYPE (at 0x1b505)"
        set &access:&cmd_addr %l (0x80b5050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN5_INT_RT_STS"
      sgroup "LPG_CHAN5_INT_RT_STS (at 0x1b510)"
        set &access:&cmd_addr %l (0x80b5100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN5_INT_SET_TYPE"
      sgroup "LPG_CHAN5_INT_SET_TYPE (at 0x1b511)"
        set &access:&cmd_addr %l (0x80b5110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN5_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN5_INT_POLARITY_HIGH (at 0x1b512)"
        set &access:&cmd_addr %l (0x80b5120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_POLARITY_LOW"
      sgroup "LPG_CHAN5_INT_POLARITY_LOW (at 0x1b513)"
        set &access:&cmd_addr %l (0x80b5130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_LATCHED_CLR"
      sgroup "LPG_CHAN5_INT_LATCHED_CLR (at 0x1b514)"
        set &access:&cmd_addr %l (0x80b5140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN5_INT_EN_SET"
      sgroup "LPG_CHAN5_INT_EN_SET (at 0x1b515)"
        set &access:&cmd_addr %l (0x80b5150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_EN_CLR"
      sgroup "LPG_CHAN5_INT_EN_CLR (at 0x1b516)"
        set &access:&cmd_addr %l (0x80b5160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_LATCHED_STS"
      sgroup "LPG_CHAN5_INT_LATCHED_STS (at 0x1b518)"
        set &access:&cmd_addr %l (0x80b5180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN5_INT_PENDING_STS"
      sgroup "LPG_CHAN5_INT_PENDING_STS (at 0x1b519)"
        set &access:&cmd_addr %l (0x80b5190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN5_INT_MID_SEL"
      sgroup "LPG_CHAN5_INT_MID_SEL (at 0x1b51a)"
        set &access:&cmd_addr %l (0x80b51a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb51a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN5_INT_PRIORITY"
      sgroup "LPG_CHAN5_INT_PRIORITY (at 0x1b51b)"
        set &access:&cmd_addr %l (0x80b51b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb51b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN5_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN5_LPG_PATTERN_CONFIG (at 0x1b540)"
        set &access:&cmd_addr %l (0x80b5400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN5_LPG_PWM_SIZE_CLK (at 0x1b541)"
        set &access:&cmd_addr %l (0x80b5410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN5_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b542)"
        set &access:&cmd_addr %l (0x80b5420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN5_LPG_PWM_TYPE_CONFIG (at 0x1b543)"
        set &access:&cmd_addr %l (0x80b5430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN5_PWM_VALUE_LSB"
      sgroup "LPG_CHAN5_PWM_VALUE_LSB (at 0x1b544)"
        set &access:&cmd_addr %l (0x80b5440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN5_PWM_VALUE_MSB"
      sgroup "LPG_CHAN5_PWM_VALUE_MSB (at 0x1b545)"
        set &access:&cmd_addr %l (0x80b5450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN5_ENABLE_CONTROL"
      sgroup "LPG_CHAN5_ENABLE_CONTROL (at 0x1b546)"
        set &access:&cmd_addr %l (0x80b5460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN5_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN5_RAMP_STEP_DURATION_LSB (at 0x1b550)"
        set &access:&cmd_addr %l (0x80b5500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN5_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN5_RAMP_STEP_DURATION_MSB (at 0x1b551)"
        set &access:&cmd_addr %l (0x80b5510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN5_PAUSE_HI_MULTIPLIER_LSB"
      sgroup "LPG_CHAN5_PAUSE_HI_MULTIPLIER_LSB (at 0x1b552)"
        set &access:&cmd_addr %l (0x80b5520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN5_PAUSE_HI_MULTIPLIER_MSB"
      sgroup "LPG_CHAN5_PAUSE_HI_MULTIPLIER_MSB (at 0x1b553)"
        set &access:&cmd_addr %l (0x80b5530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN5_PAUSE_LO_MULTIPLIER_LSB"
      sgroup "LPG_CHAN5_PAUSE_LO_MULTIPLIER_LSB (at 0x1b554)"
        set &access:&cmd_addr %l (0x80b5540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN5_PAUSE_LO_MULTIPLIER_MSB"
      sgroup "LPG_CHAN5_PAUSE_LO_MULTIPLIER_MSB (at 0x1b555)"
        set &access:&cmd_addr %l (0x80b5550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN5_HI_INDEX"
      sgroup "LPG_CHAN5_HI_INDEX (at 0x1b556)"
        set &access:&cmd_addr %l (0x80b5560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN5_LO_INDEX"
      sgroup "LPG_CHAN5_LO_INDEX (at 0x1b557)"
        set &access:&cmd_addr %l (0x80b5570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN5_SEC_ACCESS"
      sgroup "LPG_CHAN5_SEC_ACCESS (at 0x1b5d0)"
        set &access:&cmd_addr %l (0x80b5d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN5_PERPH_RESET_CTL2 (at 0x1b5d9)"
        set &access:&cmd_addr %l (0x80b5d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN5_PERPH_RESET_CTL3 (at 0x1b5da)"
        set &access:&cmd_addr %l (0x80b5da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN5_PERPH_RESET_CTL4 (at 0x1b5db)"
        set &access:&cmd_addr %l (0x80b5db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN5_INT_TEST1"
      sgroup "LPG_CHAN5_INT_TEST1 (at 0x1b5e0)"
        set &access:&cmd_addr %l (0x80b5e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_TEST_VAL"
      sgroup "LPG_CHAN5_INT_TEST_VAL (at 0x1b5e1)"
        set &access:&cmd_addr %l (0x80b5e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN5_TEST1"
      sgroup "LPG_CHAN5_TEST1 (at 0x1b5e2)"
        set &access:&cmd_addr %l (0x80b5e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN5_TEST2"
      sgroup "LPG_CHAN5_TEST2 (at 0x1b5e3)"
        set &access:&cmd_addr %l (0x80b5e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN5_TEST3"
      sgroup "LPG_CHAN5_TEST3 (at 0x1b5e4)"
        set &access:&cmd_addr %l (0x80b5e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN5_TEST4"
      sgroup "LPG_CHAN5_TEST4 (at 0x1b5e5)"
        set &access:&cmd_addr %l (0x80b5e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb5e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN6"
  tree "LPG_CHAN6"
    tree "LPG_CHAN6_REVISION1"
      sgroup "LPG_CHAN6_REVISION1 (at 0x1b600)"
        set &access:&cmd_addr %l (0x80b6000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN6_REVISION2"
      sgroup "LPG_CHAN6_REVISION2 (at 0x1b601)"
        set &access:&cmd_addr %l (0x80b6010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN6_PERPH_TYPE"
      sgroup "LPG_CHAN6_PERPH_TYPE (at 0x1b604)"
        set &access:&cmd_addr %l (0x80b6040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN6_PERPH_SUBTYPE"
      sgroup "LPG_CHAN6_PERPH_SUBTYPE (at 0x1b605)"
        set &access:&cmd_addr %l (0x80b6050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN6_INT_RT_STS"
      sgroup "LPG_CHAN6_INT_RT_STS (at 0x1b610)"
        set &access:&cmd_addr %l (0x80b6100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN6_INT_SET_TYPE"
      sgroup "LPG_CHAN6_INT_SET_TYPE (at 0x1b611)"
        set &access:&cmd_addr %l (0x80b6110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN6_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN6_INT_POLARITY_HIGH (at 0x1b612)"
        set &access:&cmd_addr %l (0x80b6120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_POLARITY_LOW"
      sgroup "LPG_CHAN6_INT_POLARITY_LOW (at 0x1b613)"
        set &access:&cmd_addr %l (0x80b6130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_LATCHED_CLR"
      sgroup "LPG_CHAN6_INT_LATCHED_CLR (at 0x1b614)"
        set &access:&cmd_addr %l (0x80b6140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN6_INT_EN_SET"
      sgroup "LPG_CHAN6_INT_EN_SET (at 0x1b615)"
        set &access:&cmd_addr %l (0x80b6150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_EN_CLR"
      sgroup "LPG_CHAN6_INT_EN_CLR (at 0x1b616)"
        set &access:&cmd_addr %l (0x80b6160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_LATCHED_STS"
      sgroup "LPG_CHAN6_INT_LATCHED_STS (at 0x1b618)"
        set &access:&cmd_addr %l (0x80b6180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN6_INT_PENDING_STS"
      sgroup "LPG_CHAN6_INT_PENDING_STS (at 0x1b619)"
        set &access:&cmd_addr %l (0x80b6190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN6_INT_MID_SEL"
      sgroup "LPG_CHAN6_INT_MID_SEL (at 0x1b61a)"
        set &access:&cmd_addr %l (0x80b61a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb61a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN6_INT_PRIORITY"
      sgroup "LPG_CHAN6_INT_PRIORITY (at 0x1b61b)"
        set &access:&cmd_addr %l (0x80b61b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb61b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN6_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN6_LPG_PATTERN_CONFIG (at 0x1b640)"
        set &access:&cmd_addr %l (0x80b6400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN6_LPG_PWM_SIZE_CLK (at 0x1b641)"
        set &access:&cmd_addr %l (0x80b6410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_7BIT),2 (PWM_8BIT),3 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN6_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b642)"
        set &access:&cmd_addr %l (0x80b6420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN6_LPG_PWM_TYPE_CONFIG (at 0x1b643)"
        set &access:&cmd_addr %l (0x80b6430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FULL_SCALE                            = " "0 (PWM_FULL_DIS),1 (PWM_FULL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_PHASE_STAGGER                         = " "0 (STAGGERING_DIS),1 (STAGGERING_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STAGGER                            = " "0 (STAGGER_0DEG),1 (STAGGER_90DEG),2 (STAGGER_180DEG),3 (STAGGER_270DEG)"
    tree.end
    tree "LPG_CHAN6_PWM_VALUE_LSB"
      sgroup "LPG_CHAN6_PWM_VALUE_LSB (at 0x1b644)"
        set &access:&cmd_addr %l (0x80b6440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN6_PWM_VALUE_MSB"
      sgroup "LPG_CHAN6_PWM_VALUE_MSB (at 0x1b645)"
        set &access:&cmd_addr %l (0x80b6450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN6_ENABLE_CONTROL"
      sgroup "LPG_CHAN6_ENABLE_CONTROL (at 0x1b646)"
        set &access:&cmd_addr %l (0x80b6460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_HI                                = " "0 (PWM_HI_DIS),1 (LPG_HI_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWM_LO                                = " "0 (PWM_LO_DIS),1 (LPG_LO_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PWM_OUTPUT                            = " "0 (TRISTATE),1 (BUFFER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN6_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN6_RAMP_STEP_DURATION_LSB (at 0x1b650)"
        set &access:&cmd_addr %l (0x80b6500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN6_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN6_RAMP_STEP_DURATION_MSB (at 0x1b651)"
        set &access:&cmd_addr %l (0x80b6510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN6_PAUSE_HI_MULTIPLIER_LSB"
      sgroup "LPG_CHAN6_PAUSE_HI_MULTIPLIER_LSB (at 0x1b652)"
        set &access:&cmd_addr %l (0x80b6520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN6_PAUSE_HI_MULTIPLIER_MSB"
      sgroup "LPG_CHAN6_PAUSE_HI_MULTIPLIER_MSB (at 0x1b653)"
        set &access:&cmd_addr %l (0x80b6530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_HI_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN6_PAUSE_LO_MULTIPLIER_LSB"
      sgroup "LPG_CHAN6_PAUSE_LO_MULTIPLIER_LSB (at 0x1b654)"
        set &access:&cmd_addr %l (0x80b6540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT_LSB                        = "
    tree.end
    tree "LPG_CHAN6_PAUSE_LO_MULTIPLIER_MSB"
      sgroup "LPG_CHAN6_PAUSE_LO_MULTIPLIER_MSB (at 0x1b655)"
        set &access:&cmd_addr %l (0x80b6550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PAUSE_LO_MULT_MSB                        = "
    tree.end
    tree "LPG_CHAN6_HI_INDEX"
      sgroup "LPG_CHAN6_HI_INDEX (at 0x1b656)"
        set &access:&cmd_addr %l (0x80b6560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN6_LO_INDEX"
      sgroup "LPG_CHAN6_LO_INDEX (at 0x1b657)"
        set &access:&cmd_addr %l (0x80b6570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN6_SEC_ACCESS"
      sgroup "LPG_CHAN6_SEC_ACCESS (at 0x1b6d0)"
        set &access:&cmd_addr %l (0x80b6d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN6_PERPH_RESET_CTL2 (at 0x1b6d9)"
        set &access:&cmd_addr %l (0x80b6d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN6_PERPH_RESET_CTL3 (at 0x1b6da)"
        set &access:&cmd_addr %l (0x80b6da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN6_PERPH_RESET_CTL4 (at 0x1b6db)"
        set &access:&cmd_addr %l (0x80b6db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN6_INT_TEST1"
      sgroup "LPG_CHAN6_INT_TEST1 (at 0x1b6e0)"
        set &access:&cmd_addr %l (0x80b6e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_TEST_VAL"
      sgroup "LPG_CHAN6_INT_TEST_VAL (at 0x1b6e1)"
        set &access:&cmd_addr %l (0x80b6e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN6_TEST1"
      sgroup "LPG_CHAN6_TEST1 (at 0x1b6e2)"
        set &access:&cmd_addr %l (0x80b6e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (reserved),4 (reserved),5 (PWM_0MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN6_TEST2"
      sgroup "LPG_CHAN6_TEST2 (at 0x1b6e3)"
        set &access:&cmd_addr %l (0x80b6e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_1KHZ),4 (FSM_STATE2),5 (PWM_1MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN6_TEST3"
      sgroup "LPG_CHAN6_TEST3 (at 0x1b6e4)"
        set &access:&cmd_addr %l (0x80b6e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_32KHZ),4 (FSM_STATE1),5 (PWM_2MSBS),6 (reserved),7 (reserved)"
    tree.end
    tree "LPG_CHAN6_TEST4"
      sgroup "LPG_CHAN6_TEST4 (at 0x1b6e5)"
        set &access:&cmd_addr %l (0x80b6e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb6e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0 (TEST_DIS),1 (LPG_OUT_LO),2 (LPG_OUT_HI),3 (CLK_19P2MHZ),4 (FSM_STATE0),5 (PWM_3MSBS),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "LPG_LUT"
  tree "LPG_LUT"
    tree "LPG_LUT_REVISION1"
      sgroup "LPG_LUT_REVISION1 (at 0x1b000)"
        set &access:&cmd_addr %l (0x80b0000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_LUT_REVISION2"
      sgroup "LPG_LUT_REVISION2 (at 0x1b001)"
        set &access:&cmd_addr %l (0x80b0010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_LUT_PERPH_TYPE"
      sgroup "LPG_LUT_PERPH_TYPE (at 0x1b004)"
        set &access:&cmd_addr %l (0x80b0040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_LUT_PERPH_SUBTYPE"
      sgroup "LPG_LUT_PERPH_SUBTYPE (at 0x1b005)"
        set &access:&cmd_addr %l (0x80b0050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_LUT_LUT0_LSB"
      sgroup "LPG_LUT_LUT0_LSB (at 0x1b040)"
        set &access:&cmd_addr %l (0x80b0400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT0_MSB"
      sgroup "LPG_LUT_LUT0_MSB (at 0x1b041)"
        set &access:&cmd_addr %l (0x80b0410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT1_LSB"
      sgroup "LPG_LUT_LUT1_LSB (at 0x1b042)"
        set &access:&cmd_addr %l (0x80b0420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT1_MSB"
      sgroup "LPG_LUT_LUT1_MSB (at 0x1b043)"
        set &access:&cmd_addr %l (0x80b0430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT2_LSB"
      sgroup "LPG_LUT_LUT2_LSB (at 0x1b044)"
        set &access:&cmd_addr %l (0x80b0440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT2_MSB"
      sgroup "LPG_LUT_LUT2_MSB (at 0x1b045)"
        set &access:&cmd_addr %l (0x80b0450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT3_LSB"
      sgroup "LPG_LUT_LUT3_LSB (at 0x1b046)"
        set &access:&cmd_addr %l (0x80b0460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT3_MSB"
      sgroup "LPG_LUT_LUT3_MSB (at 0x1b047)"
        set &access:&cmd_addr %l (0x80b0470|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0470|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT4_LSB"
      sgroup "LPG_LUT_LUT4_LSB (at 0x1b048)"
        set &access:&cmd_addr %l (0x80b0480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT4_MSB"
      sgroup "LPG_LUT_LUT4_MSB (at 0x1b049)"
        set &access:&cmd_addr %l (0x80b0490|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0490|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT5_LSB"
      sgroup "LPG_LUT_LUT5_LSB (at 0x1b04a)"
        set &access:&cmd_addr %l (0x80b04a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb04a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT5_MSB"
      sgroup "LPG_LUT_LUT5_MSB (at 0x1b04b)"
        set &access:&cmd_addr %l (0x80b04b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb04b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT6_LSB"
      sgroup "LPG_LUT_LUT6_LSB (at 0x1b04c)"
        set &access:&cmd_addr %l (0x80b04c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb04c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT6_MSB"
      sgroup "LPG_LUT_LUT6_MSB (at 0x1b04d)"
        set &access:&cmd_addr %l (0x80b04d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb04d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT7_LSB"
      sgroup "LPG_LUT_LUT7_LSB (at 0x1b04e)"
        set &access:&cmd_addr %l (0x80b04e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb04e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT7_MSB"
      sgroup "LPG_LUT_LUT7_MSB (at 0x1b04f)"
        set &access:&cmd_addr %l (0x80b04f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb04f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT8_LSB"
      sgroup "LPG_LUT_LUT8_LSB (at 0x1b050)"
        set &access:&cmd_addr %l (0x80b0500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT8_MSB"
      sgroup "LPG_LUT_LUT8_MSB (at 0x1b051)"
        set &access:&cmd_addr %l (0x80b0510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT9_LSB"
      sgroup "LPG_LUT_LUT9_LSB (at 0x1b052)"
        set &access:&cmd_addr %l (0x80b0520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT9_MSB"
      sgroup "LPG_LUT_LUT9_MSB (at 0x1b053)"
        set &access:&cmd_addr %l (0x80b0530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT10_LSB"
      sgroup "LPG_LUT_LUT10_LSB (at 0x1b054)"
        set &access:&cmd_addr %l (0x80b0540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT10_MSB"
      sgroup "LPG_LUT_LUT10_MSB (at 0x1b055)"
        set &access:&cmd_addr %l (0x80b0550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT11_LSB"
      sgroup "LPG_LUT_LUT11_LSB (at 0x1b056)"
        set &access:&cmd_addr %l (0x80b0560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT11_MSB"
      sgroup "LPG_LUT_LUT11_MSB (at 0x1b057)"
        set &access:&cmd_addr %l (0x80b0570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT12_LSB"
      sgroup "LPG_LUT_LUT12_LSB (at 0x1b058)"
        set &access:&cmd_addr %l (0x80b0580|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0580|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT12_MSB"
      sgroup "LPG_LUT_LUT12_MSB (at 0x1b059)"
        set &access:&cmd_addr %l (0x80b0590|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0590|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT13_LSB"
      sgroup "LPG_LUT_LUT13_LSB (at 0x1b05a)"
        set &access:&cmd_addr %l (0x80b05a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb05a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT13_MSB"
      sgroup "LPG_LUT_LUT13_MSB (at 0x1b05b)"
        set &access:&cmd_addr %l (0x80b05b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb05b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT14_LSB"
      sgroup "LPG_LUT_LUT14_LSB (at 0x1b05c)"
        set &access:&cmd_addr %l (0x80b05c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb05c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT14_MSB"
      sgroup "LPG_LUT_LUT14_MSB (at 0x1b05d)"
        set &access:&cmd_addr %l (0x80b05d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb05d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT15_LSB"
      sgroup "LPG_LUT_LUT15_LSB (at 0x1b05e)"
        set &access:&cmd_addr %l (0x80b05e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb05e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT15_MSB"
      sgroup "LPG_LUT_LUT15_MSB (at 0x1b05f)"
        set &access:&cmd_addr %l (0x80b05f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb05f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT16_LSB"
      sgroup "LPG_LUT_LUT16_LSB (at 0x1b060)"
        set &access:&cmd_addr %l (0x80b0600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT16_MSB"
      sgroup "LPG_LUT_LUT16_MSB (at 0x1b061)"
        set &access:&cmd_addr %l (0x80b0610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT17_LSB"
      sgroup "LPG_LUT_LUT17_LSB (at 0x1b062)"
        set &access:&cmd_addr %l (0x80b0620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT17_MSB"
      sgroup "LPG_LUT_LUT17_MSB (at 0x1b063)"
        set &access:&cmd_addr %l (0x80b0630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT18_LSB"
      sgroup "LPG_LUT_LUT18_LSB (at 0x1b064)"
        set &access:&cmd_addr %l (0x80b0640|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0640|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT18_MSB"
      sgroup "LPG_LUT_LUT18_MSB (at 0x1b065)"
        set &access:&cmd_addr %l (0x80b0650|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0650|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT19_LSB"
      sgroup "LPG_LUT_LUT19_LSB (at 0x1b066)"
        set &access:&cmd_addr %l (0x80b0660|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0660|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT19_MSB"
      sgroup "LPG_LUT_LUT19_MSB (at 0x1b067)"
        set &access:&cmd_addr %l (0x80b0670|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0670|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT20_LSB"
      sgroup "LPG_LUT_LUT20_LSB (at 0x1b068)"
        set &access:&cmd_addr %l (0x80b0680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT20_MSB"
      sgroup "LPG_LUT_LUT20_MSB (at 0x1b069)"
        set &access:&cmd_addr %l (0x80b0690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT21_LSB"
      sgroup "LPG_LUT_LUT21_LSB (at 0x1b06a)"
        set &access:&cmd_addr %l (0x80b06a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb06a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT21_MSB"
      sgroup "LPG_LUT_LUT21_MSB (at 0x1b06b)"
        set &access:&cmd_addr %l (0x80b06b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb06b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT22_LSB"
      sgroup "LPG_LUT_LUT22_LSB (at 0x1b06c)"
        set &access:&cmd_addr %l (0x80b06c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb06c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT22_MSB"
      sgroup "LPG_LUT_LUT22_MSB (at 0x1b06d)"
        set &access:&cmd_addr %l (0x80b06d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb06d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT23_LSB"
      sgroup "LPG_LUT_LUT23_LSB (at 0x1b06e)"
        set &access:&cmd_addr %l (0x80b06e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb06e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT23_MSB"
      sgroup "LPG_LUT_LUT23_MSB (at 0x1b06f)"
        set &access:&cmd_addr %l (0x80b06f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb06f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT24_LSB"
      sgroup "LPG_LUT_LUT24_LSB (at 0x1b070)"
        set &access:&cmd_addr %l (0x80b0700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT24_MSB"
      sgroup "LPG_LUT_LUT24_MSB (at 0x1b071)"
        set &access:&cmd_addr %l (0x80b0710|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0710|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT25_LSB"
      sgroup "LPG_LUT_LUT25_LSB (at 0x1b072)"
        set &access:&cmd_addr %l (0x80b0720|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0720|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT25_MSB"
      sgroup "LPG_LUT_LUT25_MSB (at 0x1b073)"
        set &access:&cmd_addr %l (0x80b0730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT26_LSB"
      sgroup "LPG_LUT_LUT26_LSB (at 0x1b074)"
        set &access:&cmd_addr %l (0x80b0740|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0740|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT26_MSB"
      sgroup "LPG_LUT_LUT26_MSB (at 0x1b075)"
        set &access:&cmd_addr %l (0x80b0750|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0750|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT27_LSB"
      sgroup "LPG_LUT_LUT27_LSB (at 0x1b076)"
        set &access:&cmd_addr %l (0x80b0760|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0760|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT27_MSB"
      sgroup "LPG_LUT_LUT27_MSB (at 0x1b077)"
        set &access:&cmd_addr %l (0x80b0770|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0770|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT28_LSB"
      sgroup "LPG_LUT_LUT28_LSB (at 0x1b078)"
        set &access:&cmd_addr %l (0x80b0780|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0780|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT28_MSB"
      sgroup "LPG_LUT_LUT28_MSB (at 0x1b079)"
        set &access:&cmd_addr %l (0x80b0790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT29_LSB"
      sgroup "LPG_LUT_LUT29_LSB (at 0x1b07a)"
        set &access:&cmd_addr %l (0x80b07a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb07a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT29_MSB"
      sgroup "LPG_LUT_LUT29_MSB (at 0x1b07b)"
        set &access:&cmd_addr %l (0x80b07b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb07b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT30_LSB"
      sgroup "LPG_LUT_LUT30_LSB (at 0x1b07c)"
        set &access:&cmd_addr %l (0x80b07c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb07c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT30_MSB"
      sgroup "LPG_LUT_LUT30_MSB (at 0x1b07d)"
        set &access:&cmd_addr %l (0x80b07d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb07d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT31_LSB"
      sgroup "LPG_LUT_LUT31_LSB (at 0x1b07e)"
        set &access:&cmd_addr %l (0x80b07e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb07e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT31_MSB"
      sgroup "LPG_LUT_LUT31_MSB (at 0x1b07f)"
        set &access:&cmd_addr %l (0x80b07f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb07f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT32_LSB"
      sgroup "LPG_LUT_LUT32_LSB (at 0x1b080)"
        set &access:&cmd_addr %l (0x80b0800|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0800|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT32_MSB"
      sgroup "LPG_LUT_LUT32_MSB (at 0x1b081)"
        set &access:&cmd_addr %l (0x80b0810|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0810|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT33_LSB"
      sgroup "LPG_LUT_LUT33_LSB (at 0x1b082)"
        set &access:&cmd_addr %l (0x80b0820|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0820|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT33_MSB"
      sgroup "LPG_LUT_LUT33_MSB (at 0x1b083)"
        set &access:&cmd_addr %l (0x80b0830|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0830|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT34_LSB"
      sgroup "LPG_LUT_LUT34_LSB (at 0x1b084)"
        set &access:&cmd_addr %l (0x80b0840|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0840|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT34_MSB"
      sgroup "LPG_LUT_LUT34_MSB (at 0x1b085)"
        set &access:&cmd_addr %l (0x80b0850|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0850|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT35_LSB"
      sgroup "LPG_LUT_LUT35_LSB (at 0x1b086)"
        set &access:&cmd_addr %l (0x80b0860|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0860|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT35_MSB"
      sgroup "LPG_LUT_LUT35_MSB (at 0x1b087)"
        set &access:&cmd_addr %l (0x80b0870|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0870|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT36_LSB"
      sgroup "LPG_LUT_LUT36_LSB (at 0x1b088)"
        set &access:&cmd_addr %l (0x80b0880|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0880|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT36_MSB"
      sgroup "LPG_LUT_LUT36_MSB (at 0x1b089)"
        set &access:&cmd_addr %l (0x80b0890|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0890|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT37_LSB"
      sgroup "LPG_LUT_LUT37_LSB (at 0x1b08a)"
        set &access:&cmd_addr %l (0x80b08a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb08a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT37_MSB"
      sgroup "LPG_LUT_LUT37_MSB (at 0x1b08b)"
        set &access:&cmd_addr %l (0x80b08b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb08b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT38_LSB"
      sgroup "LPG_LUT_LUT38_LSB (at 0x1b08c)"
        set &access:&cmd_addr %l (0x80b08c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb08c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT38_MSB"
      sgroup "LPG_LUT_LUT38_MSB (at 0x1b08d)"
        set &access:&cmd_addr %l (0x80b08d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb08d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT39_LSB"
      sgroup "LPG_LUT_LUT39_LSB (at 0x1b08e)"
        set &access:&cmd_addr %l (0x80b08e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb08e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT39_MSB"
      sgroup "LPG_LUT_LUT39_MSB (at 0x1b08f)"
        set &access:&cmd_addr %l (0x80b08f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb08f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT40_LSB"
      sgroup "LPG_LUT_LUT40_LSB (at 0x1b090)"
        set &access:&cmd_addr %l (0x80b0900|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0900|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT40_MSB"
      sgroup "LPG_LUT_LUT40_MSB (at 0x1b091)"
        set &access:&cmd_addr %l (0x80b0910|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0910|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT41_LSB"
      sgroup "LPG_LUT_LUT41_LSB (at 0x1b092)"
        set &access:&cmd_addr %l (0x80b0920|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0920|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT41_MSB"
      sgroup "LPG_LUT_LUT41_MSB (at 0x1b093)"
        set &access:&cmd_addr %l (0x80b0930|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0930|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT42_LSB"
      sgroup "LPG_LUT_LUT42_LSB (at 0x1b094)"
        set &access:&cmd_addr %l (0x80b0940|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0940|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT42_MSB"
      sgroup "LPG_LUT_LUT42_MSB (at 0x1b095)"
        set &access:&cmd_addr %l (0x80b0950|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0950|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT43_LSB"
      sgroup "LPG_LUT_LUT43_LSB (at 0x1b096)"
        set &access:&cmd_addr %l (0x80b0960|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0960|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT43_MSB"
      sgroup "LPG_LUT_LUT43_MSB (at 0x1b097)"
        set &access:&cmd_addr %l (0x80b0970|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0970|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT44_LSB"
      sgroup "LPG_LUT_LUT44_LSB (at 0x1b098)"
        set &access:&cmd_addr %l (0x80b0980|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0980|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT44_MSB"
      sgroup "LPG_LUT_LUT44_MSB (at 0x1b099)"
        set &access:&cmd_addr %l (0x80b0990|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0990|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT45_LSB"
      sgroup "LPG_LUT_LUT45_LSB (at 0x1b09a)"
        set &access:&cmd_addr %l (0x80b09a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb09a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT45_MSB"
      sgroup "LPG_LUT_LUT45_MSB (at 0x1b09b)"
        set &access:&cmd_addr %l (0x80b09b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb09b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT46_LSB"
      sgroup "LPG_LUT_LUT46_LSB (at 0x1b09c)"
        set &access:&cmd_addr %l (0x80b09c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb09c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT46_MSB"
      sgroup "LPG_LUT_LUT46_MSB (at 0x1b09d)"
        set &access:&cmd_addr %l (0x80b09d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb09d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT47_LSB"
      sgroup "LPG_LUT_LUT47_LSB (at 0x1b09e)"
        set &access:&cmd_addr %l (0x80b09e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb09e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT47_MSB"
      sgroup "LPG_LUT_LUT47_MSB (at 0x1b09f)"
        set &access:&cmd_addr %l (0x80b09f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb09f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT48_LSB"
      sgroup "LPG_LUT_LUT48_LSB (at 0x1b0a0)"
        set &access:&cmd_addr %l (0x80b0a00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT48_MSB"
      sgroup "LPG_LUT_LUT48_MSB (at 0x1b0a1)"
        set &access:&cmd_addr %l (0x80b0a10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT49_LSB"
      sgroup "LPG_LUT_LUT49_LSB (at 0x1b0a2)"
        set &access:&cmd_addr %l (0x80b0a20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT49_MSB"
      sgroup "LPG_LUT_LUT49_MSB (at 0x1b0a3)"
        set &access:&cmd_addr %l (0x80b0a30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT50_LSB"
      sgroup "LPG_LUT_LUT50_LSB (at 0x1b0a4)"
        set &access:&cmd_addr %l (0x80b0a40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT50_MSB"
      sgroup "LPG_LUT_LUT50_MSB (at 0x1b0a5)"
        set &access:&cmd_addr %l (0x80b0a50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT51_LSB"
      sgroup "LPG_LUT_LUT51_LSB (at 0x1b0a6)"
        set &access:&cmd_addr %l (0x80b0a60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT51_MSB"
      sgroup "LPG_LUT_LUT51_MSB (at 0x1b0a7)"
        set &access:&cmd_addr %l (0x80b0a70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT52_LSB"
      sgroup "LPG_LUT_LUT52_LSB (at 0x1b0a8)"
        set &access:&cmd_addr %l (0x80b0a80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT52_MSB"
      sgroup "LPG_LUT_LUT52_MSB (at 0x1b0a9)"
        set &access:&cmd_addr %l (0x80b0a90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0a90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT53_LSB"
      sgroup "LPG_LUT_LUT53_LSB (at 0x1b0aa)"
        set &access:&cmd_addr %l (0x80b0aa0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0aa0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT53_MSB"
      sgroup "LPG_LUT_LUT53_MSB (at 0x1b0ab)"
        set &access:&cmd_addr %l (0x80b0ab0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0ab0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT54_LSB"
      sgroup "LPG_LUT_LUT54_LSB (at 0x1b0ac)"
        set &access:&cmd_addr %l (0x80b0ac0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0ac0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT54_MSB"
      sgroup "LPG_LUT_LUT54_MSB (at 0x1b0ad)"
        set &access:&cmd_addr %l (0x80b0ad0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0ad0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT55_LSB"
      sgroup "LPG_LUT_LUT55_LSB (at 0x1b0ae)"
        set &access:&cmd_addr %l (0x80b0ae0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0ae0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT55_MSB"
      sgroup "LPG_LUT_LUT55_MSB (at 0x1b0af)"
        set &access:&cmd_addr %l (0x80b0af0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0af0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT56_LSB"
      sgroup "LPG_LUT_LUT56_LSB (at 0x1b0b0)"
        set &access:&cmd_addr %l (0x80b0b00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT56_MSB"
      sgroup "LPG_LUT_LUT56_MSB (at 0x1b0b1)"
        set &access:&cmd_addr %l (0x80b0b10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT57_LSB"
      sgroup "LPG_LUT_LUT57_LSB (at 0x1b0b2)"
        set &access:&cmd_addr %l (0x80b0b20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT57_MSB"
      sgroup "LPG_LUT_LUT57_MSB (at 0x1b0b3)"
        set &access:&cmd_addr %l (0x80b0b30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT58_LSB"
      sgroup "LPG_LUT_LUT58_LSB (at 0x1b0b4)"
        set &access:&cmd_addr %l (0x80b0b40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT58_MSB"
      sgroup "LPG_LUT_LUT58_MSB (at 0x1b0b5)"
        set &access:&cmd_addr %l (0x80b0b50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT59_LSB"
      sgroup "LPG_LUT_LUT59_LSB (at 0x1b0b6)"
        set &access:&cmd_addr %l (0x80b0b60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT59_MSB"
      sgroup "LPG_LUT_LUT59_MSB (at 0x1b0b7)"
        set &access:&cmd_addr %l (0x80b0b70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT60_LSB"
      sgroup "LPG_LUT_LUT60_LSB (at 0x1b0b8)"
        set &access:&cmd_addr %l (0x80b0b80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT60_MSB"
      sgroup "LPG_LUT_LUT60_MSB (at 0x1b0b9)"
        set &access:&cmd_addr %l (0x80b0b90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0b90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT61_LSB"
      sgroup "LPG_LUT_LUT61_LSB (at 0x1b0ba)"
        set &access:&cmd_addr %l (0x80b0ba0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0ba0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT61_MSB"
      sgroup "LPG_LUT_LUT61_MSB (at 0x1b0bb)"
        set &access:&cmd_addr %l (0x80b0bb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0bb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT62_LSB"
      sgroup "LPG_LUT_LUT62_LSB (at 0x1b0bc)"
        set &access:&cmd_addr %l (0x80b0bc0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0bc0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT62_MSB"
      sgroup "LPG_LUT_LUT62_MSB (at 0x1b0bd)"
        set &access:&cmd_addr %l (0x80b0bd0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0bd0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT63_LSB"
      sgroup "LPG_LUT_LUT63_LSB (at 0x1b0be)"
        set &access:&cmd_addr %l (0x80b0be0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0be0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT63_MSB"
      sgroup "LPG_LUT_LUT63_MSB (at 0x1b0bf)"
        set &access:&cmd_addr %l (0x80b0bf0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0bf0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_RAMP_CONTROL"
      sgroup "LPG_LUT_RAMP_CONTROL (at 0x1b0c8)"
        set &access:&cmd_addr %l (0x80b0c80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0c80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S7_RAMP_START                            = " "0 (LPG8_RAMP_DIS),1 (LPG8_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   S6_RAMP_START                            = " "0 (LPG7_RAMP_DIS),1 (LPG7_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   S5_RAMP_START                            = " "0 (LPG6_RAMP_DIS),1 (LPG6_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   S4_RAMP_START                            = " "0 (LPG5_RAMP_DIS),1 (LPG5_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   S3_RAMP_START                            = " "0 (LPG4_RAMP_DIS),1 (LPG4_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   S2_RAMP_START                            = " "0 (LPG3_RAMP_DIS),1 (LPG3_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   S1_RAMP_START                            = " "0 (LPG2_RAMP_DIS),1 (LPG2_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   S0_RAMP_START                            = " "0 (LPG1_RAMP_DIS),1 (LPG1_RAMP_START)"
    tree.end
    tree "LPG_LUT_SEC_ACCESS"
      sgroup "LPG_LUT_SEC_ACCESS (at 0x1b0d0)"
        set &access:&cmd_addr %l (0x80b0d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL2"
      sgroup "LPG_LUT_PERPH_RESET_CTL2 (at 0x1b0d9)"
        set &access:&cmd_addr %l (0x80b0d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL3"
      sgroup "LPG_LUT_PERPH_RESET_CTL3 (at 0x1b0da)"
        set &access:&cmd_addr %l (0x80b0da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL4"
      sgroup "LPG_LUT_PERPH_RESET_CTL4 (at 0x1b0db)"
        set &access:&cmd_addr %l (0x80b0db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xb0db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "LVS1"
  tree "LVS1"
    tree "LVS1_REVISION1"
      sgroup "LVS1_REVISION1 (at 0x18000)"
        set &access:&cmd_addr %l (0x8080000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LVS1_REVISION2"
      sgroup "LVS1_REVISION2 (at 0x18001)"
        set &access:&cmd_addr %l (0x8080010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LVS1_REVISION3"
      sgroup "LVS1_REVISION3 (at 0x18002)"
        set &access:&cmd_addr %l (0x8080020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LVS1_REVISION4"
      sgroup "LVS1_REVISION4 (at 0x18003)"
        set &access:&cmd_addr %l (0x8080030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LVS1_PERPH_TYPE"
      sgroup "LVS1_PERPH_TYPE (at 0x18004)"
        set &access:&cmd_addr %l (0x8080040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LVS1_PERPH_SUBTYPE"
      sgroup "LVS1_PERPH_SUBTYPE (at 0x18005)"
        set &access:&cmd_addr %l (0x8080050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LVS1_STATUS1"
      sgroup "LVS1_STATUS1 (at 0x18008)"
        set &access:&cmd_addr %l (0x8080080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VS_NOT_OK),1 (VS_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVERCURRENT                              = " "0 (NO_OC_EVENT),1 (OC_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (LPM),1 (NPM)"
    tree.end
    tree "LVS1_INT_RT_STS"
      sgroup "LVS1_INT_RT_STS (at 0x18010)"
        set &access:&cmd_addr %l (0x8080100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "LVS1_INT_SET_TYPE"
      sgroup "LVS1_INT_SET_TYPE (at 0x18011)"
        set &access:&cmd_addr %l (0x8080110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LVS1_INT_POLARITY_HIGH"
      sgroup "LVS1_INT_POLARITY_HIGH (at 0x18012)"
        set &access:&cmd_addr %l (0x8080120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LVS1_INT_POLARITY_LOW"
      sgroup "LVS1_INT_POLARITY_LOW (at 0x18013)"
        set &access:&cmd_addr %l (0x8080130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LVS1_INT_LATCHED_CLR"
      sgroup "LVS1_INT_LATCHED_CLR (at 0x18014)"
        set &access:&cmd_addr %l (0x8080140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LVS1_INT_EN_SET"
      sgroup "LVS1_INT_EN_SET (at 0x18015)"
        set &access:&cmd_addr %l (0x8080150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LVS1_INT_EN_CLR"
      sgroup "LVS1_INT_EN_CLR (at 0x18016)"
        set &access:&cmd_addr %l (0x8080160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LVS1_INT_LATCHED_STS"
      sgroup "LVS1_INT_LATCHED_STS (at 0x18018)"
        set &access:&cmd_addr %l (0x8080180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LVS1_INT_PENDING_STS"
      sgroup "LVS1_INT_PENDING_STS (at 0x18019)"
        set &access:&cmd_addr %l (0x8080190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LVS1_INT_MID_SEL"
      sgroup "LVS1_INT_MID_SEL (at 0x1801a)"
        set &access:&cmd_addr %l (0x80801a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x801a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LVS1_INT_PRIORITY"
      sgroup "LVS1_INT_PRIORITY (at 0x1801b)"
        set &access:&cmd_addr %l (0x80801b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x801b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LVS1_MODE_CTL1"
      sgroup "LVS1_MODE_CTL1 (at 0x18045)"
        set &access:&cmd_addr %l (0x8080450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NO_FORCE),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO                                     = " "0 (NO_AUTO),1 (AUTO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
    tree.end
    tree "LVS1_EN_CTL1"
      sgroup "LVS1_EN_CTL1 (at 0x18046)"
        set &access:&cmd_addr %l (0x8080460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (NO_FORCE),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (NO_FOLLOW),1 (FOLLOW_HWEN)"
    tree.end
    tree "LVS1_PD_CTL"
      sgroup "LVS1_PD_CTL (at 0x18048)"
        set &access:&cmd_addr %l (0x8080480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "LVS1_CURRENT_LIM_CTL"
      sgroup "LVS1_CURRENT_LIM_CTL (at 0x1804a)"
        set &access:&cmd_addr %l (0x80804a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x804a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_OVERRIDE                             = " "0 (DISABLE_ON_OCP),1 (STAY_ENABLED_ON_OCP)"
    tree.end
    tree "LVS1_SOFT_START_CTL"
      sgroup "LVS1_SOFT_START_CTL (at 0x1804c)"
        set &access:&cmd_addr %l (0x80804c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x804c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_EN                            = " "0 (SOFTSTART_ENABLED),1 (SOFTSTART_DISABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SOFT_START_SEL                           = " "0 (SS_PD_50NA),1 (SS_PD_250NA),2 (SS_PD_550NA),3 (SS_PD_750NA)"
    tree.end
    tree "LVS1_SEC_ACCESS"
      sgroup "LVS1_SEC_ACCESS (at 0x180d0)"
        set &access:&cmd_addr %l (0x8080d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LVS1_PERPH_RESET_CTL1"
      sgroup "LVS1_PERPH_RESET_CTL1 (at 0x180d8)"
        set &access:&cmd_addr %l (0x8080d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LVS1_PERPH_RESET_CTL2"
      sgroup "LVS1_PERPH_RESET_CTL2 (at 0x180d9)"
        set &access:&cmd_addr %l (0x8080d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LVS1_PERPH_RESET_CTL3"
      sgroup "LVS1_PERPH_RESET_CTL3 (at 0x180da)"
        set &access:&cmd_addr %l (0x8080da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LVS1_PERPH_RESET_CTL4"
      sgroup "LVS1_PERPH_RESET_CTL4 (at 0x180db)"
        set &access:&cmd_addr %l (0x8080db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LVS1_INT_TEST1"
      sgroup "LVS1_INT_TEST1 (at 0x180e0)"
        set &access:&cmd_addr %l (0x8080e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LVS1_INT_TEST_VAL"
      sgroup "LVS1_INT_TEST_VAL (at 0x180e1)"
        set &access:&cmd_addr %l (0x8080e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERCURRENT_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LVS1_TEST1"
      sgroup "LVS1_TEST1 (at 0x180e2)"
        set &access:&cmd_addr %l (0x8080e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_TM                               = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST_SEL                                = " "0 (DISABLE_RDS_ON_TEST),1 (ENABLE_RDS_ON_TEST)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DTEST_SEL                                = " "0 (DTEST_DISABLED),1 (DTEST_VOUT_OK),2 (DTEST_OCP),3 (RESERVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TM                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "LVS1_TRIM_NUM"
      sgroup "LVS1_TRIM_NUM (at 0x180f0)"
        set &access:&cmd_addr %l (0x8080f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LVS1_TRIM1"
      sgroup "LVS1_TRIM1 (at 0x180f1)"
        set &access:&cmd_addr %l (0x8080f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   OTA_TRIM                                 = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   OCP_TRIM                                 = " "0 (MINUS_10PCT),1 (MINUS_20PCT),2 (MINUS_30PCT),3 (MINUS_40PCT),4 (PLUS_30PCT),5 (PLUS_20PCT),6 (PLUS_10PCT),7 (NOMINAL_450MA)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&cmd_addr %l (0x802c000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&cmd_addr %l (0x802c010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&cmd_addr %l (0x802c020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&cmd_addr %l (0x802c030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&cmd_addr %l (0x802c040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&cmd_addr %l (0x802c050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&cmd_addr %l (0x802c080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_OK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (MBG_LPM),1 (MBG_NPM)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&cmd_addr %l (0x802c440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0 (NO_FORCE_LPM),1 (FORCE_NPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0 (NO_FOLLOW),1 (FOLLOW_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0 (NORMAL_MODE),1 (FORCE_FAST_VBG)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0 (NO_FORCE_IPTAT),1 (FORCE_IPTAT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0 (NO_FORCE_IREF),1 (FORCE_IREF)"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&cmd_addr %l (0x802c460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2c460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0 (MBG_DISABLED),1 (MBG_ENABLED)"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&cmd_addr %l (0x802cd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&cmd_addr %l (0x802cd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&cmd_addr %l (0x802cd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&cmd_addr %l (0x802cda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&cmd_addr %l (0x802cdb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cdb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&cmd_addr %l (0x802ce20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2ce20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&cmd_addr %l (0x802ce30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2ce30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&cmd_addr %l (0x802cf00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&cmd_addr %l (0x802cf10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&cmd_addr %l (0x802cf20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&cmd_addr %l (0x802cf30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&cmd_addr %l (0x802cf40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&cmd_addr %l (0x802cf50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&cmd_addr %l (0x802cf60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&cmd_addr %l (0x802cf70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&cmd_addr %l (0x802cf80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x2cf80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&cmd_addr %l (0x8009000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&cmd_addr %l (0x8009010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&cmd_addr %l (0x8009020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&cmd_addr %l (0x8009030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&cmd_addr %l (0x8009040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&cmd_addr %l (0x8009050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS1"
      sgroup "MISC_STATUS1 (at 0x908)"
        set &access:&cmd_addr %l (0x8009080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USB_HOST_DETECTED                        = " "0 (NO_USB_HOST_DETECTED),1 (USB_HOST_DETECTED)"
    tree.end
    tree "MISC_INT_RT_STS"
      sgroup "MISC_INT_RT_STS (at 0x910)"
        set &access:&cmd_addr %l (0x8009100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_STS                            = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MISC_INT_SET_TYPE"
      sgroup "MISC_INT_SET_TYPE (at 0x911)"
        set &access:&cmd_addr %l (0x8009110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MISC_INT_POLARITY_HIGH"
      sgroup "MISC_INT_POLARITY_HIGH (at 0x912)"
        set &access:&cmd_addr %l (0x8009120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_POLARITY_HIGH                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MISC_INT_POLARITY_LOW"
      sgroup "MISC_INT_POLARITY_LOW (at 0x913)"
        set &access:&cmd_addr %l (0x8009130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_POLARITY_LOW                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MISC_INT_LATCHED_CLR"
      sgroup "MISC_INT_LATCHED_CLR (at 0x914)"
        set &access:&cmd_addr %l (0x8009140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_CLR                            = " "0, 1"
    tree.end
    tree "MISC_INT_EN_SET"
      sgroup "MISC_INT_EN_SET (at 0x915)"
        set &access:&cmd_addr %l (0x8009150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MISC_INT_EN_CLR"
      sgroup "MISC_INT_EN_CLR (at 0x916)"
        set &access:&cmd_addr %l (0x8009160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MISC_INT_LATCHED_STS"
      sgroup "MISC_INT_LATCHED_STS (at 0x918)"
        set &access:&cmd_addr %l (0x8009180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MISC_INT_PENDING_STS"
      sgroup "MISC_INT_PENDING_STS (at 0x919)"
        set &access:&cmd_addr %l (0x8009190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBID_INT_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MISC_INT_MID_SEL"
      sgroup "MISC_INT_MID_SEL (at 0x91a)"
        set &access:&cmd_addr %l (0x80091a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x91a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MISC_INT_PRIORITY"
      sgroup "MISC_INT_PRIORITY (at 0x91b)"
        set &access:&cmd_addr %l (0x80091b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x91b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MISC_TEST_CONNECT"
      sgroup "MISC_TEST_CONNECT (at 0x940)"
        set &access:&cmd_addr %l (0x8009400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_CONNECT                            = " "0 (ATEST_CON_DISABLED),1 (ATEST_CON_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST_CONNECT_1                          = " "0 (DTEST_CON1_DISABLED),1 (DTEST_CON1_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_CONNECT_0                          = " "0 (DTEST_CON0_DISABLED),1 (DTEST_CON0_ENABLED)"
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      sgroup "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
        set &access:&cmd_addr %l (0x8009420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XVDD_DVDD_SRC_CTRL                       = " "0 (reserved),1 (USE_LDO),2 (DO_NOT_USE_LDO),3 (reserved)"
    tree.end
    tree "MISC_LED_IZTC_CTL"
      sgroup "MISC_LED_IZTC_CTL (at 0x943)"
        set &access:&cmd_addr %l (0x8009430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ATEST_LED_IZTC                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_MISC_OPTIONS"
      sgroup "MISC_MISC_OPTIONS (at 0x944)"
        set &access:&cmd_addr %l (0x8009440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIM_EN                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_BUCK_CMN_CTL1"
      sgroup "MISC_BUCK_CMN_CTL1 (at 0x945)"
        set &access:&cmd_addr %l (0x8009450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYPASS_IBG_DLY                           = " "0 (BYPASS_DISABLED),1 (BYPASS_ENABLED)"
    tree.end
    tree "MISC_USB_ID_CTL1"
      sgroup "MISC_USB_ID_CTL1 (at 0x946)"
        set &access:&cmd_addr %l (0x8009460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USB_ID_PU_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_ID_LVDET_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USB_ID_IIDPU_EN                          = " "0, 1"
    tree.end
    tree "MISC_S5_DF_CTL"
      sgroup "MISC_S5_DF_CTL (at 0x947)"
        set &access:&cmd_addr %l (0x8009470|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9470|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S5_FORCE_RESET                           = " "0 (S5_USABLE),1 (S5_DEFEATURED)"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&cmd_addr %l (0x8009d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&cmd_addr %l (0x8009d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&cmd_addr %l (0x8009da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&cmd_addr %l (0x8009db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_INT_TEST1"
      sgroup "MISC_INT_TEST1 (at 0x9dc)"
        set &access:&cmd_addr %l (0x8009dc0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9dc0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "MISC_INT_TEST_VAL"
      sgroup "MISC_INT_TEST_VAL (at 0x9de)"
        set &access:&cmd_addr %l (0x8009de0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9de0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_ID_TEST_VAL                          = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&cmd_addr %l (0x8009e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&cmd_addr %l (0x8009f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "MISC_IZTC_TRIM"
      sgroup "MISC_IZTC_TRIM (at 0x9f1)"
        set &access:&cmd_addr %l (0x8009f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x9f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IZTC_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      sgroup "MPP1_REVISION1 (at 0xa000)"
        set &access:&cmd_addr %l (0x80a0000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      sgroup "MPP1_REVISION2 (at 0xa001)"
        set &access:&cmd_addr %l (0x80a0010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      sgroup "MPP1_REVISION3 (at 0xa002)"
        set &access:&cmd_addr %l (0x80a0020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      sgroup "MPP1_REVISION4 (at 0xa003)"
        set &access:&cmd_addr %l (0x80a0030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      sgroup "MPP1_PERPH_TYPE (at 0xa004)"
        set &access:&cmd_addr %l (0x80a0040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      sgroup "MPP1_PERPH_SUBTYPE (at 0xa005)"
        set &access:&cmd_addr %l (0x80a0050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      sgroup "MPP1_STATUS1 (at 0xa008)"
        set &access:&cmd_addr %l (0x80a0080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP1_INT_RT_STS"
      sgroup "MPP1_INT_RT_STS (at 0xa010)"
        set &access:&cmd_addr %l (0x80a0100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      sgroup "MPP1_INT_SET_TYPE (at 0xa011)"
        set &access:&cmd_addr %l (0x80a0110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      sgroup "MPP1_INT_POLARITY_HIGH (at 0xa012)"
        set &access:&cmd_addr %l (0x80a0120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      sgroup "MPP1_INT_POLARITY_LOW (at 0xa013)"
        set &access:&cmd_addr %l (0x80a0130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      sgroup "MPP1_INT_LATCHED_CLR (at 0xa014)"
        set &access:&cmd_addr %l (0x80a0140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      sgroup "MPP1_INT_EN_SET (at 0xa015)"
        set &access:&cmd_addr %l (0x80a0150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_EN_CLR"
      sgroup "MPP1_INT_EN_CLR (at 0xa016)"
        set &access:&cmd_addr %l (0x80a0160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      sgroup "MPP1_INT_LATCHED_STS (at 0xa018)"
        set &access:&cmd_addr %l (0x80a0180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      sgroup "MPP1_INT_PENDING_STS (at 0xa019)"
        set &access:&cmd_addr %l (0x80a0190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP1_INT_MID_SEL"
      sgroup "MPP1_INT_MID_SEL (at 0xa01a)"
        set &access:&cmd_addr %l (0x80a01a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa01a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP1_INT_PRIORITY"
      sgroup "MPP1_INT_PRIORITY (at 0xa01b)"
        set &access:&cmd_addr %l (0x80a01b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa01b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP1_MODE_CTL"
      sgroup "MPP1_MODE_CTL (at 0xa040)"
        set &access:&cmd_addr %l (0x80a0400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      sgroup "MPP1_DIG_VIN_CTL (at 0xa041)"
        set &access:&cmd_addr %l (0x80a0410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      sgroup "MPP1_DIG_PULL_CTL (at 0xa042)"
        set &access:&cmd_addr %l (0x80a0420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      sgroup "MPP1_DIG_IN_CTL (at 0xa043)"
        set &access:&cmd_addr %l (0x80a0430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP1_EN_CTL"
      sgroup "MPP1_EN_CTL (at 0xa046)"
        set &access:&cmd_addr %l (0x80a0460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      sgroup "MPP1_ANA_OUT_CTL (at 0xa048)"
        set &access:&cmd_addr %l (0x80a0480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      sgroup "MPP1_ANA_IN_CTL (at 0xa04a)"
        set &access:&cmd_addr %l (0x80a04a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa04a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP1_SINK_CTL"
      sgroup "MPP1_SINK_CTL (at 0xa04c)"
        set &access:&cmd_addr %l (0x80a04c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa04c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP1_SEC_ACCESS"
      sgroup "MPP1_SEC_ACCESS (at 0xa0d0)"
        set &access:&cmd_addr %l (0x80a0d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      sgroup "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
        set &access:&cmd_addr %l (0x80a0d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      sgroup "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
        set &access:&cmd_addr %l (0x80a0d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      sgroup "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
        set &access:&cmd_addr %l (0x80a0da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      sgroup "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
        set &access:&cmd_addr %l (0x80a0db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa0db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      sgroup "MPP2_REVISION1 (at 0xa100)"
        set &access:&cmd_addr %l (0x80a1000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      sgroup "MPP2_REVISION2 (at 0xa101)"
        set &access:&cmd_addr %l (0x80a1010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      sgroup "MPP2_REVISION3 (at 0xa102)"
        set &access:&cmd_addr %l (0x80a1020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      sgroup "MPP2_REVISION4 (at 0xa103)"
        set &access:&cmd_addr %l (0x80a1030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      sgroup "MPP2_PERPH_TYPE (at 0xa104)"
        set &access:&cmd_addr %l (0x80a1040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      sgroup "MPP2_PERPH_SUBTYPE (at 0xa105)"
        set &access:&cmd_addr %l (0x80a1050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      sgroup "MPP2_STATUS1 (at 0xa108)"
        set &access:&cmd_addr %l (0x80a1080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP2_INT_RT_STS"
      sgroup "MPP2_INT_RT_STS (at 0xa110)"
        set &access:&cmd_addr %l (0x80a1100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      sgroup "MPP2_INT_SET_TYPE (at 0xa111)"
        set &access:&cmd_addr %l (0x80a1110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      sgroup "MPP2_INT_POLARITY_HIGH (at 0xa112)"
        set &access:&cmd_addr %l (0x80a1120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      sgroup "MPP2_INT_POLARITY_LOW (at 0xa113)"
        set &access:&cmd_addr %l (0x80a1130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      sgroup "MPP2_INT_LATCHED_CLR (at 0xa114)"
        set &access:&cmd_addr %l (0x80a1140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      sgroup "MPP2_INT_EN_SET (at 0xa115)"
        set &access:&cmd_addr %l (0x80a1150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_EN_CLR"
      sgroup "MPP2_INT_EN_CLR (at 0xa116)"
        set &access:&cmd_addr %l (0x80a1160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      sgroup "MPP2_INT_LATCHED_STS (at 0xa118)"
        set &access:&cmd_addr %l (0x80a1180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      sgroup "MPP2_INT_PENDING_STS (at 0xa119)"
        set &access:&cmd_addr %l (0x80a1190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP2_INT_MID_SEL"
      sgroup "MPP2_INT_MID_SEL (at 0xa11a)"
        set &access:&cmd_addr %l (0x80a11a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa11a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP2_INT_PRIORITY"
      sgroup "MPP2_INT_PRIORITY (at 0xa11b)"
        set &access:&cmd_addr %l (0x80a11b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa11b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP2_MODE_CTL"
      sgroup "MPP2_MODE_CTL (at 0xa140)"
        set &access:&cmd_addr %l (0x80a1400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      sgroup "MPP2_DIG_VIN_CTL (at 0xa141)"
        set &access:&cmd_addr %l (0x80a1410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      sgroup "MPP2_DIG_PULL_CTL (at 0xa142)"
        set &access:&cmd_addr %l (0x80a1420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      sgroup "MPP2_DIG_IN_CTL (at 0xa143)"
        set &access:&cmd_addr %l (0x80a1430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP2_EN_CTL"
      sgroup "MPP2_EN_CTL (at 0xa146)"
        set &access:&cmd_addr %l (0x80a1460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      sgroup "MPP2_ANA_OUT_CTL (at 0xa148)"
        set &access:&cmd_addr %l (0x80a1480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      sgroup "MPP2_ANA_IN_CTL (at 0xa14a)"
        set &access:&cmd_addr %l (0x80a14a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa14a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP2_SINK_CTL"
      sgroup "MPP2_SINK_CTL (at 0xa14c)"
        set &access:&cmd_addr %l (0x80a14c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa14c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP2_SEC_ACCESS"
      sgroup "MPP2_SEC_ACCESS (at 0xa1d0)"
        set &access:&cmd_addr %l (0x80a1d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      sgroup "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
        set &access:&cmd_addr %l (0x80a1d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      sgroup "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
        set &access:&cmd_addr %l (0x80a1d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      sgroup "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
        set &access:&cmd_addr %l (0x80a1da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      sgroup "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
        set &access:&cmd_addr %l (0x80a1db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa1db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      sgroup "MPP3_REVISION1 (at 0xa200)"
        set &access:&cmd_addr %l (0x80a2000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      sgroup "MPP3_REVISION2 (at 0xa201)"
        set &access:&cmd_addr %l (0x80a2010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      sgroup "MPP3_REVISION3 (at 0xa202)"
        set &access:&cmd_addr %l (0x80a2020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      sgroup "MPP3_REVISION4 (at 0xa203)"
        set &access:&cmd_addr %l (0x80a2030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      sgroup "MPP3_PERPH_TYPE (at 0xa204)"
        set &access:&cmd_addr %l (0x80a2040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      sgroup "MPP3_PERPH_SUBTYPE (at 0xa205)"
        set &access:&cmd_addr %l (0x80a2050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      sgroup "MPP3_STATUS1 (at 0xa208)"
        set &access:&cmd_addr %l (0x80a2080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP3_INT_RT_STS"
      sgroup "MPP3_INT_RT_STS (at 0xa210)"
        set &access:&cmd_addr %l (0x80a2100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      sgroup "MPP3_INT_SET_TYPE (at 0xa211)"
        set &access:&cmd_addr %l (0x80a2110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      sgroup "MPP3_INT_POLARITY_HIGH (at 0xa212)"
        set &access:&cmd_addr %l (0x80a2120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      sgroup "MPP3_INT_POLARITY_LOW (at 0xa213)"
        set &access:&cmd_addr %l (0x80a2130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      sgroup "MPP3_INT_LATCHED_CLR (at 0xa214)"
        set &access:&cmd_addr %l (0x80a2140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      sgroup "MPP3_INT_EN_SET (at 0xa215)"
        set &access:&cmd_addr %l (0x80a2150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_EN_CLR"
      sgroup "MPP3_INT_EN_CLR (at 0xa216)"
        set &access:&cmd_addr %l (0x80a2160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      sgroup "MPP3_INT_LATCHED_STS (at 0xa218)"
        set &access:&cmd_addr %l (0x80a2180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      sgroup "MPP3_INT_PENDING_STS (at 0xa219)"
        set &access:&cmd_addr %l (0x80a2190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP3_INT_MID_SEL"
      sgroup "MPP3_INT_MID_SEL (at 0xa21a)"
        set &access:&cmd_addr %l (0x80a21a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa21a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP3_INT_PRIORITY"
      sgroup "MPP3_INT_PRIORITY (at 0xa21b)"
        set &access:&cmd_addr %l (0x80a21b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa21b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP3_MODE_CTL"
      sgroup "MPP3_MODE_CTL (at 0xa240)"
        set &access:&cmd_addr %l (0x80a2400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      sgroup "MPP3_DIG_VIN_CTL (at 0xa241)"
        set &access:&cmd_addr %l (0x80a2410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      sgroup "MPP3_DIG_PULL_CTL (at 0xa242)"
        set &access:&cmd_addr %l (0x80a2420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      sgroup "MPP3_DIG_IN_CTL (at 0xa243)"
        set &access:&cmd_addr %l (0x80a2430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP3_EN_CTL"
      sgroup "MPP3_EN_CTL (at 0xa246)"
        set &access:&cmd_addr %l (0x80a2460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      sgroup "MPP3_ANA_OUT_CTL (at 0xa248)"
        set &access:&cmd_addr %l (0x80a2480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      sgroup "MPP3_ANA_IN_CTL (at 0xa24a)"
        set &access:&cmd_addr %l (0x80a24a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa24a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP3_SINK_CTL"
      sgroup "MPP3_SINK_CTL (at 0xa24c)"
        set &access:&cmd_addr %l (0x80a24c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa24c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP3_SEC_ACCESS"
      sgroup "MPP3_SEC_ACCESS (at 0xa2d0)"
        set &access:&cmd_addr %l (0x80a2d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      sgroup "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
        set &access:&cmd_addr %l (0x80a2d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      sgroup "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
        set &access:&cmd_addr %l (0x80a2d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      sgroup "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
        set &access:&cmd_addr %l (0x80a2da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      sgroup "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
        set &access:&cmd_addr %l (0x80a2db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa2db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      sgroup "MPP4_REVISION1 (at 0xa300)"
        set &access:&cmd_addr %l (0x80a3000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      sgroup "MPP4_REVISION2 (at 0xa301)"
        set &access:&cmd_addr %l (0x80a3010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      sgroup "MPP4_REVISION3 (at 0xa302)"
        set &access:&cmd_addr %l (0x80a3020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      sgroup "MPP4_REVISION4 (at 0xa303)"
        set &access:&cmd_addr %l (0x80a3030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      sgroup "MPP4_PERPH_TYPE (at 0xa304)"
        set &access:&cmd_addr %l (0x80a3040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      sgroup "MPP4_PERPH_SUBTYPE (at 0xa305)"
        set &access:&cmd_addr %l (0x80a3050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      sgroup "MPP4_STATUS1 (at 0xa308)"
        set &access:&cmd_addr %l (0x80a3080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP4_INT_RT_STS"
      sgroup "MPP4_INT_RT_STS (at 0xa310)"
        set &access:&cmd_addr %l (0x80a3100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      sgroup "MPP4_INT_SET_TYPE (at 0xa311)"
        set &access:&cmd_addr %l (0x80a3110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      sgroup "MPP4_INT_POLARITY_HIGH (at 0xa312)"
        set &access:&cmd_addr %l (0x80a3120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      sgroup "MPP4_INT_POLARITY_LOW (at 0xa313)"
        set &access:&cmd_addr %l (0x80a3130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      sgroup "MPP4_INT_LATCHED_CLR (at 0xa314)"
        set &access:&cmd_addr %l (0x80a3140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      sgroup "MPP4_INT_EN_SET (at 0xa315)"
        set &access:&cmd_addr %l (0x80a3150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_EN_CLR"
      sgroup "MPP4_INT_EN_CLR (at 0xa316)"
        set &access:&cmd_addr %l (0x80a3160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      sgroup "MPP4_INT_LATCHED_STS (at 0xa318)"
        set &access:&cmd_addr %l (0x80a3180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      sgroup "MPP4_INT_PENDING_STS (at 0xa319)"
        set &access:&cmd_addr %l (0x80a3190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP4_INT_MID_SEL"
      sgroup "MPP4_INT_MID_SEL (at 0xa31a)"
        set &access:&cmd_addr %l (0x80a31a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa31a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP4_INT_PRIORITY"
      sgroup "MPP4_INT_PRIORITY (at 0xa31b)"
        set &access:&cmd_addr %l (0x80a31b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa31b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP4_MODE_CTL"
      sgroup "MPP4_MODE_CTL (at 0xa340)"
        set &access:&cmd_addr %l (0x80a3400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      sgroup "MPP4_DIG_VIN_CTL (at 0xa341)"
        set &access:&cmd_addr %l (0x80a3410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      sgroup "MPP4_DIG_PULL_CTL (at 0xa342)"
        set &access:&cmd_addr %l (0x80a3420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      sgroup "MPP4_DIG_IN_CTL (at 0xa343)"
        set &access:&cmd_addr %l (0x80a3430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP4_EN_CTL"
      sgroup "MPP4_EN_CTL (at 0xa346)"
        set &access:&cmd_addr %l (0x80a3460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      sgroup "MPP4_ANA_OUT_CTL (at 0xa348)"
        set &access:&cmd_addr %l (0x80a3480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      sgroup "MPP4_ANA_IN_CTL (at 0xa34a)"
        set &access:&cmd_addr %l (0x80a34a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa34a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP4_SINK_CTL"
      sgroup "MPP4_SINK_CTL (at 0xa34c)"
        set &access:&cmd_addr %l (0x80a34c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa34c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP4_SEC_ACCESS"
      sgroup "MPP4_SEC_ACCESS (at 0xa3d0)"
        set &access:&cmd_addr %l (0x80a3d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      sgroup "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
        set &access:&cmd_addr %l (0x80a3d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      sgroup "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
        set &access:&cmd_addr %l (0x80a3d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      sgroup "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
        set &access:&cmd_addr %l (0x80a3da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      sgroup "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
        set &access:&cmd_addr %l (0x80a3db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa3db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP5"
  tree "MPP5"
    tree "MPP5_REVISION1"
      sgroup "MPP5_REVISION1 (at 0xa400)"
        set &access:&cmd_addr %l (0x80a4000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP5_REVISION2"
      sgroup "MPP5_REVISION2 (at 0xa401)"
        set &access:&cmd_addr %l (0x80a4010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP5_REVISION3"
      sgroup "MPP5_REVISION3 (at 0xa402)"
        set &access:&cmd_addr %l (0x80a4020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP5_REVISION4"
      sgroup "MPP5_REVISION4 (at 0xa403)"
        set &access:&cmd_addr %l (0x80a4030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP5_PERPH_TYPE"
      sgroup "MPP5_PERPH_TYPE (at 0xa404)"
        set &access:&cmd_addr %l (0x80a4040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP5_PERPH_SUBTYPE"
      sgroup "MPP5_PERPH_SUBTYPE (at 0xa405)"
        set &access:&cmd_addr %l (0x80a4050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP5_STATUS1"
      sgroup "MPP5_STATUS1 (at 0xa408)"
        set &access:&cmd_addr %l (0x80a4080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP5_INT_RT_STS"
      sgroup "MPP5_INT_RT_STS (at 0xa410)"
        set &access:&cmd_addr %l (0x80a4100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP5_INT_SET_TYPE"
      sgroup "MPP5_INT_SET_TYPE (at 0xa411)"
        set &access:&cmd_addr %l (0x80a4110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP5_INT_POLARITY_HIGH"
      sgroup "MPP5_INT_POLARITY_HIGH (at 0xa412)"
        set &access:&cmd_addr %l (0x80a4120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_POLARITY_LOW"
      sgroup "MPP5_INT_POLARITY_LOW (at 0xa413)"
        set &access:&cmd_addr %l (0x80a4130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_CLR"
      sgroup "MPP5_INT_LATCHED_CLR (at 0xa414)"
        set &access:&cmd_addr %l (0x80a4140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP5_INT_EN_SET"
      sgroup "MPP5_INT_EN_SET (at 0xa415)"
        set &access:&cmd_addr %l (0x80a4150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_EN_CLR"
      sgroup "MPP5_INT_EN_CLR (at 0xa416)"
        set &access:&cmd_addr %l (0x80a4160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP5_INT_LATCHED_STS"
      sgroup "MPP5_INT_LATCHED_STS (at 0xa418)"
        set &access:&cmd_addr %l (0x80a4180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP5_INT_PENDING_STS"
      sgroup "MPP5_INT_PENDING_STS (at 0xa419)"
        set &access:&cmd_addr %l (0x80a4190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP5_INT_MID_SEL"
      sgroup "MPP5_INT_MID_SEL (at 0xa41a)"
        set &access:&cmd_addr %l (0x80a41a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa41a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP5_INT_PRIORITY"
      sgroup "MPP5_INT_PRIORITY (at 0xa41b)"
        set &access:&cmd_addr %l (0x80a41b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa41b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP5_MODE_CTL"
      sgroup "MPP5_MODE_CTL (at 0xa440)"
        set &access:&cmd_addr %l (0x80a4400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP5_DIG_VIN_CTL"
      sgroup "MPP5_DIG_VIN_CTL (at 0xa441)"
        set &access:&cmd_addr %l (0x80a4410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_PULL_CTL"
      sgroup "MPP5_DIG_PULL_CTL (at 0xa442)"
        set &access:&cmd_addr %l (0x80a4420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP5_DIG_IN_CTL"
      sgroup "MPP5_DIG_IN_CTL (at 0xa443)"
        set &access:&cmd_addr %l (0x80a4430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP5_EN_CTL"
      sgroup "MPP5_EN_CTL (at 0xa446)"
        set &access:&cmd_addr %l (0x80a4460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP5_ANA_OUT_CTL"
      sgroup "MPP5_ANA_OUT_CTL (at 0xa448)"
        set &access:&cmd_addr %l (0x80a4480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_ANA_IN_CTL"
      sgroup "MPP5_ANA_IN_CTL (at 0xa44a)"
        set &access:&cmd_addr %l (0x80a44a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa44a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP5_SINK_CTL"
      sgroup "MPP5_SINK_CTL (at 0xa44c)"
        set &access:&cmd_addr %l (0x80a44c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa44c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP5_SEC_ACCESS"
      sgroup "MPP5_SEC_ACCESS (at 0xa4d0)"
        set &access:&cmd_addr %l (0x80a4d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP5_PERPH_RESET_CTL1"
      sgroup "MPP5_PERPH_RESET_CTL1 (at 0xa4d8)"
        set &access:&cmd_addr %l (0x80a4d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL2"
      sgroup "MPP5_PERPH_RESET_CTL2 (at 0xa4d9)"
        set &access:&cmd_addr %l (0x80a4d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL3"
      sgroup "MPP5_PERPH_RESET_CTL3 (at 0xa4da)"
        set &access:&cmd_addr %l (0x80a4da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP5_PERPH_RESET_CTL4"
      sgroup "MPP5_PERPH_RESET_CTL4 (at 0xa4db)"
        set &access:&cmd_addr %l (0x80a4db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa4db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP6"
  tree "MPP6"
    tree "MPP6_REVISION1"
      sgroup "MPP6_REVISION1 (at 0xa500)"
        set &access:&cmd_addr %l (0x80a5000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP6_REVISION2"
      sgroup "MPP6_REVISION2 (at 0xa501)"
        set &access:&cmd_addr %l (0x80a5010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP6_REVISION3"
      sgroup "MPP6_REVISION3 (at 0xa502)"
        set &access:&cmd_addr %l (0x80a5020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP6_REVISION4"
      sgroup "MPP6_REVISION4 (at 0xa503)"
        set &access:&cmd_addr %l (0x80a5030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP6_PERPH_TYPE"
      sgroup "MPP6_PERPH_TYPE (at 0xa504)"
        set &access:&cmd_addr %l (0x80a5040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP6_PERPH_SUBTYPE"
      sgroup "MPP6_PERPH_SUBTYPE (at 0xa505)"
        set &access:&cmd_addr %l (0x80a5050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP6_STATUS1"
      sgroup "MPP6_STATUS1 (at 0xa508)"
        set &access:&cmd_addr %l (0x80a5080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP6_INT_RT_STS"
      sgroup "MPP6_INT_RT_STS (at 0xa510)"
        set &access:&cmd_addr %l (0x80a5100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP6_INT_SET_TYPE"
      sgroup "MPP6_INT_SET_TYPE (at 0xa511)"
        set &access:&cmd_addr %l (0x80a5110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP6_INT_POLARITY_HIGH"
      sgroup "MPP6_INT_POLARITY_HIGH (at 0xa512)"
        set &access:&cmd_addr %l (0x80a5120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_POLARITY_LOW"
      sgroup "MPP6_INT_POLARITY_LOW (at 0xa513)"
        set &access:&cmd_addr %l (0x80a5130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_CLR"
      sgroup "MPP6_INT_LATCHED_CLR (at 0xa514)"
        set &access:&cmd_addr %l (0x80a5140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP6_INT_EN_SET"
      sgroup "MPP6_INT_EN_SET (at 0xa515)"
        set &access:&cmd_addr %l (0x80a5150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_EN_CLR"
      sgroup "MPP6_INT_EN_CLR (at 0xa516)"
        set &access:&cmd_addr %l (0x80a5160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP6_INT_LATCHED_STS"
      sgroup "MPP6_INT_LATCHED_STS (at 0xa518)"
        set &access:&cmd_addr %l (0x80a5180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP6_INT_PENDING_STS"
      sgroup "MPP6_INT_PENDING_STS (at 0xa519)"
        set &access:&cmd_addr %l (0x80a5190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP6_INT_MID_SEL"
      sgroup "MPP6_INT_MID_SEL (at 0xa51a)"
        set &access:&cmd_addr %l (0x80a51a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa51a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP6_INT_PRIORITY"
      sgroup "MPP6_INT_PRIORITY (at 0xa51b)"
        set &access:&cmd_addr %l (0x80a51b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa51b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP6_MODE_CTL"
      sgroup "MPP6_MODE_CTL (at 0xa540)"
        set &access:&cmd_addr %l (0x80a5400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP6_DIG_VIN_CTL"
      sgroup "MPP6_DIG_VIN_CTL (at 0xa541)"
        set &access:&cmd_addr %l (0x80a5410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_PULL_CTL"
      sgroup "MPP6_DIG_PULL_CTL (at 0xa542)"
        set &access:&cmd_addr %l (0x80a5420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP6_DIG_IN_CTL"
      sgroup "MPP6_DIG_IN_CTL (at 0xa543)"
        set &access:&cmd_addr %l (0x80a5430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP6_EN_CTL"
      sgroup "MPP6_EN_CTL (at 0xa546)"
        set &access:&cmd_addr %l (0x80a5460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP6_ANA_OUT_CTL"
      sgroup "MPP6_ANA_OUT_CTL (at 0xa548)"
        set &access:&cmd_addr %l (0x80a5480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_ANA_IN_CTL"
      sgroup "MPP6_ANA_IN_CTL (at 0xa54a)"
        set &access:&cmd_addr %l (0x80a54a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa54a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP6_SINK_CTL"
      sgroup "MPP6_SINK_CTL (at 0xa54c)"
        set &access:&cmd_addr %l (0x80a54c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa54c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP6_SEC_ACCESS"
      sgroup "MPP6_SEC_ACCESS (at 0xa5d0)"
        set &access:&cmd_addr %l (0x80a5d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP6_PERPH_RESET_CTL1"
      sgroup "MPP6_PERPH_RESET_CTL1 (at 0xa5d8)"
        set &access:&cmd_addr %l (0x80a5d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL2"
      sgroup "MPP6_PERPH_RESET_CTL2 (at 0xa5d9)"
        set &access:&cmd_addr %l (0x80a5d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL3"
      sgroup "MPP6_PERPH_RESET_CTL3 (at 0xa5da)"
        set &access:&cmd_addr %l (0x80a5da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP6_PERPH_RESET_CTL4"
      sgroup "MPP6_PERPH_RESET_CTL4 (at 0xa5db)"
        set &access:&cmd_addr %l (0x80a5db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa5db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP7"
  tree "MPP7"
    tree "MPP7_REVISION1"
      sgroup "MPP7_REVISION1 (at 0xa600)"
        set &access:&cmd_addr %l (0x80a6000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP7_REVISION2"
      sgroup "MPP7_REVISION2 (at 0xa601)"
        set &access:&cmd_addr %l (0x80a6010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP7_REVISION3"
      sgroup "MPP7_REVISION3 (at 0xa602)"
        set &access:&cmd_addr %l (0x80a6020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP7_REVISION4"
      sgroup "MPP7_REVISION4 (at 0xa603)"
        set &access:&cmd_addr %l (0x80a6030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP7_PERPH_TYPE"
      sgroup "MPP7_PERPH_TYPE (at 0xa604)"
        set &access:&cmd_addr %l (0x80a6040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP7_PERPH_SUBTYPE"
      sgroup "MPP7_PERPH_SUBTYPE (at 0xa605)"
        set &access:&cmd_addr %l (0x80a6050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP7_STATUS1"
      sgroup "MPP7_STATUS1 (at 0xa608)"
        set &access:&cmd_addr %l (0x80a6080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP7_INT_RT_STS"
      sgroup "MPP7_INT_RT_STS (at 0xa610)"
        set &access:&cmd_addr %l (0x80a6100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP7_INT_SET_TYPE"
      sgroup "MPP7_INT_SET_TYPE (at 0xa611)"
        set &access:&cmd_addr %l (0x80a6110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP7_INT_POLARITY_HIGH"
      sgroup "MPP7_INT_POLARITY_HIGH (at 0xa612)"
        set &access:&cmd_addr %l (0x80a6120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP7_INT_POLARITY_LOW"
      sgroup "MPP7_INT_POLARITY_LOW (at 0xa613)"
        set &access:&cmd_addr %l (0x80a6130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP7_INT_LATCHED_CLR"
      sgroup "MPP7_INT_LATCHED_CLR (at 0xa614)"
        set &access:&cmd_addr %l (0x80a6140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP7_INT_EN_SET"
      sgroup "MPP7_INT_EN_SET (at 0xa615)"
        set &access:&cmd_addr %l (0x80a6150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP7_INT_EN_CLR"
      sgroup "MPP7_INT_EN_CLR (at 0xa616)"
        set &access:&cmd_addr %l (0x80a6160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP7_INT_LATCHED_STS"
      sgroup "MPP7_INT_LATCHED_STS (at 0xa618)"
        set &access:&cmd_addr %l (0x80a6180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP7_INT_PENDING_STS"
      sgroup "MPP7_INT_PENDING_STS (at 0xa619)"
        set &access:&cmd_addr %l (0x80a6190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP7_INT_MID_SEL"
      sgroup "MPP7_INT_MID_SEL (at 0xa61a)"
        set &access:&cmd_addr %l (0x80a61a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa61a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP7_INT_PRIORITY"
      sgroup "MPP7_INT_PRIORITY (at 0xa61b)"
        set &access:&cmd_addr %l (0x80a61b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa61b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP7_MODE_CTL"
      sgroup "MPP7_MODE_CTL (at 0xa640)"
        set &access:&cmd_addr %l (0x80a6400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP7_DIG_VIN_CTL"
      sgroup "MPP7_DIG_VIN_CTL (at 0xa641)"
        set &access:&cmd_addr %l (0x80a6410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP7_DIG_PULL_CTL"
      sgroup "MPP7_DIG_PULL_CTL (at 0xa642)"
        set &access:&cmd_addr %l (0x80a6420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP7_DIG_IN_CTL"
      sgroup "MPP7_DIG_IN_CTL (at 0xa643)"
        set &access:&cmd_addr %l (0x80a6430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP7_EN_CTL"
      sgroup "MPP7_EN_CTL (at 0xa646)"
        set &access:&cmd_addr %l (0x80a6460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP7_ANA_OUT_CTL"
      sgroup "MPP7_ANA_OUT_CTL (at 0xa648)"
        set &access:&cmd_addr %l (0x80a6480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP7_ANA_IN_CTL"
      sgroup "MPP7_ANA_IN_CTL (at 0xa64a)"
        set &access:&cmd_addr %l (0x80a64a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa64a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP7_SINK_CTL"
      sgroup "MPP7_SINK_CTL (at 0xa64c)"
        set &access:&cmd_addr %l (0x80a64c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa64c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP7_SEC_ACCESS"
      sgroup "MPP7_SEC_ACCESS (at 0xa6d0)"
        set &access:&cmd_addr %l (0x80a6d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP7_PERPH_RESET_CTL1"
      sgroup "MPP7_PERPH_RESET_CTL1 (at 0xa6d8)"
        set &access:&cmd_addr %l (0x80a6d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP7_PERPH_RESET_CTL2"
      sgroup "MPP7_PERPH_RESET_CTL2 (at 0xa6d9)"
        set &access:&cmd_addr %l (0x80a6d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP7_PERPH_RESET_CTL3"
      sgroup "MPP7_PERPH_RESET_CTL3 (at 0xa6da)"
        set &access:&cmd_addr %l (0x80a6da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP7_PERPH_RESET_CTL4"
      sgroup "MPP7_PERPH_RESET_CTL4 (at 0xa6db)"
        set &access:&cmd_addr %l (0x80a6db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa6db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "MPP8"
  tree "MPP8"
    tree "MPP8_REVISION1"
      sgroup "MPP8_REVISION1 (at 0xa700)"
        set &access:&cmd_addr %l (0x80a7000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP8_REVISION2"
      sgroup "MPP8_REVISION2 (at 0xa701)"
        set &access:&cmd_addr %l (0x80a7010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP8_REVISION3"
      sgroup "MPP8_REVISION3 (at 0xa702)"
        set &access:&cmd_addr %l (0x80a7020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP8_REVISION4"
      sgroup "MPP8_REVISION4 (at 0xa703)"
        set &access:&cmd_addr %l (0x80a7030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP8_PERPH_TYPE"
      sgroup "MPP8_PERPH_TYPE (at 0xa704)"
        set &access:&cmd_addr %l (0x80a7040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP8_PERPH_SUBTYPE"
      sgroup "MPP8_PERPH_SUBTYPE (at 0xa705)"
        set &access:&cmd_addr %l (0x80a7050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP8_STATUS1"
      sgroup "MPP8_STATUS1 (at 0xa708)"
        set &access:&cmd_addr %l (0x80a7080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0 (MPP_INPUT_LOW),1 (MPP_INPUT_HIGH)"
    tree.end
    tree "MPP8_INT_RT_STS"
      sgroup "MPP8_INT_RT_STS (at 0xa710)"
        set &access:&cmd_addr %l (0x80a7100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "MPP8_INT_SET_TYPE"
      sgroup "MPP8_INT_SET_TYPE (at 0xa711)"
        set &access:&cmd_addr %l (0x80a7110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MPP8_INT_POLARITY_HIGH"
      sgroup "MPP8_INT_POLARITY_HIGH (at 0xa712)"
        set &access:&cmd_addr %l (0x80a7120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MPP8_INT_POLARITY_LOW"
      sgroup "MPP8_INT_POLARITY_LOW (at 0xa713)"
        set &access:&cmd_addr %l (0x80a7130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MPP8_INT_LATCHED_CLR"
      sgroup "MPP8_INT_LATCHED_CLR (at 0xa714)"
        set &access:&cmd_addr %l (0x80a7140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP8_INT_EN_SET"
      sgroup "MPP8_INT_EN_SET (at 0xa715)"
        set &access:&cmd_addr %l (0x80a7150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP8_INT_EN_CLR"
      sgroup "MPP8_INT_EN_CLR (at 0xa716)"
        set &access:&cmd_addr %l (0x80a7160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MPP8_INT_LATCHED_STS"
      sgroup "MPP8_INT_LATCHED_STS (at 0xa718)"
        set &access:&cmd_addr %l (0x80a7180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MPP8_INT_PENDING_STS"
      sgroup "MPP8_INT_PENDING_STS (at 0xa719)"
        set &access:&cmd_addr %l (0x80a7190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MPP8_INT_MID_SEL"
      sgroup "MPP8_INT_MID_SEL (at 0xa71a)"
        set &access:&cmd_addr %l (0x80a71a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa71a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MPP8_INT_PRIORITY"
      sgroup "MPP8_INT_PRIORITY (at 0xa71b)"
        set &access:&cmd_addr %l (0x80a71b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa71b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MPP8_MODE_CTL"
      sgroup "MPP8_MODE_CTL (at 0xa740)"
        set &access:&cmd_addr %l (0x80a7400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0 (DIGITAL_INPUT),1 (DIGITAL_OUTPUT),2 (DIGITAL_IN_AND_OUT),3 (BIDIRECTIONAL),4 (ANALOG_INPUT),5 (ANALOG_OUTPUT),6 (CURRENT_SINK),7 (RESERVED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP8_DIG_VIN_CTL"
      sgroup "MPP8_DIG_VIN_CTL (at 0xa741)"
        set &access:&cmd_addr %l (0x80a7410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (VIN2),3 (VIN3),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP8_DIG_PULL_CTL"
      sgroup "MPP8_DIG_PULL_CTL (at 0xa742)"
        set &access:&cmd_addr %l (0x80a7420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (R600OHM),1 (OPEN),2 (R10KOHM),3 (R30KOHM),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "MPP8_DIG_IN_CTL"
      sgroup "MPP8_DIG_IN_CTL (at 0xa743)"
        set &access:&cmd_addr %l (0x80a7430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "MPP8_EN_CTL"
      sgroup "MPP8_EN_CTL (at 0xa746)"
        set &access:&cmd_addr %l (0x80a7460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (MPP_DISABLED),1 (MPP_ENABLED)"
    tree.end
    tree "MPP8_ANA_OUT_CTL"
      sgroup "MPP8_ANA_OUT_CTL (at 0xa748)"
        set &access:&cmd_addr %l (0x80a7480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0 (VREF_1V25),1 (VREF_0V625),2 (VREF_0V3125),3 (PAIRED_MPP),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP8_ANA_IN_CTL"
      sgroup "MPP8_ANA_IN_CTL (at 0xa74a)"
        set &access:&cmd_addr %l (0x80a74a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa74a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0 (HKADC5),1 (HKADC6),2 (HKADC7),3 (HKADC8),4 (ATEST1),5 (ATEST2),6 (ATEST3),7 (ATEST4)"
    tree.end
    tree "MPP8_SINK_CTL"
      sgroup "MPP8_SINK_CTL (at 0xa74c)"
        set &access:&cmd_addr %l (0x80a74c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa74c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0 (CURRENT_5MA),1 (CURRENT_10MA),2 (CURRENT_15MA),3 (CURRENT_20MA),4 (CURRENT_25MA),5 (CURRENT_30MA),6 (CURRENT_35MA),7 (CURRENT_40MA)"
    tree.end
    tree "MPP8_SEC_ACCESS"
      sgroup "MPP8_SEC_ACCESS (at 0xa7d0)"
        set &access:&cmd_addr %l (0x80a7d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP8_PERPH_RESET_CTL1"
      sgroup "MPP8_PERPH_RESET_CTL1 (at 0xa7d8)"
        set &access:&cmd_addr %l (0x80a7d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MPP8_PERPH_RESET_CTL2"
      sgroup "MPP8_PERPH_RESET_CTL2 (at 0xa7d9)"
        set &access:&cmd_addr %l (0x80a7d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP8_PERPH_RESET_CTL3"
      sgroup "MPP8_PERPH_RESET_CTL3 (at 0xa7da)"
        set &access:&cmd_addr %l (0x80a7da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "MPP8_PERPH_RESET_CTL4"
      sgroup "MPP8_PERPH_RESET_CTL4 (at 0xa7db)"
        set &access:&cmd_addr %l (0x80a7db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa7db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&cmd_addr %l (0x8071000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&cmd_addr %l (0x8071010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&cmd_addr %l (0x8071020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&cmd_addr %l (0x8071030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&cmd_addr %l (0x8071040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&cmd_addr %l (0x8071050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&cmd_addr %l (0x8071080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&cmd_addr %l (0x8071090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&cmd_addr %l (0x8071100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&cmd_addr %l (0x8071110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&cmd_addr %l (0x8071120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&cmd_addr %l (0x8071130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&cmd_addr %l (0x8071140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&cmd_addr %l (0x8071150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&cmd_addr %l (0x8071160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&cmd_addr %l (0x8071180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&cmd_addr %l (0x8071190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&cmd_addr %l (0x80711a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x711a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&cmd_addr %l (0x80711b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x711b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&cmd_addr %l (0x8071400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&cmd_addr %l (0x8071420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&cmd_addr %l (0x8071460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&cmd_addr %l (0x8071d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&cmd_addr %l (0x8071d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&cmd_addr %l (0x8071d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&cmd_addr %l (0x8071da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&cmd_addr %l (0x8071db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&cmd_addr %l (0x8071e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&cmd_addr %l (0x8071e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x71e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&cmd_addr %l (0x8072000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&cmd_addr %l (0x8072010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&cmd_addr %l (0x8072020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&cmd_addr %l (0x8072030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&cmd_addr %l (0x8072040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&cmd_addr %l (0x8072050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&cmd_addr %l (0x8072080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&cmd_addr %l (0x8072090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&cmd_addr %l (0x8072100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&cmd_addr %l (0x8072110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&cmd_addr %l (0x8072120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&cmd_addr %l (0x8072130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&cmd_addr %l (0x8072140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&cmd_addr %l (0x8072150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&cmd_addr %l (0x8072160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&cmd_addr %l (0x8072180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&cmd_addr %l (0x8072190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&cmd_addr %l (0x80721a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x721a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&cmd_addr %l (0x80721b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x721b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&cmd_addr %l (0x8072400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&cmd_addr %l (0x8072420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&cmd_addr %l (0x8072460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&cmd_addr %l (0x8072d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&cmd_addr %l (0x8072d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&cmd_addr %l (0x8072d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&cmd_addr %l (0x8072da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&cmd_addr %l (0x8072db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&cmd_addr %l (0x8072e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&cmd_addr %l (0x8072e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x72e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT10"
  tree "PBS_CLIENT10"
    tree "PBS_CLIENT10_REVISION1"
      sgroup "PBS_CLIENT10_REVISION1 (at 0x7b00)"
        set &access:&cmd_addr %l (0x807b000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION2"
      sgroup "PBS_CLIENT10_REVISION2 (at 0x7b01)"
        set &access:&cmd_addr %l (0x807b010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION3"
      sgroup "PBS_CLIENT10_REVISION3 (at 0x7b02)"
        set &access:&cmd_addr %l (0x807b020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT10_REVISION4"
      sgroup "PBS_CLIENT10_REVISION4 (at 0x7b03)"
        set &access:&cmd_addr %l (0x807b030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT10_PERPH_TYPE"
      sgroup "PBS_CLIENT10_PERPH_TYPE (at 0x7b04)"
        set &access:&cmd_addr %l (0x807b040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT10_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT10_PERPH_SUBTYPE (at 0x7b05)"
        set &access:&cmd_addr %l (0x807b050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT10_STATUS0"
      sgroup "PBS_CLIENT10_STATUS0 (at 0x7b08)"
        set &access:&cmd_addr %l (0x807b080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_STATUS1"
      sgroup "PBS_CLIENT10_STATUS1 (at 0x7b09)"
        set &access:&cmd_addr %l (0x807b090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT10_INT_RT_STS"
      sgroup "PBS_CLIENT10_INT_RT_STS (at 0x7b10)"
        set &access:&cmd_addr %l (0x807b100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT10_INT_SET_TYPE"
      sgroup "PBS_CLIENT10_INT_SET_TYPE (at 0x7b11)"
        set &access:&cmd_addr %l (0x807b110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT10_INT_POLARITY_HIGH (at 0x7b12)"
        set &access:&cmd_addr %l (0x807b120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT10_INT_POLARITY_LOW (at 0x7b13)"
        set &access:&cmd_addr %l (0x807b130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT10_INT_LATCHED_CLR (at 0x7b14)"
        set &access:&cmd_addr %l (0x807b140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_INT_EN_SET"
      sgroup "PBS_CLIENT10_INT_EN_SET (at 0x7b15)"
        set &access:&cmd_addr %l (0x807b150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_EN_CLR"
      sgroup "PBS_CLIENT10_INT_EN_CLR (at 0x7b16)"
        set &access:&cmd_addr %l (0x807b160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_LATCHED_STS"
      sgroup "PBS_CLIENT10_INT_LATCHED_STS (at 0x7b18)"
        set &access:&cmd_addr %l (0x807b180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT10_INT_PENDING_STS"
      sgroup "PBS_CLIENT10_INT_PENDING_STS (at 0x7b19)"
        set &access:&cmd_addr %l (0x807b190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT10_INT_MID_SEL"
      sgroup "PBS_CLIENT10_INT_MID_SEL (at 0x7b1a)"
        set &access:&cmd_addr %l (0x807b1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT10_INT_PRIORITY"
      sgroup "PBS_CLIENT10_INT_PRIORITY (at 0x7b1b)"
        set &access:&cmd_addr %l (0x807b1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_TRIG_CFG"
      sgroup "PBS_CLIENT10_TRIG_CFG (at 0x7b40)"
        set &access:&cmd_addr %l (0x807b400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT10_TRIG_CTL"
      sgroup "PBS_CLIENT10_TRIG_CTL (at 0x7b42)"
        set &access:&cmd_addr %l (0x807b420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT10_EN_CTL"
      sgroup "PBS_CLIENT10_EN_CTL (at 0x7b46)"
        set &access:&cmd_addr %l (0x807b460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7b460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_SEC_ACCESS"
      sgroup "PBS_CLIENT10_SEC_ACCESS (at 0x7bd0)"
        set &access:&cmd_addr %l (0x807bd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7bd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL1 (at 0x7bd8)"
        set &access:&cmd_addr %l (0x807bd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7bd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL2 (at 0x7bd9)"
        set &access:&cmd_addr %l (0x807bd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7bd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL3 (at 0x7bda)"
        set &access:&cmd_addr %l (0x807bda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7bda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT10_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT10_PERPH_RESET_CTL4 (at 0x7bdb)"
        set &access:&cmd_addr %l (0x807bdb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7bdb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST1"
      sgroup "PBS_CLIENT10_INT_TEST1 (at 0x7be0)"
        set &access:&cmd_addr %l (0x807be00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7be00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT10_INT_TEST_VAL"
      sgroup "PBS_CLIENT10_INT_TEST_VAL (at 0x7be1)"
        set &access:&cmd_addr %l (0x807be10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7be10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT11"
  tree "PBS_CLIENT11"
    tree "PBS_CLIENT11_REVISION1"
      sgroup "PBS_CLIENT11_REVISION1 (at 0x7c00)"
        set &access:&cmd_addr %l (0x807c000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION2"
      sgroup "PBS_CLIENT11_REVISION2 (at 0x7c01)"
        set &access:&cmd_addr %l (0x807c010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION3"
      sgroup "PBS_CLIENT11_REVISION3 (at 0x7c02)"
        set &access:&cmd_addr %l (0x807c020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT11_REVISION4"
      sgroup "PBS_CLIENT11_REVISION4 (at 0x7c03)"
        set &access:&cmd_addr %l (0x807c030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT11_PERPH_TYPE"
      sgroup "PBS_CLIENT11_PERPH_TYPE (at 0x7c04)"
        set &access:&cmd_addr %l (0x807c040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT11_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT11_PERPH_SUBTYPE (at 0x7c05)"
        set &access:&cmd_addr %l (0x807c050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT11_STATUS0"
      sgroup "PBS_CLIENT11_STATUS0 (at 0x7c08)"
        set &access:&cmd_addr %l (0x807c080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_STATUS1"
      sgroup "PBS_CLIENT11_STATUS1 (at 0x7c09)"
        set &access:&cmd_addr %l (0x807c090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT11_INT_RT_STS"
      sgroup "PBS_CLIENT11_INT_RT_STS (at 0x7c10)"
        set &access:&cmd_addr %l (0x807c100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT11_INT_SET_TYPE"
      sgroup "PBS_CLIENT11_INT_SET_TYPE (at 0x7c11)"
        set &access:&cmd_addr %l (0x807c110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT11_INT_POLARITY_HIGH (at 0x7c12)"
        set &access:&cmd_addr %l (0x807c120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT11_INT_POLARITY_LOW (at 0x7c13)"
        set &access:&cmd_addr %l (0x807c130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT11_INT_LATCHED_CLR (at 0x7c14)"
        set &access:&cmd_addr %l (0x807c140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_INT_EN_SET"
      sgroup "PBS_CLIENT11_INT_EN_SET (at 0x7c15)"
        set &access:&cmd_addr %l (0x807c150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_EN_CLR"
      sgroup "PBS_CLIENT11_INT_EN_CLR (at 0x7c16)"
        set &access:&cmd_addr %l (0x807c160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_LATCHED_STS"
      sgroup "PBS_CLIENT11_INT_LATCHED_STS (at 0x7c18)"
        set &access:&cmd_addr %l (0x807c180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT11_INT_PENDING_STS"
      sgroup "PBS_CLIENT11_INT_PENDING_STS (at 0x7c19)"
        set &access:&cmd_addr %l (0x807c190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT11_INT_MID_SEL"
      sgroup "PBS_CLIENT11_INT_MID_SEL (at 0x7c1a)"
        set &access:&cmd_addr %l (0x807c1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT11_INT_PRIORITY"
      sgroup "PBS_CLIENT11_INT_PRIORITY (at 0x7c1b)"
        set &access:&cmd_addr %l (0x807c1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_TRIG_CFG"
      sgroup "PBS_CLIENT11_TRIG_CFG (at 0x7c40)"
        set &access:&cmd_addr %l (0x807c400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT11_TRIG_CTL"
      sgroup "PBS_CLIENT11_TRIG_CTL (at 0x7c42)"
        set &access:&cmd_addr %l (0x807c420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT11_EN_CTL"
      sgroup "PBS_CLIENT11_EN_CTL (at 0x7c46)"
        set &access:&cmd_addr %l (0x807c460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7c460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_SEC_ACCESS"
      sgroup "PBS_CLIENT11_SEC_ACCESS (at 0x7cd0)"
        set &access:&cmd_addr %l (0x807cd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7cd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL1 (at 0x7cd8)"
        set &access:&cmd_addr %l (0x807cd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7cd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL2 (at 0x7cd9)"
        set &access:&cmd_addr %l (0x807cd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7cd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL3 (at 0x7cda)"
        set &access:&cmd_addr %l (0x807cda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7cda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT11_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT11_PERPH_RESET_CTL4 (at 0x7cdb)"
        set &access:&cmd_addr %l (0x807cdb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7cdb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST1"
      sgroup "PBS_CLIENT11_INT_TEST1 (at 0x7ce0)"
        set &access:&cmd_addr %l (0x807ce00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ce00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT11_INT_TEST_VAL"
      sgroup "PBS_CLIENT11_INT_TEST_VAL (at 0x7ce1)"
        set &access:&cmd_addr %l (0x807ce10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ce10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT12"
  tree "PBS_CLIENT12"
    tree "PBS_CLIENT12_REVISION1"
      sgroup "PBS_CLIENT12_REVISION1 (at 0x7d00)"
        set &access:&cmd_addr %l (0x807d000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION2"
      sgroup "PBS_CLIENT12_REVISION2 (at 0x7d01)"
        set &access:&cmd_addr %l (0x807d010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION3"
      sgroup "PBS_CLIENT12_REVISION3 (at 0x7d02)"
        set &access:&cmd_addr %l (0x807d020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT12_REVISION4"
      sgroup "PBS_CLIENT12_REVISION4 (at 0x7d03)"
        set &access:&cmd_addr %l (0x807d030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT12_PERPH_TYPE"
      sgroup "PBS_CLIENT12_PERPH_TYPE (at 0x7d04)"
        set &access:&cmd_addr %l (0x807d040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT12_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT12_PERPH_SUBTYPE (at 0x7d05)"
        set &access:&cmd_addr %l (0x807d050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT12_STATUS0"
      sgroup "PBS_CLIENT12_STATUS0 (at 0x7d08)"
        set &access:&cmd_addr %l (0x807d080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_STATUS1"
      sgroup "PBS_CLIENT12_STATUS1 (at 0x7d09)"
        set &access:&cmd_addr %l (0x807d090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT12_INT_RT_STS"
      sgroup "PBS_CLIENT12_INT_RT_STS (at 0x7d10)"
        set &access:&cmd_addr %l (0x807d100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT12_INT_SET_TYPE"
      sgroup "PBS_CLIENT12_INT_SET_TYPE (at 0x7d11)"
        set &access:&cmd_addr %l (0x807d110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT12_INT_POLARITY_HIGH (at 0x7d12)"
        set &access:&cmd_addr %l (0x807d120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT12_INT_POLARITY_LOW (at 0x7d13)"
        set &access:&cmd_addr %l (0x807d130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT12_INT_LATCHED_CLR (at 0x7d14)"
        set &access:&cmd_addr %l (0x807d140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_INT_EN_SET"
      sgroup "PBS_CLIENT12_INT_EN_SET (at 0x7d15)"
        set &access:&cmd_addr %l (0x807d150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_EN_CLR"
      sgroup "PBS_CLIENT12_INT_EN_CLR (at 0x7d16)"
        set &access:&cmd_addr %l (0x807d160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_LATCHED_STS"
      sgroup "PBS_CLIENT12_INT_LATCHED_STS (at 0x7d18)"
        set &access:&cmd_addr %l (0x807d180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT12_INT_PENDING_STS"
      sgroup "PBS_CLIENT12_INT_PENDING_STS (at 0x7d19)"
        set &access:&cmd_addr %l (0x807d190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT12_INT_MID_SEL"
      sgroup "PBS_CLIENT12_INT_MID_SEL (at 0x7d1a)"
        set &access:&cmd_addr %l (0x807d1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT12_INT_PRIORITY"
      sgroup "PBS_CLIENT12_INT_PRIORITY (at 0x7d1b)"
        set &access:&cmd_addr %l (0x807d1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_TRIG_CFG"
      sgroup "PBS_CLIENT12_TRIG_CFG (at 0x7d40)"
        set &access:&cmd_addr %l (0x807d400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT12_TRIG_CTL"
      sgroup "PBS_CLIENT12_TRIG_CTL (at 0x7d42)"
        set &access:&cmd_addr %l (0x807d420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT12_EN_CTL"
      sgroup "PBS_CLIENT12_EN_CTL (at 0x7d46)"
        set &access:&cmd_addr %l (0x807d460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7d460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_SEC_ACCESS"
      sgroup "PBS_CLIENT12_SEC_ACCESS (at 0x7dd0)"
        set &access:&cmd_addr %l (0x807dd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7dd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL1 (at 0x7dd8)"
        set &access:&cmd_addr %l (0x807dd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7dd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL2 (at 0x7dd9)"
        set &access:&cmd_addr %l (0x807dd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7dd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL3 (at 0x7dda)"
        set &access:&cmd_addr %l (0x807dda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7dda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT12_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT12_PERPH_RESET_CTL4 (at 0x7ddb)"
        set &access:&cmd_addr %l (0x807ddb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ddb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST1"
      sgroup "PBS_CLIENT12_INT_TEST1 (at 0x7de0)"
        set &access:&cmd_addr %l (0x807de00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7de00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT12_INT_TEST_VAL"
      sgroup "PBS_CLIENT12_INT_TEST_VAL (at 0x7de1)"
        set &access:&cmd_addr %l (0x807de10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7de10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT13"
  tree "PBS_CLIENT13"
    tree "PBS_CLIENT13_REVISION1"
      sgroup "PBS_CLIENT13_REVISION1 (at 0x7e00)"
        set &access:&cmd_addr %l (0x807e000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION2"
      sgroup "PBS_CLIENT13_REVISION2 (at 0x7e01)"
        set &access:&cmd_addr %l (0x807e010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION3"
      sgroup "PBS_CLIENT13_REVISION3 (at 0x7e02)"
        set &access:&cmd_addr %l (0x807e020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT13_REVISION4"
      sgroup "PBS_CLIENT13_REVISION4 (at 0x7e03)"
        set &access:&cmd_addr %l (0x807e030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT13_PERPH_TYPE"
      sgroup "PBS_CLIENT13_PERPH_TYPE (at 0x7e04)"
        set &access:&cmd_addr %l (0x807e040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT13_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT13_PERPH_SUBTYPE (at 0x7e05)"
        set &access:&cmd_addr %l (0x807e050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT13_STATUS0"
      sgroup "PBS_CLIENT13_STATUS0 (at 0x7e08)"
        set &access:&cmd_addr %l (0x807e080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_STATUS1"
      sgroup "PBS_CLIENT13_STATUS1 (at 0x7e09)"
        set &access:&cmd_addr %l (0x807e090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT13_INT_RT_STS"
      sgroup "PBS_CLIENT13_INT_RT_STS (at 0x7e10)"
        set &access:&cmd_addr %l (0x807e100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT13_INT_SET_TYPE"
      sgroup "PBS_CLIENT13_INT_SET_TYPE (at 0x7e11)"
        set &access:&cmd_addr %l (0x807e110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT13_INT_POLARITY_HIGH (at 0x7e12)"
        set &access:&cmd_addr %l (0x807e120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT13_INT_POLARITY_LOW (at 0x7e13)"
        set &access:&cmd_addr %l (0x807e130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT13_INT_LATCHED_CLR (at 0x7e14)"
        set &access:&cmd_addr %l (0x807e140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_INT_EN_SET"
      sgroup "PBS_CLIENT13_INT_EN_SET (at 0x7e15)"
        set &access:&cmd_addr %l (0x807e150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_EN_CLR"
      sgroup "PBS_CLIENT13_INT_EN_CLR (at 0x7e16)"
        set &access:&cmd_addr %l (0x807e160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_LATCHED_STS"
      sgroup "PBS_CLIENT13_INT_LATCHED_STS (at 0x7e18)"
        set &access:&cmd_addr %l (0x807e180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT13_INT_PENDING_STS"
      sgroup "PBS_CLIENT13_INT_PENDING_STS (at 0x7e19)"
        set &access:&cmd_addr %l (0x807e190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT13_INT_MID_SEL"
      sgroup "PBS_CLIENT13_INT_MID_SEL (at 0x7e1a)"
        set &access:&cmd_addr %l (0x807e1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT13_INT_PRIORITY"
      sgroup "PBS_CLIENT13_INT_PRIORITY (at 0x7e1b)"
        set &access:&cmd_addr %l (0x807e1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_TRIG_CFG"
      sgroup "PBS_CLIENT13_TRIG_CFG (at 0x7e40)"
        set &access:&cmd_addr %l (0x807e400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT13_TRIG_CTL"
      sgroup "PBS_CLIENT13_TRIG_CTL (at 0x7e42)"
        set &access:&cmd_addr %l (0x807e420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT13_EN_CTL"
      sgroup "PBS_CLIENT13_EN_CTL (at 0x7e46)"
        set &access:&cmd_addr %l (0x807e460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7e460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_SEC_ACCESS"
      sgroup "PBS_CLIENT13_SEC_ACCESS (at 0x7ed0)"
        set &access:&cmd_addr %l (0x807ed00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ed00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT13_PERPH_RESET_CTL1 (at 0x7ed8)"
        set &access:&cmd_addr %l (0x807ed80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ed80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT13_PERPH_RESET_CTL2 (at 0x7ed9)"
        set &access:&cmd_addr %l (0x807ed90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ed90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT13_PERPH_RESET_CTL3 (at 0x7eda)"
        set &access:&cmd_addr %l (0x807eda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7eda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT13_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT13_PERPH_RESET_CTL4 (at 0x7edb)"
        set &access:&cmd_addr %l (0x807edb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7edb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT13_INT_TEST1"
      sgroup "PBS_CLIENT13_INT_TEST1 (at 0x7ee0)"
        set &access:&cmd_addr %l (0x807ee00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ee00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT13_INT_TEST_VAL"
      sgroup "PBS_CLIENT13_INT_TEST_VAL (at 0x7ee1)"
        set &access:&cmd_addr %l (0x807ee10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ee10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT14"
  tree "PBS_CLIENT14"
    tree "PBS_CLIENT14_REVISION1"
      sgroup "PBS_CLIENT14_REVISION1 (at 0x7f00)"
        set &access:&cmd_addr %l (0x807f000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION2"
      sgroup "PBS_CLIENT14_REVISION2 (at 0x7f01)"
        set &access:&cmd_addr %l (0x807f010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION3"
      sgroup "PBS_CLIENT14_REVISION3 (at 0x7f02)"
        set &access:&cmd_addr %l (0x807f020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT14_REVISION4"
      sgroup "PBS_CLIENT14_REVISION4 (at 0x7f03)"
        set &access:&cmd_addr %l (0x807f030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT14_PERPH_TYPE"
      sgroup "PBS_CLIENT14_PERPH_TYPE (at 0x7f04)"
        set &access:&cmd_addr %l (0x807f040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT14_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT14_PERPH_SUBTYPE (at 0x7f05)"
        set &access:&cmd_addr %l (0x807f050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT14_STATUS0"
      sgroup "PBS_CLIENT14_STATUS0 (at 0x7f08)"
        set &access:&cmd_addr %l (0x807f080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_STATUS1"
      sgroup "PBS_CLIENT14_STATUS1 (at 0x7f09)"
        set &access:&cmd_addr %l (0x807f090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT14_INT_RT_STS"
      sgroup "PBS_CLIENT14_INT_RT_STS (at 0x7f10)"
        set &access:&cmd_addr %l (0x807f100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT14_INT_SET_TYPE"
      sgroup "PBS_CLIENT14_INT_SET_TYPE (at 0x7f11)"
        set &access:&cmd_addr %l (0x807f110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT14_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT14_INT_POLARITY_HIGH (at 0x7f12)"
        set &access:&cmd_addr %l (0x807f120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT14_INT_POLARITY_LOW (at 0x7f13)"
        set &access:&cmd_addr %l (0x807f130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT14_INT_LATCHED_CLR (at 0x7f14)"
        set &access:&cmd_addr %l (0x807f140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_INT_EN_SET"
      sgroup "PBS_CLIENT14_INT_EN_SET (at 0x7f15)"
        set &access:&cmd_addr %l (0x807f150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_EN_CLR"
      sgroup "PBS_CLIENT14_INT_EN_CLR (at 0x7f16)"
        set &access:&cmd_addr %l (0x807f160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_LATCHED_STS"
      sgroup "PBS_CLIENT14_INT_LATCHED_STS (at 0x7f18)"
        set &access:&cmd_addr %l (0x807f180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT14_INT_PENDING_STS"
      sgroup "PBS_CLIENT14_INT_PENDING_STS (at 0x7f19)"
        set &access:&cmd_addr %l (0x807f190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT14_INT_MID_SEL"
      sgroup "PBS_CLIENT14_INT_MID_SEL (at 0x7f1a)"
        set &access:&cmd_addr %l (0x807f1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT14_INT_PRIORITY"
      sgroup "PBS_CLIENT14_INT_PRIORITY (at 0x7f1b)"
        set &access:&cmd_addr %l (0x807f1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_TRIG_CFG"
      sgroup "PBS_CLIENT14_TRIG_CFG (at 0x7f40)"
        set &access:&cmd_addr %l (0x807f400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT14_TRIG_CTL"
      sgroup "PBS_CLIENT14_TRIG_CTL (at 0x7f42)"
        set &access:&cmd_addr %l (0x807f420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT14_EN_CTL"
      sgroup "PBS_CLIENT14_EN_CTL (at 0x7f46)"
        set &access:&cmd_addr %l (0x807f460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7f460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_SEC_ACCESS"
      sgroup "PBS_CLIENT14_SEC_ACCESS (at 0x7fd0)"
        set &access:&cmd_addr %l (0x807fd00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7fd00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT14_PERPH_RESET_CTL1 (at 0x7fd8)"
        set &access:&cmd_addr %l (0x807fd80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7fd80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT14_PERPH_RESET_CTL2 (at 0x7fd9)"
        set &access:&cmd_addr %l (0x807fd90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7fd90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT14_PERPH_RESET_CTL3 (at 0x7fda)"
        set &access:&cmd_addr %l (0x807fda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7fda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT14_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT14_PERPH_RESET_CTL4 (at 0x7fdb)"
        set &access:&cmd_addr %l (0x807fdb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7fdb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT14_INT_TEST1"
      sgroup "PBS_CLIENT14_INT_TEST1 (at 0x7fe0)"
        set &access:&cmd_addr %l (0x807fe00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7fe00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT14_INT_TEST_VAL"
      sgroup "PBS_CLIENT14_INT_TEST_VAL (at 0x7fe1)"
        set &access:&cmd_addr %l (0x807fe10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7fe10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT15"
  tree "PBS_CLIENT15"
    tree "PBS_CLIENT15_REVISION1"
      sgroup "PBS_CLIENT15_REVISION1 (at 0x8000)"
        set &access:&cmd_addr %l (0x8080000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION2"
      sgroup "PBS_CLIENT15_REVISION2 (at 0x8001)"
        set &access:&cmd_addr %l (0x8080010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION3"
      sgroup "PBS_CLIENT15_REVISION3 (at 0x8002)"
        set &access:&cmd_addr %l (0x8080020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT15_REVISION4"
      sgroup "PBS_CLIENT15_REVISION4 (at 0x8003)"
        set &access:&cmd_addr %l (0x8080030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT15_PERPH_TYPE"
      sgroup "PBS_CLIENT15_PERPH_TYPE (at 0x8004)"
        set &access:&cmd_addr %l (0x8080040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT15_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT15_PERPH_SUBTYPE (at 0x8005)"
        set &access:&cmd_addr %l (0x8080050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT15_STATUS0"
      sgroup "PBS_CLIENT15_STATUS0 (at 0x8008)"
        set &access:&cmd_addr %l (0x8080080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_STATUS1"
      sgroup "PBS_CLIENT15_STATUS1 (at 0x8009)"
        set &access:&cmd_addr %l (0x8080090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT15_INT_RT_STS"
      sgroup "PBS_CLIENT15_INT_RT_STS (at 0x8010)"
        set &access:&cmd_addr %l (0x8080100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT15_INT_SET_TYPE"
      sgroup "PBS_CLIENT15_INT_SET_TYPE (at 0x8011)"
        set &access:&cmd_addr %l (0x8080110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT15_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT15_INT_POLARITY_HIGH (at 0x8012)"
        set &access:&cmd_addr %l (0x8080120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT15_INT_POLARITY_LOW (at 0x8013)"
        set &access:&cmd_addr %l (0x8080130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT15_INT_LATCHED_CLR (at 0x8014)"
        set &access:&cmd_addr %l (0x8080140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_INT_EN_SET"
      sgroup "PBS_CLIENT15_INT_EN_SET (at 0x8015)"
        set &access:&cmd_addr %l (0x8080150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_EN_CLR"
      sgroup "PBS_CLIENT15_INT_EN_CLR (at 0x8016)"
        set &access:&cmd_addr %l (0x8080160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_LATCHED_STS"
      sgroup "PBS_CLIENT15_INT_LATCHED_STS (at 0x8018)"
        set &access:&cmd_addr %l (0x8080180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT15_INT_PENDING_STS"
      sgroup "PBS_CLIENT15_INT_PENDING_STS (at 0x8019)"
        set &access:&cmd_addr %l (0x8080190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT15_INT_MID_SEL"
      sgroup "PBS_CLIENT15_INT_MID_SEL (at 0x801a)"
        set &access:&cmd_addr %l (0x80801a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x801a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT15_INT_PRIORITY"
      sgroup "PBS_CLIENT15_INT_PRIORITY (at 0x801b)"
        set &access:&cmd_addr %l (0x80801b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x801b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_TRIG_CFG"
      sgroup "PBS_CLIENT15_TRIG_CFG (at 0x8040)"
        set &access:&cmd_addr %l (0x8080400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT15_TRIG_CTL"
      sgroup "PBS_CLIENT15_TRIG_CTL (at 0x8042)"
        set &access:&cmd_addr %l (0x8080420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT15_EN_CTL"
      sgroup "PBS_CLIENT15_EN_CTL (at 0x8046)"
        set &access:&cmd_addr %l (0x8080460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_SEC_ACCESS"
      sgroup "PBS_CLIENT15_SEC_ACCESS (at 0x80d0)"
        set &access:&cmd_addr %l (0x8080d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT15_PERPH_RESET_CTL1 (at 0x80d8)"
        set &access:&cmd_addr %l (0x8080d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT15_PERPH_RESET_CTL2 (at 0x80d9)"
        set &access:&cmd_addr %l (0x8080d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT15_PERPH_RESET_CTL3 (at 0x80da)"
        set &access:&cmd_addr %l (0x8080da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT15_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT15_PERPH_RESET_CTL4 (at 0x80db)"
        set &access:&cmd_addr %l (0x8080db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT15_INT_TEST1"
      sgroup "PBS_CLIENT15_INT_TEST1 (at 0x80e0)"
        set &access:&cmd_addr %l (0x8080e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT15_INT_TEST_VAL"
      sgroup "PBS_CLIENT15_INT_TEST_VAL (at 0x80e1)"
        set &access:&cmd_addr %l (0x8080e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&cmd_addr %l (0x8073000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&cmd_addr %l (0x8073010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&cmd_addr %l (0x8073020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&cmd_addr %l (0x8073030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&cmd_addr %l (0x8073040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&cmd_addr %l (0x8073050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&cmd_addr %l (0x8073080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&cmd_addr %l (0x8073090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&cmd_addr %l (0x8073100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&cmd_addr %l (0x8073110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&cmd_addr %l (0x8073120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&cmd_addr %l (0x8073130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&cmd_addr %l (0x8073140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&cmd_addr %l (0x8073150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&cmd_addr %l (0x8073160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&cmd_addr %l (0x8073180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&cmd_addr %l (0x8073190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&cmd_addr %l (0x80731a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x731a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&cmd_addr %l (0x80731b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x731b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      sgroup "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
        set &access:&cmd_addr %l (0x8073400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&cmd_addr %l (0x8073420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&cmd_addr %l (0x8073460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&cmd_addr %l (0x8073d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&cmd_addr %l (0x8073d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&cmd_addr %l (0x8073d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&cmd_addr %l (0x8073da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&cmd_addr %l (0x8073db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&cmd_addr %l (0x8073e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&cmd_addr %l (0x8073e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x73e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&cmd_addr %l (0x8074000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&cmd_addr %l (0x8074010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&cmd_addr %l (0x8074020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&cmd_addr %l (0x8074030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&cmd_addr %l (0x8074040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&cmd_addr %l (0x8074050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&cmd_addr %l (0x8074080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&cmd_addr %l (0x8074090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&cmd_addr %l (0x8074100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&cmd_addr %l (0x8074110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&cmd_addr %l (0x8074120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&cmd_addr %l (0x8074130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&cmd_addr %l (0x8074140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&cmd_addr %l (0x8074150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&cmd_addr %l (0x8074160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&cmd_addr %l (0x8074180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&cmd_addr %l (0x8074190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&cmd_addr %l (0x80741a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x741a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&cmd_addr %l (0x80741b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x741b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      sgroup "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
        set &access:&cmd_addr %l (0x8074400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&cmd_addr %l (0x8074420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&cmd_addr %l (0x8074460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&cmd_addr %l (0x8074d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&cmd_addr %l (0x8074d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&cmd_addr %l (0x8074d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&cmd_addr %l (0x8074da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&cmd_addr %l (0x8074db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&cmd_addr %l (0x8074e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&cmd_addr %l (0x8074e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x74e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      sgroup "PBS_CLIENT4_REVISION1 (at 0x7500)"
        set &access:&cmd_addr %l (0x8075000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      sgroup "PBS_CLIENT4_REVISION2 (at 0x7501)"
        set &access:&cmd_addr %l (0x8075010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      sgroup "PBS_CLIENT4_REVISION3 (at 0x7502)"
        set &access:&cmd_addr %l (0x8075020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      sgroup "PBS_CLIENT4_REVISION4 (at 0x7503)"
        set &access:&cmd_addr %l (0x8075030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      sgroup "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
        set &access:&cmd_addr %l (0x8075040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
        set &access:&cmd_addr %l (0x8075050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      sgroup "PBS_CLIENT4_STATUS0 (at 0x7508)"
        set &access:&cmd_addr %l (0x8075080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_STATUS1"
      sgroup "PBS_CLIENT4_STATUS1 (at 0x7509)"
        set &access:&cmd_addr %l (0x8075090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      sgroup "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
        set &access:&cmd_addr %l (0x8075100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      sgroup "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
        set &access:&cmd_addr %l (0x8075110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
        set &access:&cmd_addr %l (0x8075120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
        set &access:&cmd_addr %l (0x8075130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
        set &access:&cmd_addr %l (0x8075140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      sgroup "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
        set &access:&cmd_addr %l (0x8075150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      sgroup "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
        set &access:&cmd_addr %l (0x8075160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      sgroup "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
        set &access:&cmd_addr %l (0x8075180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      sgroup "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
        set &access:&cmd_addr %l (0x8075190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      sgroup "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
        set &access:&cmd_addr %l (0x80751a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x751a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      sgroup "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
        set &access:&cmd_addr %l (0x80751b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x751b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      sgroup "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
        set &access:&cmd_addr %l (0x8075400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      sgroup "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
        set &access:&cmd_addr %l (0x8075420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      sgroup "PBS_CLIENT4_EN_CTL (at 0x7546)"
        set &access:&cmd_addr %l (0x8075460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      sgroup "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
        set &access:&cmd_addr %l (0x8075d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
        set &access:&cmd_addr %l (0x8075d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
        set &access:&cmd_addr %l (0x8075d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
        set &access:&cmd_addr %l (0x8075da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
        set &access:&cmd_addr %l (0x8075db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      sgroup "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
        set &access:&cmd_addr %l (0x8075e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      sgroup "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
        set &access:&cmd_addr %l (0x8075e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x75e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      sgroup "PBS_CLIENT5_REVISION1 (at 0x7600)"
        set &access:&cmd_addr %l (0x8076000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      sgroup "PBS_CLIENT5_REVISION2 (at 0x7601)"
        set &access:&cmd_addr %l (0x8076010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      sgroup "PBS_CLIENT5_REVISION3 (at 0x7602)"
        set &access:&cmd_addr %l (0x8076020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      sgroup "PBS_CLIENT5_REVISION4 (at 0x7603)"
        set &access:&cmd_addr %l (0x8076030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      sgroup "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
        set &access:&cmd_addr %l (0x8076040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
        set &access:&cmd_addr %l (0x8076050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      sgroup "PBS_CLIENT5_STATUS0 (at 0x7608)"
        set &access:&cmd_addr %l (0x8076080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_STATUS1"
      sgroup "PBS_CLIENT5_STATUS1 (at 0x7609)"
        set &access:&cmd_addr %l (0x8076090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      sgroup "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
        set &access:&cmd_addr %l (0x8076100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      sgroup "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
        set &access:&cmd_addr %l (0x8076110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
        set &access:&cmd_addr %l (0x8076120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
        set &access:&cmd_addr %l (0x8076130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
        set &access:&cmd_addr %l (0x8076140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      sgroup "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
        set &access:&cmd_addr %l (0x8076150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      sgroup "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
        set &access:&cmd_addr %l (0x8076160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      sgroup "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
        set &access:&cmd_addr %l (0x8076180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      sgroup "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
        set &access:&cmd_addr %l (0x8076190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      sgroup "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
        set &access:&cmd_addr %l (0x80761a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x761a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      sgroup "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
        set &access:&cmd_addr %l (0x80761b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x761b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      sgroup "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
        set &access:&cmd_addr %l (0x8076400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      sgroup "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
        set &access:&cmd_addr %l (0x8076420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      sgroup "PBS_CLIENT5_EN_CTL (at 0x7646)"
        set &access:&cmd_addr %l (0x8076460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      sgroup "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
        set &access:&cmd_addr %l (0x8076d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
        set &access:&cmd_addr %l (0x8076d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
        set &access:&cmd_addr %l (0x8076d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
        set &access:&cmd_addr %l (0x8076da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
        set &access:&cmd_addr %l (0x8076db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      sgroup "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
        set &access:&cmd_addr %l (0x8076e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      sgroup "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
        set &access:&cmd_addr %l (0x8076e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x76e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      sgroup "PBS_CLIENT6_REVISION1 (at 0x7700)"
        set &access:&cmd_addr %l (0x8077000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      sgroup "PBS_CLIENT6_REVISION2 (at 0x7701)"
        set &access:&cmd_addr %l (0x8077010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      sgroup "PBS_CLIENT6_REVISION3 (at 0x7702)"
        set &access:&cmd_addr %l (0x8077020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      sgroup "PBS_CLIENT6_REVISION4 (at 0x7703)"
        set &access:&cmd_addr %l (0x8077030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      sgroup "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
        set &access:&cmd_addr %l (0x8077040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
        set &access:&cmd_addr %l (0x8077050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      sgroup "PBS_CLIENT6_STATUS0 (at 0x7708)"
        set &access:&cmd_addr %l (0x8077080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_STATUS1"
      sgroup "PBS_CLIENT6_STATUS1 (at 0x7709)"
        set &access:&cmd_addr %l (0x8077090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      sgroup "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
        set &access:&cmd_addr %l (0x8077100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      sgroup "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
        set &access:&cmd_addr %l (0x8077110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
        set &access:&cmd_addr %l (0x8077120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
        set &access:&cmd_addr %l (0x8077130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
        set &access:&cmd_addr %l (0x8077140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      sgroup "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
        set &access:&cmd_addr %l (0x8077150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      sgroup "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
        set &access:&cmd_addr %l (0x8077160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      sgroup "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
        set &access:&cmd_addr %l (0x8077180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      sgroup "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
        set &access:&cmd_addr %l (0x8077190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      sgroup "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
        set &access:&cmd_addr %l (0x80771a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x771a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      sgroup "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
        set &access:&cmd_addr %l (0x80771b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x771b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      sgroup "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
        set &access:&cmd_addr %l (0x8077400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      sgroup "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
        set &access:&cmd_addr %l (0x8077420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      sgroup "PBS_CLIENT6_EN_CTL (at 0x7746)"
        set &access:&cmd_addr %l (0x8077460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      sgroup "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
        set &access:&cmd_addr %l (0x8077d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
        set &access:&cmd_addr %l (0x8077d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
        set &access:&cmd_addr %l (0x8077d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
        set &access:&cmd_addr %l (0x8077da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
        set &access:&cmd_addr %l (0x8077db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      sgroup "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
        set &access:&cmd_addr %l (0x8077e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      sgroup "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
        set &access:&cmd_addr %l (0x8077e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x77e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      sgroup "PBS_CLIENT7_REVISION1 (at 0x7800)"
        set &access:&cmd_addr %l (0x8078000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      sgroup "PBS_CLIENT7_REVISION2 (at 0x7801)"
        set &access:&cmd_addr %l (0x8078010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      sgroup "PBS_CLIENT7_REVISION3 (at 0x7802)"
        set &access:&cmd_addr %l (0x8078020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      sgroup "PBS_CLIENT7_REVISION4 (at 0x7803)"
        set &access:&cmd_addr %l (0x8078030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      sgroup "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
        set &access:&cmd_addr %l (0x8078040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
        set &access:&cmd_addr %l (0x8078050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      sgroup "PBS_CLIENT7_STATUS0 (at 0x7808)"
        set &access:&cmd_addr %l (0x8078080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_STATUS1"
      sgroup "PBS_CLIENT7_STATUS1 (at 0x7809)"
        set &access:&cmd_addr %l (0x8078090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      sgroup "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
        set &access:&cmd_addr %l (0x8078100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      sgroup "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
        set &access:&cmd_addr %l (0x8078110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
        set &access:&cmd_addr %l (0x8078120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
        set &access:&cmd_addr %l (0x8078130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
        set &access:&cmd_addr %l (0x8078140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      sgroup "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
        set &access:&cmd_addr %l (0x8078150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      sgroup "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
        set &access:&cmd_addr %l (0x8078160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      sgroup "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
        set &access:&cmd_addr %l (0x8078180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      sgroup "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
        set &access:&cmd_addr %l (0x8078190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      sgroup "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
        set &access:&cmd_addr %l (0x80781a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x781a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      sgroup "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
        set &access:&cmd_addr %l (0x80781b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x781b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      sgroup "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
        set &access:&cmd_addr %l (0x8078400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      sgroup "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
        set &access:&cmd_addr %l (0x8078420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      sgroup "PBS_CLIENT7_EN_CTL (at 0x7846)"
        set &access:&cmd_addr %l (0x8078460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      sgroup "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
        set &access:&cmd_addr %l (0x8078d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
        set &access:&cmd_addr %l (0x8078d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
        set &access:&cmd_addr %l (0x8078d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
        set &access:&cmd_addr %l (0x8078da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
        set &access:&cmd_addr %l (0x8078db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      sgroup "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
        set &access:&cmd_addr %l (0x8078e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      sgroup "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
        set &access:&cmd_addr %l (0x8078e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x78e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT8"
  tree "PBS_CLIENT8"
    tree "PBS_CLIENT8_REVISION1"
      sgroup "PBS_CLIENT8_REVISION1 (at 0x7900)"
        set &access:&cmd_addr %l (0x8079000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION2"
      sgroup "PBS_CLIENT8_REVISION2 (at 0x7901)"
        set &access:&cmd_addr %l (0x8079010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION3"
      sgroup "PBS_CLIENT8_REVISION3 (at 0x7902)"
        set &access:&cmd_addr %l (0x8079020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT8_REVISION4"
      sgroup "PBS_CLIENT8_REVISION4 (at 0x7903)"
        set &access:&cmd_addr %l (0x8079030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT8_PERPH_TYPE"
      sgroup "PBS_CLIENT8_PERPH_TYPE (at 0x7904)"
        set &access:&cmd_addr %l (0x8079040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT8_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT8_PERPH_SUBTYPE (at 0x7905)"
        set &access:&cmd_addr %l (0x8079050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT8_STATUS0"
      sgroup "PBS_CLIENT8_STATUS0 (at 0x7908)"
        set &access:&cmd_addr %l (0x8079080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_STATUS1"
      sgroup "PBS_CLIENT8_STATUS1 (at 0x7909)"
        set &access:&cmd_addr %l (0x8079090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT8_INT_RT_STS"
      sgroup "PBS_CLIENT8_INT_RT_STS (at 0x7910)"
        set &access:&cmd_addr %l (0x8079100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT8_INT_SET_TYPE"
      sgroup "PBS_CLIENT8_INT_SET_TYPE (at 0x7911)"
        set &access:&cmd_addr %l (0x8079110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT8_INT_POLARITY_HIGH (at 0x7912)"
        set &access:&cmd_addr %l (0x8079120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT8_INT_POLARITY_LOW (at 0x7913)"
        set &access:&cmd_addr %l (0x8079130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT8_INT_LATCHED_CLR (at 0x7914)"
        set &access:&cmd_addr %l (0x8079140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_INT_EN_SET"
      sgroup "PBS_CLIENT8_INT_EN_SET (at 0x7915)"
        set &access:&cmd_addr %l (0x8079150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_EN_CLR"
      sgroup "PBS_CLIENT8_INT_EN_CLR (at 0x7916)"
        set &access:&cmd_addr %l (0x8079160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_LATCHED_STS"
      sgroup "PBS_CLIENT8_INT_LATCHED_STS (at 0x7918)"
        set &access:&cmd_addr %l (0x8079180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT8_INT_PENDING_STS"
      sgroup "PBS_CLIENT8_INT_PENDING_STS (at 0x7919)"
        set &access:&cmd_addr %l (0x8079190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT8_INT_MID_SEL"
      sgroup "PBS_CLIENT8_INT_MID_SEL (at 0x791a)"
        set &access:&cmd_addr %l (0x80791a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x791a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT8_INT_PRIORITY"
      sgroup "PBS_CLIENT8_INT_PRIORITY (at 0x791b)"
        set &access:&cmd_addr %l (0x80791b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x791b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_TRIG_CFG"
      sgroup "PBS_CLIENT8_TRIG_CFG (at 0x7940)"
        set &access:&cmd_addr %l (0x8079400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT8_TRIG_CTL"
      sgroup "PBS_CLIENT8_TRIG_CTL (at 0x7942)"
        set &access:&cmd_addr %l (0x8079420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT8_EN_CTL"
      sgroup "PBS_CLIENT8_EN_CTL (at 0x7946)"
        set &access:&cmd_addr %l (0x8079460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_SEC_ACCESS"
      sgroup "PBS_CLIENT8_SEC_ACCESS (at 0x79d0)"
        set &access:&cmd_addr %l (0x8079d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL1 (at 0x79d8)"
        set &access:&cmd_addr %l (0x8079d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL2 (at 0x79d9)"
        set &access:&cmd_addr %l (0x8079d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL3 (at 0x79da)"
        set &access:&cmd_addr %l (0x8079da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT8_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT8_PERPH_RESET_CTL4 (at 0x79db)"
        set &access:&cmd_addr %l (0x8079db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST1"
      sgroup "PBS_CLIENT8_INT_TEST1 (at 0x79e0)"
        set &access:&cmd_addr %l (0x8079e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT8_INT_TEST_VAL"
      sgroup "PBS_CLIENT8_INT_TEST_VAL (at 0x79e1)"
        set &access:&cmd_addr %l (0x8079e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x79e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT9"
  tree "PBS_CLIENT9"
    tree "PBS_CLIENT9_REVISION1"
      sgroup "PBS_CLIENT9_REVISION1 (at 0x7a00)"
        set &access:&cmd_addr %l (0x807a000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION2"
      sgroup "PBS_CLIENT9_REVISION2 (at 0x7a01)"
        set &access:&cmd_addr %l (0x807a010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION3"
      sgroup "PBS_CLIENT9_REVISION3 (at 0x7a02)"
        set &access:&cmd_addr %l (0x807a020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT9_REVISION4"
      sgroup "PBS_CLIENT9_REVISION4 (at 0x7a03)"
        set &access:&cmd_addr %l (0x807a030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT9_PERPH_TYPE"
      sgroup "PBS_CLIENT9_PERPH_TYPE (at 0x7a04)"
        set &access:&cmd_addr %l (0x807a040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT9_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT9_PERPH_SUBTYPE (at 0x7a05)"
        set &access:&cmd_addr %l (0x807a050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT9_STATUS0"
      sgroup "PBS_CLIENT9_STATUS0 (at 0x7a08)"
        set &access:&cmd_addr %l (0x807a080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_TRIG_EN_STATUS                        = " "0 (HW_TRIGGER_DISABLED),1 (HW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_STATUS1"
      sgroup "PBS_CLIENT9_STATUS1 (at 0x7a09)"
        set &access:&cmd_addr %l (0x807a090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT9_INT_RT_STS"
      sgroup "PBS_CLIENT9_INT_RT_STS (at 0x7a10)"
        set &access:&cmd_addr %l (0x807a100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT9_INT_SET_TYPE"
      sgroup "PBS_CLIENT9_INT_SET_TYPE (at 0x7a11)"
        set &access:&cmd_addr %l (0x807a110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT9_INT_POLARITY_HIGH (at 0x7a12)"
        set &access:&cmd_addr %l (0x807a120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT9_INT_POLARITY_LOW (at 0x7a13)"
        set &access:&cmd_addr %l (0x807a130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT9_INT_LATCHED_CLR (at 0x7a14)"
        set &access:&cmd_addr %l (0x807a140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_INT_EN_SET"
      sgroup "PBS_CLIENT9_INT_EN_SET (at 0x7a15)"
        set &access:&cmd_addr %l (0x807a150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_EN_CLR"
      sgroup "PBS_CLIENT9_INT_EN_CLR (at 0x7a16)"
        set &access:&cmd_addr %l (0x807a160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_LATCHED_STS"
      sgroup "PBS_CLIENT9_INT_LATCHED_STS (at 0x7a18)"
        set &access:&cmd_addr %l (0x807a180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT9_INT_PENDING_STS"
      sgroup "PBS_CLIENT9_INT_PENDING_STS (at 0x7a19)"
        set &access:&cmd_addr %l (0x807a190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT9_INT_MID_SEL"
      sgroup "PBS_CLIENT9_INT_MID_SEL (at 0x7a1a)"
        set &access:&cmd_addr %l (0x807a1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT9_INT_PRIORITY"
      sgroup "PBS_CLIENT9_INT_PRIORITY (at 0x7a1b)"
        set &access:&cmd_addr %l (0x807a1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_TRIG_CFG"
      sgroup "PBS_CLIENT9_TRIG_CFG (at 0x7a40)"
        set &access:&cmd_addr %l (0x807a400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT9_TRIG_CTL"
      sgroup "PBS_CLIENT9_TRIG_CTL (at 0x7a42)"
        set &access:&cmd_addr %l (0x807a420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT9_EN_CTL"
      sgroup "PBS_CLIENT9_EN_CTL (at 0x7a46)"
        set &access:&cmd_addr %l (0x807a460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7a460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_SEC_ACCESS"
      sgroup "PBS_CLIENT9_SEC_ACCESS (at 0x7ad0)"
        set &access:&cmd_addr %l (0x807ad00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ad00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT9_PERPH_RESET_CTL1 (at 0x7ad8)"
        set &access:&cmd_addr %l (0x807ad80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ad80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT9_PERPH_RESET_CTL2 (at 0x7ad9)"
        set &access:&cmd_addr %l (0x807ad90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ad90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT9_PERPH_RESET_CTL3 (at 0x7ada)"
        set &access:&cmd_addr %l (0x807ada0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ada0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT9_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT9_PERPH_RESET_CTL4 (at 0x7adb)"
        set &access:&cmd_addr %l (0x807adb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7adb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST1"
      sgroup "PBS_CLIENT9_INT_TEST1 (at 0x7ae0)"
        set &access:&cmd_addr %l (0x807ae00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ae00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT9_INT_TEST_VAL"
      sgroup "PBS_CLIENT9_INT_TEST_VAL (at 0x7ae1)"
        set &access:&cmd_addr %l (0x807ae10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x7ae10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&cmd_addr %l (0x8070000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&cmd_addr %l (0x8070010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&cmd_addr %l (0x8070020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&cmd_addr %l (0x8070030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&cmd_addr %l (0x8070040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&cmd_addr %l (0x8070050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&cmd_addr %l (0x8070080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS3"
      sgroup "PBS_CORE_SEQ_STATUS3 (at 0x7009)"
        set &access:&cmd_addr %l (0x8070090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_MODE_STATUS                          = " "0 (NORMAL_MODE),1 (RIF_MEM_ACCESS_MODE)"
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&cmd_addr %l (0x80700a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&cmd_addr %l (0x80700b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&cmd_addr %l (0x80700c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&cmd_addr %l (0x80700d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&cmd_addr %l (0x80700e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&cmd_addr %l (0x80700f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x700f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&cmd_addr %l (0x8070400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&cmd_addr %l (0x8070410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&cmd_addr %l (0x8070420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&cmd_addr %l (0x8070430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&cmd_addr %l (0x8070480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&cmd_addr %l (0x8070490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&cmd_addr %l (0x80704a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&cmd_addr %l (0x80704b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&cmd_addr %l (0x80704c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&cmd_addr %l (0x80704d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&cmd_addr %l (0x80704e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&cmd_addr %l (0x80704f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x704f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
        set &access:&cmd_addr %l (0x8070500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
        set &access:&cmd_addr %l (0x8070510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
        set &access:&cmd_addr %l (0x8070540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
        set &access:&cmd_addr %l (0x8070550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
        set &access:&cmd_addr %l (0x8070580|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70580|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
        set &access:&cmd_addr %l (0x8070590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
        set &access:&cmd_addr %l (0x80705c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x705c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
        set &access:&cmd_addr %l (0x80705d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x705d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
        set &access:&cmd_addr %l (0x8070600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
        set &access:&cmd_addr %l (0x8070610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
        set &access:&cmd_addr %l (0x8070640|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70640|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
        set &access:&cmd_addr %l (0x8070650|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70650|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
        set &access:&cmd_addr %l (0x8070680|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70680|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
        set &access:&cmd_addr %l (0x8070690|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70690|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
        set &access:&cmd_addr %l (0x80706c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x706c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
        set &access:&cmd_addr %l (0x80706d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x706d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
        set &access:&cmd_addr %l (0x8070700|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70700|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
        set &access:&cmd_addr %l (0x8070710|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70710|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
        set &access:&cmd_addr %l (0x8070740|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70740|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
        set &access:&cmd_addr %l (0x8070750|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70750|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
        set &access:&cmd_addr %l (0x8070780|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70780|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
        set &access:&cmd_addr %l (0x8070790|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70790|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
        set &access:&cmd_addr %l (0x80707c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x707c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
        set &access:&cmd_addr %l (0x80707d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x707d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
        set &access:&cmd_addr %l (0x8070800|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70800|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
        set &access:&cmd_addr %l (0x8070810|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70810|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
        set &access:&cmd_addr %l (0x8070840|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70840|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
        set &access:&cmd_addr %l (0x8070850|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70850|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
        set &access:&cmd_addr %l (0x8070880|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70880|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
        set &access:&cmd_addr %l (0x8070890|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70890|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
        set &access:&cmd_addr %l (0x80708c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x708c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
        set &access:&cmd_addr %l (0x80708d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x708d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&cmd_addr %l (0x8070900|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70900|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&cmd_addr %l (0x8070910|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70910|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&cmd_addr %l (0x8070920|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70920|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&cmd_addr %l (0x8070930|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70930|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&cmd_addr %l (0x8070940|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70940|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&cmd_addr %l (0x8070950|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70950|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&cmd_addr %l (0x8070960|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70960|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&cmd_addr %l (0x8070970|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70970|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&cmd_addr %l (0x8070d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&cmd_addr %l (0x8070d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&cmd_addr %l (0x8070da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&cmd_addr %l (0x8070db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&cmd_addr %l (0x8070e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&cmd_addr %l (0x8070e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&cmd_addr %l (0x8070e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&cmd_addr %l (0x8070e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&cmd_addr %l (0x8070e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x70e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&cmd_addr %l (0x8008000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&cmd_addr %l (0x8008010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&cmd_addr %l (0x8008020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&cmd_addr %l (0x8008030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&cmd_addr %l (0x8008040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&cmd_addr %l (0x8008050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&cmd_addr %l (0x8008070|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8070|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REG_WRITE_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_RESET_ERROR                          = " "0 (NO_ERROR),1 (ERROR_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REG_SYNC_ERROR                           = " "0, 1"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x808)"
        set &access:&cmd_addr %l (0x8008080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x80a)"
        set &access:&cmd_addr %l (0x80080a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      sgroup "PON_WARM_RESET_REASON2 (at 0x80b)"
        set &access:&cmd_addr %l (0x80080b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x80c)"
        set &access:&cmd_addr %l (0x80080c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON2"
      sgroup "PON_POFF_REASON2 (at 0x80d)"
        set &access:&cmd_addr %l (0x80080d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGER                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x80e)"
        set &access:&cmd_addr %l (0x80080e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      sgroup "PON_SOFT_RESET_REASON2 (at 0x80f)"
        set &access:&cmd_addr %l (0x80080f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x80f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&cmd_addr %l (0x8008100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&cmd_addr %l (0x8008110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&cmd_addr %l (0x8008120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&cmd_addr %l (0x8008130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&cmd_addr %l (0x8008140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&cmd_addr %l (0x8008150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&cmd_addr %l (0x8008160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&cmd_addr %l (0x8008180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&cmd_addr %l (0x8008190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&cmd_addr %l (0x80081a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x81a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&cmd_addr %l (0x80081b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x81b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&cmd_addr %l (0x8008400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&cmd_addr %l (0x8008410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&cmd_addr %l (0x8008420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&cmd_addr %l (0x8008430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&cmd_addr %l (0x8008440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&cmd_addr %l (0x8008450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&cmd_addr %l (0x8008460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&cmd_addr %l (0x8008470|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8470|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&cmd_addr %l (0x8008480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&cmd_addr %l (0x8008490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&cmd_addr %l (0x80084a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&cmd_addr %l (0x80084b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&cmd_addr %l (0x80084c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&cmd_addr %l (0x80084d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&cmd_addr %l (0x80084e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&cmd_addr %l (0x80084f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x84f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&cmd_addr %l (0x8008500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&cmd_addr %l (0x8008510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&cmd_addr %l (0x8008520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&cmd_addr %l (0x8008530|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8530|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&cmd_addr %l (0x8008540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&cmd_addr %l (0x8008550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&cmd_addr %l (0x8008560|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8560|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&cmd_addr %l (0x8008570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&cmd_addr %l (0x8008580|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8580|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (reserved),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&cmd_addr %l (0x80085a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x85a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&cmd_addr %l (0x80085b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x85b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&cmd_addr %l (0x8008620|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8620|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&cmd_addr %l (0x8008630|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8630|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&cmd_addr %l (0x8008640|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8640|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      sgroup "PON_OVERTEMP_RESET_CTL (at 0x866)"
        set &access:&cmd_addr %l (0x8008660|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8660|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL2"
      sgroup "PON_OVERTEMP_RESET_CTL2 (at 0x867)"
        set &access:&cmd_addr %l (0x8008670|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8670|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_TFT_RESET_CTL"
      sgroup "PON_TFT_RESET_CTL (at 0x86a)"
        set &access:&cmd_addr %l (0x80086a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x86a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL2"
      sgroup "PON_TFT_RESET_CTL2 (at 0x86b)"
        set &access:&cmd_addr %l (0x80086b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x86b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&cmd_addr %l (0x8008700|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8700|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PD_DISABLED),1 (PD_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&cmd_addr %l (0x8008710|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8710|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0 (MS_15P6),1 (MS_31P2),2 (MS_62P5),3 (MS_125),4 (MS_250),5 (MS_500),6 (MS_1000),7 (MS_2000)"
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&cmd_addr %l (0x8008740|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8740|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&cmd_addr %l (0x8008750|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8750|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&cmd_addr %l (0x8008800|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8800|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&cmd_addr %l (0x8008820|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8820|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLOCK_50K_EN                             = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBG_EN                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_PWR_EN                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_WATCHDOG_LOCK"
      sgroup "PON_WATCHDOG_LOCK (at 0x883)"
        set &access:&cmd_addr %l (0x8008830|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8830|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_LOCK                             = " "0 (WD_UNLOCKED),1 (WD_LOCKED)"
    tree.end
    tree "PON_UVLO"
      sgroup "PON_UVLO (at 0x888)"
        set &access:&cmd_addr %l (0x8008880|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8880|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_AVDD_VPH"
      sgroup "PON_AVDD_VPH (at 0x88a)"
        set &access:&cmd_addr %l (0x80088a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_HPM_EN                              = " "0 (LPM),1 (HPM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&cmd_addr %l (0x80088c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&cmd_addr %l (0x80088d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&cmd_addr %l (0x80088e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&cmd_addr %l (0x80088f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x88f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      sgroup "PON_PON1_INTERFACE (at 0x890)"
        set &access:&cmd_addr %l (0x8008900|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8900|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&cmd_addr %l (0x8008910|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8910|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_FSM_CTL"
      sgroup "PON_FSM_CTL (at 0x894)"
        set &access:&cmd_addr %l (0x8008940|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8940|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_FSM                                  = "
    tree.end
    tree "PON_FSM_STATUS"
      sgroup "PON_FSM_STATUS (at 0x895)"
        set &access:&cmd_addr %l (0x8008950|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8950|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FSM_STATE                                = "
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&cmd_addr %l (0x8008d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&cmd_addr %l (0x8008d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&cmd_addr %l (0x8008da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&cmd_addr %l (0x8008db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&cmd_addr %l (0x8008e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&cmd_addr %l (0x8008e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&cmd_addr %l (0x8008e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&cmd_addr %l (0x8008e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&cmd_addr %l (0x8008e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PON_WARM_REASON_CLEAR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USE_MSME_FOR_DVDD                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&cmd_addr %l (0x8008e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      sgroup "PON_VMAX_SEL (at 0x8e7)"
        set &access:&cmd_addr %l (0x8008e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&cmd_addr %l (0x8008f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      sgroup "PON_PON_TRIM (at 0x8f1)"
        set &access:&cmd_addr %l (0x8008f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      sgroup "PON_PON_CNTL_2_TRIM (at 0x8f2)"
        set &access:&cmd_addr %l (0x8008f20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x8f20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "PWM_3D"
  tree "PWM_3D"
    tree "PWM_3D_REVISION1"
      sgroup "PWM_3D_REVISION1 (at 0x1bc00)"
        set &access:&cmd_addr %l (0x80bc000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbc000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PWM_3D_REVISION2"
      sgroup "PWM_3D_REVISION2 (at 0x1bc01)"
        set &access:&cmd_addr %l (0x80bc010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbc010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PWM_3D_PERPH_TYPE"
      sgroup "PWM_3D_PERPH_TYPE (at 0x1bc04)"
        set &access:&cmd_addr %l (0x80bc040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbc040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PWM_3D_PERPH_SUBTYPE"
      sgroup "PWM_3D_PERPH_SUBTYPE (at 0x1bc05)"
        set &access:&cmd_addr %l (0x80bc050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbc050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PWM_3D_PWM_SOURCE_SEL"
      sgroup "PWM_3D_PWM_SOURCE_SEL (at 0x1bc45)"
        set &access:&cmd_addr %l (0x80bc450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbc450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_SOURCE                               = " "0 (PWM_SRC_LPG0),1 (PWM_SRC_LPG1),2 (PWM_SRC_LPG2),3 (PWM_SRC_LPG3),4 (PWM_SRC_LPG4),5 (PWM_SRC_LPG5),6 (PWM_SRC_LPG6),7 (PWM_SRC_LPG7)"
    tree.end
    tree "PWM_3D_ENABLE_CONTROL"
      sgroup "PWM_3D_ENABLE_CONTROL (at 0x1bc46)"
        set &access:&cmd_addr %l (0x80bc460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
