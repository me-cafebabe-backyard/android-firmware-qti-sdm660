        set &access:&cmd_addr %l (0xbc460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_3D_PWM                                = " "0 (PWM_3D_DIS),1 (PWM_3D_EN)"
    tree.end
    tree "PWM_3D_PHASE_SELECT"
      sgroup "PWM_3D_PHASE_SELECT (at 0x1bc47)"
        set &access:&cmd_addr %l (0x80bc470|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbc470|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PHASE_SEL                                = "
    tree.end
    tree "PWM_3D_SEC_ACCESS"
      sgroup "PWM_3D_SEC_ACCESS (at 0x1bcd0)"
        set &access:&cmd_addr %l (0x80bcd00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbcd00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PWM_3D_PERPH_RESET_CTL2"
      sgroup "PWM_3D_PERPH_RESET_CTL2 (at 0x1bcd9)"
        set &access:&cmd_addr %l (0x80bcd90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbcd90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_3D_PERPH_RESET_CTL3"
      sgroup "PWM_3D_PERPH_RESET_CTL3 (at 0x1bcda)"
        set &access:&cmd_addr %l (0x80bcda0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbcda0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM_3D_PERPH_RESET_CTL4"
      sgroup "PWM_3D_PERPH_RESET_CTL4 (at 0x1bcdb)"
        set &access:&cmd_addr %l (0x80bcdb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xbcdb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&cmd_addr %l (0x8001000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&cmd_addr %l (0x8001010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&cmd_addr %l (0x8001020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&cmd_addr %l (0x8001030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&cmd_addr %l (0x8001040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&cmd_addr %l (0x8001050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      sgroup "REVID_STATUS1 (at 0x108)"
        set &access:&cmd_addr %l (0x8001080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OP4                                      = " "0 (OP4_GND),1 (reserved),2 (OP4_HIZ),3 (OP4_VDD)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OP3                                      = " "0 (OP3_GND),1 (reserved),2 (OP3_HIZ),3 (OP3_VDD)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OP2                                      = " "0 (OP2_GND),1 (reserved),2 (OP2_HIZ),3 (OP2_VDD)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OP1                                      = " "0 (OP1_GND),1 (reserved),2 (OP1_HIZ),3 (OP1_VDD)"
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&cmd_addr %l (0x8001d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      sgroup "REVID_TEST1 (at 0x1e0)"
        set &access:&cmd_addr %l (0x8001e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0 (FORCE_ON_DISABLED),1 (FORCE_ON_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (DTEST_DISABLED),1 (DTEST_OPT1),2 (DTEST_OPT2),3 (DTEST_OPT3),4 (DTEST_OPT4),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
  tree.end
tree.end
tree "RF_CLK1"
  tree "RF_CLK1"
    tree "RF_CLK1_REVISION1"
      sgroup "RF_CLK1_REVISION1 (at 0x5400)"
        set &access:&cmd_addr %l (0x8054000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION2"
      sgroup "RF_CLK1_REVISION2 (at 0x5401)"
        set &access:&cmd_addr %l (0x8054010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK1_REVISION3"
      sgroup "RF_CLK1_REVISION3 (at 0x5402)"
        set &access:&cmd_addr %l (0x8054020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION4"
      sgroup "RF_CLK1_REVISION4 (at 0x5403)"
        set &access:&cmd_addr %l (0x8054030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK1_PERPH_TYPE"
      sgroup "RF_CLK1_PERPH_TYPE (at 0x5404)"
        set &access:&cmd_addr %l (0x8054040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK1_PERPH_SUBTYPE"
      sgroup "RF_CLK1_PERPH_SUBTYPE (at 0x5405)"
        set &access:&cmd_addr %l (0x8054050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK1_STATUS1"
      sgroup "RF_CLK1_STATUS1 (at 0x5408)"
        set &access:&cmd_addr %l (0x8054080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK1_DRV_CTL1"
      sgroup "RF_CLK1_DRV_CTL1 (at 0x5444)"
        set &access:&cmd_addr %l (0x8054440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK1_EN_CTL"
      sgroup "RF_CLK1_EN_CTL (at 0x5446)"
        set &access:&cmd_addr %l (0x8054460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK1_PD_CTL"
      sgroup "RF_CLK1_PD_CTL (at 0x5448)"
        set &access:&cmd_addr %l (0x8054480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK1_SEC_ACCESS"
      sgroup "RF_CLK1_SEC_ACCESS (at 0x54d0)"
        set &access:&cmd_addr %l (0x8054d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL1"
      sgroup "RF_CLK1_PERPH_RESET_CTL1 (at 0x54d8)"
        set &access:&cmd_addr %l (0x8054d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL2"
      sgroup "RF_CLK1_PERPH_RESET_CTL2 (at 0x54d9)"
        set &access:&cmd_addr %l (0x8054d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL3"
      sgroup "RF_CLK1_PERPH_RESET_CTL3 (at 0x54da)"
        set &access:&cmd_addr %l (0x8054da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL4"
      sgroup "RF_CLK1_PERPH_RESET_CTL4 (at 0x54db)"
        set &access:&cmd_addr %l (0x8054db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x54db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK2"
  tree "RF_CLK2"
    tree "RF_CLK2_REVISION1"
      sgroup "RF_CLK2_REVISION1 (at 0x5500)"
        set &access:&cmd_addr %l (0x8055000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION2"
      sgroup "RF_CLK2_REVISION2 (at 0x5501)"
        set &access:&cmd_addr %l (0x8055010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK2_REVISION3"
      sgroup "RF_CLK2_REVISION3 (at 0x5502)"
        set &access:&cmd_addr %l (0x8055020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION4"
      sgroup "RF_CLK2_REVISION4 (at 0x5503)"
        set &access:&cmd_addr %l (0x8055030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK2_PERPH_TYPE"
      sgroup "RF_CLK2_PERPH_TYPE (at 0x5504)"
        set &access:&cmd_addr %l (0x8055040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK2_PERPH_SUBTYPE"
      sgroup "RF_CLK2_PERPH_SUBTYPE (at 0x5505)"
        set &access:&cmd_addr %l (0x8055050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK2_STATUS1"
      sgroup "RF_CLK2_STATUS1 (at 0x5508)"
        set &access:&cmd_addr %l (0x8055080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK2_DRV_CTL1"
      sgroup "RF_CLK2_DRV_CTL1 (at 0x5544)"
        set &access:&cmd_addr %l (0x8055440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK2_EN_CTL"
      sgroup "RF_CLK2_EN_CTL (at 0x5546)"
        set &access:&cmd_addr %l (0x8055460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK2_PD_CTL"
      sgroup "RF_CLK2_PD_CTL (at 0x5548)"
        set &access:&cmd_addr %l (0x8055480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK2_SEC_ACCESS"
      sgroup "RF_CLK2_SEC_ACCESS (at 0x55d0)"
        set &access:&cmd_addr %l (0x8055d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL1"
      sgroup "RF_CLK2_PERPH_RESET_CTL1 (at 0x55d8)"
        set &access:&cmd_addr %l (0x8055d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL2"
      sgroup "RF_CLK2_PERPH_RESET_CTL2 (at 0x55d9)"
        set &access:&cmd_addr %l (0x8055d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL3"
      sgroup "RF_CLK2_PERPH_RESET_CTL3 (at 0x55da)"
        set &access:&cmd_addr %l (0x8055da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL4"
      sgroup "RF_CLK2_PERPH_RESET_CTL4 (at 0x55db)"
        set &access:&cmd_addr %l (0x8055db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x55db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK3"
  tree "RF_CLK3"
    tree "RF_CLK3_REVISION1"
      sgroup "RF_CLK3_REVISION1 (at 0x5600)"
        set &access:&cmd_addr %l (0x8056000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK3_REVISION2"
      sgroup "RF_CLK3_REVISION2 (at 0x5601)"
        set &access:&cmd_addr %l (0x8056010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK3_REVISION3"
      sgroup "RF_CLK3_REVISION3 (at 0x5602)"
        set &access:&cmd_addr %l (0x8056020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK3_REVISION4"
      sgroup "RF_CLK3_REVISION4 (at 0x5603)"
        set &access:&cmd_addr %l (0x8056030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK3_PERPH_TYPE"
      sgroup "RF_CLK3_PERPH_TYPE (at 0x5604)"
        set &access:&cmd_addr %l (0x8056040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK3_PERPH_SUBTYPE"
      sgroup "RF_CLK3_PERPH_SUBTYPE (at 0x5605)"
        set &access:&cmd_addr %l (0x8056050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK3_STATUS1"
      sgroup "RF_CLK3_STATUS1 (at 0x5608)"
        set &access:&cmd_addr %l (0x8056080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
    tree.end
    tree "RF_CLK3_DRV_CTL1"
      sgroup "RF_CLK3_DRV_CTL1 (at 0x5644)"
        set &access:&cmd_addr %l (0x8056440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK3_EN_CTL"
      sgroup "RF_CLK3_EN_CTL (at 0x5646)"
        set &access:&cmd_addr %l (0x8056460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK3_PD_CTL"
      sgroup "RF_CLK3_PD_CTL (at 0x5648)"
        set &access:&cmd_addr %l (0x8056480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK3_SEC_ACCESS"
      sgroup "RF_CLK3_SEC_ACCESS (at 0x56d0)"
        set &access:&cmd_addr %l (0x8056d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL1"
      sgroup "RF_CLK3_PERPH_RESET_CTL1 (at 0x56d8)"
        set &access:&cmd_addr %l (0x8056d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL2"
      sgroup "RF_CLK3_PERPH_RESET_CTL2 (at 0x56d9)"
        set &access:&cmd_addr %l (0x8056d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL3"
      sgroup "RF_CLK3_PERPH_RESET_CTL3 (at 0x56da)"
        set &access:&cmd_addr %l (0x8056da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL4"
      sgroup "RF_CLK3_PERPH_RESET_CTL4 (at 0x56db)"
        set &access:&cmd_addr %l (0x8056db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x56db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (RESET_MODULE)"
    tree.end
  tree.end
tree.end
tree "RTC_ALARM"
  tree "RTC_ALARM"
    tree "RTC_ALARM_REVISION1"
      sgroup "RTC_ALARM_REVISION1 (at 0x6100)"
        set &access:&cmd_addr %l (0x8061000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_ALARM_REVISION2"
      sgroup "RTC_ALARM_REVISION2 (at 0x6101)"
        set &access:&cmd_addr %l (0x8061010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_ALARM_PERPH_TYPE"
      sgroup "RTC_ALARM_PERPH_TYPE (at 0x6104)"
        set &access:&cmd_addr %l (0x8061040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_ALARM_PERPH_SUBTYPE"
      sgroup "RTC_ALARM_PERPH_SUBTYPE (at 0x6105)"
        set &access:&cmd_addr %l (0x8061050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_ALARM_STATUS1"
      sgroup "RTC_ALARM_STATUS1 (at 0x6108)"
        set &access:&cmd_addr %l (0x8061080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_ALARM_OK                             = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
    tree.end
    tree "RTC_ALARM_INT_RT_STS"
      sgroup "RTC_ALARM_INT_RT_STS (at 0x6110)"
        set &access:&cmd_addr %l (0x8061100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (RTC_ALARM_NOT_EXPIRED),1 (RTC_ALARM_EXPIRED)"
    tree.end
    tree "RTC_ALARM_INT_SET_TYPE"
      sgroup "RTC_ALARM_INT_SET_TYPE (at 0x6111)"
        set &access:&cmd_addr %l (0x8061110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_HIGH"
      sgroup "RTC_ALARM_INT_POLARITY_HIGH (at 0x6112)"
        set &access:&cmd_addr %l (0x8061120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_LOW"
      sgroup "RTC_ALARM_INT_POLARITY_LOW (at 0x6113)"
        set &access:&cmd_addr %l (0x8061130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_CLR"
      sgroup "RTC_ALARM_INT_LATCHED_CLR (at 0x6114)"
        set &access:&cmd_addr %l (0x8061140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_EN_SET"
      sgroup "RTC_ALARM_INT_EN_SET (at 0x6115)"
        set &access:&cmd_addr %l (0x8061150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_EN_CLR"
      sgroup "RTC_ALARM_INT_EN_CLR (at 0x6116)"
        set &access:&cmd_addr %l (0x8061160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_STS"
      sgroup "RTC_ALARM_INT_LATCHED_STS (at 0x6118)"
        set &access:&cmd_addr %l (0x8061180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_ALARM_INT_PENDING_STS"
      sgroup "RTC_ALARM_INT_PENDING_STS (at 0x6119)"
        set &access:&cmd_addr %l (0x8061190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_ALARM_INT_MID_SEL"
      sgroup "RTC_ALARM_INT_MID_SEL (at 0x611a)"
        set &access:&cmd_addr %l (0x80611a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x611a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_ALARM_INT_PRIORITY"
      sgroup "RTC_ALARM_INT_PRIORITY (at 0x611b)"
        set &access:&cmd_addr %l (0x80611b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x611b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_ALARM_ALARM_DATA0"
      sgroup "RTC_ALARM_ALARM_DATA0 (at 0x6140)"
        set &access:&cmd_addr %l (0x8061400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA0                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA1"
      sgroup "RTC_ALARM_ALARM_DATA1 (at 0x6141)"
        set &access:&cmd_addr %l (0x8061410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA1                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA2"
      sgroup "RTC_ALARM_ALARM_DATA2 (at 0x6142)"
        set &access:&cmd_addr %l (0x8061420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA2                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA3"
      sgroup "RTC_ALARM_ALARM_DATA3 (at 0x6143)"
        set &access:&cmd_addr %l (0x8061430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA3                          = "
    tree.end
    tree "RTC_ALARM_EN_CTL1"
      sgroup "RTC_ALARM_EN_CTL1 (at 0x6146)"
        set &access:&cmd_addr %l (0x8061460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ALARM_EN                                 = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABORT_EN                                 = " "0 (RTC_STARTUP_DOESNT_ABORT),1 (RTC_STARTUP_ABORT_EN)"
    tree.end
    tree "RTC_ALARM_ALARM_CLR"
      sgroup "RTC_ALARM_ALARM_CLR (at 0x6148)"
        set &access:&cmd_addr %l (0x8061480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALARM_CLR                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_SEC_ACCESS"
      sgroup "RTC_ALARM_SEC_ACCESS (at 0x61d0)"
        set &access:&cmd_addr %l (0x8061d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL1"
      sgroup "RTC_ALARM_PERPH_RESET_CTL1 (at 0x61d8)"
        set &access:&cmd_addr %l (0x8061d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL2"
      sgroup "RTC_ALARM_PERPH_RESET_CTL2 (at 0x61d9)"
        set &access:&cmd_addr %l (0x8061d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL3"
      sgroup "RTC_ALARM_PERPH_RESET_CTL3 (at 0x61da)"
        set &access:&cmd_addr %l (0x8061da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL4"
      sgroup "RTC_ALARM_PERPH_RESET_CTL4 (at 0x61db)"
        set &access:&cmd_addr %l (0x8061db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_TEST1"
      sgroup "RTC_ALARM_INT_TEST1 (at 0x61e0)"
        set &access:&cmd_addr %l (0x8061e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_ALARM_INT_TEST_VAL"
      sgroup "RTC_ALARM_INT_TEST_VAL (at 0x61e1)"
        set &access:&cmd_addr %l (0x8061e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM_TEST_VAL                       = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_TIMER"
  tree "RTC_TIMER"
    tree "RTC_TIMER_REVISION1"
      sgroup "RTC_TIMER_REVISION1 (at 0x6200)"
        set &access:&cmd_addr %l (0x8062000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_TIMER_REVISION2"
      sgroup "RTC_TIMER_REVISION2 (at 0x6201)"
        set &access:&cmd_addr %l (0x8062010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_TIMER_PERPH_TYPE"
      sgroup "RTC_TIMER_PERPH_TYPE (at 0x6204)"
        set &access:&cmd_addr %l (0x8062040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_TIMER_PERPH_SUBTYPE"
      sgroup "RTC_TIMER_PERPH_SUBTYPE (at 0x6205)"
        set &access:&cmd_addr %l (0x8062050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_TIMER_STATUS1"
      sgroup "RTC_TIMER_STATUS1 (at 0x6208)"
        set &access:&cmd_addr %l (0x8062080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_OK                                 = " "0 (TIMER_OFF),1 (TIMER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_RT_STS"
      sgroup "RTC_TIMER_INT_RT_STS (at 0x6210)"
        set &access:&cmd_addr %l (0x8062100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_SET_TYPE"
      sgroup "RTC_TIMER_INT_SET_TYPE (at 0x6211)"
        set &access:&cmd_addr %l (0x8062110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_HIGH"
      sgroup "RTC_TIMER_INT_POLARITY_HIGH (at 0x6212)"
        set &access:&cmd_addr %l (0x8062120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_LOW"
      sgroup "RTC_TIMER_INT_POLARITY_LOW (at 0x6213)"
        set &access:&cmd_addr %l (0x8062130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_CLR"
      sgroup "RTC_TIMER_INT_LATCHED_CLR (at 0x6214)"
        set &access:&cmd_addr %l (0x8062140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_EN_SET"
      sgroup "RTC_TIMER_INT_EN_SET (at 0x6215)"
        set &access:&cmd_addr %l (0x8062150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_EN_CLR"
      sgroup "RTC_TIMER_INT_EN_CLR (at 0x6216)"
        set &access:&cmd_addr %l (0x8062160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_STS"
      sgroup "RTC_TIMER_INT_LATCHED_STS (at 0x6218)"
        set &access:&cmd_addr %l (0x8062180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_TIMER_INT_PENDING_STS"
      sgroup "RTC_TIMER_INT_PENDING_STS (at 0x6219)"
        set &access:&cmd_addr %l (0x8062190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_TIMER_INT_MID_SEL"
      sgroup "RTC_TIMER_INT_MID_SEL (at 0x621a)"
        set &access:&cmd_addr %l (0x80621a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x621a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_TIMER_INT_PRIORITY"
      sgroup "RTC_TIMER_INT_PRIORITY (at 0x621b)"
        set &access:&cmd_addr %l (0x80621b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x621b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_TIMER_TIMER_DATA1"
      sgroup "RTC_TIMER_TIMER_DATA1 (at 0x6240)"
        set &access:&cmd_addr %l (0x8062400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA1                              = "
    tree.end
    tree "RTC_TIMER_TIMER_DATA2"
      sgroup "RTC_TIMER_TIMER_DATA2 (at 0x6242)"
        set &access:&cmd_addr %l (0x8062420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA2                              = "
    tree.end
    tree "RTC_TIMER_TIMER_MODE"
      sgroup "RTC_TIMER_TIMER_MODE (at 0x6245)"
        set &access:&cmd_addr %l (0x8062450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONTINUOUS                               = " "0 (TIMER_STOPS),1 (TIMER_RESTARTS)"
    tree.end
    tree "RTC_TIMER_EN_CTL"
      sgroup "RTC_TIMER_EN_CTL (at 0x6246)"
        set &access:&cmd_addr %l (0x8062460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_EN                                 = " "0 (TIMER_DIS),1 (TIMER_EN)"
    tree.end
    tree "RTC_TIMER_TIMER_RDATA1"
      sgroup "RTC_TIMER_TIMER_RDATA1 (at 0x6248)"
        set &access:&cmd_addr %l (0x8062480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA1                             = "
    tree.end
    tree "RTC_TIMER_TIMER_RDATA2"
      sgroup "RTC_TIMER_TIMER_RDATA2 (at 0x6249)"
        set &access:&cmd_addr %l (0x8062490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA2                             = "
    tree.end
    tree "RTC_TIMER_SEC_ACCESS"
      sgroup "RTC_TIMER_SEC_ACCESS (at 0x62d0)"
        set &access:&cmd_addr %l (0x8062d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL1"
      sgroup "RTC_TIMER_PERPH_RESET_CTL1 (at 0x62d8)"
        set &access:&cmd_addr %l (0x8062d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL2"
      sgroup "RTC_TIMER_PERPH_RESET_CTL2 (at 0x62d9)"
        set &access:&cmd_addr %l (0x8062d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL3"
      sgroup "RTC_TIMER_PERPH_RESET_CTL3 (at 0x62da)"
        set &access:&cmd_addr %l (0x8062da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL4"
      sgroup "RTC_TIMER_PERPH_RESET_CTL4 (at 0x62db)"
        set &access:&cmd_addr %l (0x8062db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_TEST1"
      sgroup "RTC_TIMER_INT_TEST1 (at 0x62e0)"
        set &access:&cmd_addr %l (0x8062e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_TIMER_INT_TEST_VAL"
      sgroup "RTC_TIMER_INT_TEST_VAL (at 0x62e1)"
        set &access:&cmd_addr %l (0x8062e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x62e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED_TEST_VAL                   = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_WR"
  tree "RTC_WR"
    tree "RTC_WR_REVISION1"
      sgroup "RTC_WR_REVISION1 (at 0x6000)"
        set &access:&cmd_addr %l (0x8060000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_WR_REVISION2"
      sgroup "RTC_WR_REVISION2 (at 0x6001)"
        set &access:&cmd_addr %l (0x8060010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_WR_PERPH_TYPE"
      sgroup "RTC_WR_PERPH_TYPE (at 0x6004)"
        set &access:&cmd_addr %l (0x8060040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_WR_PERPH_SUBTYPE"
      sgroup "RTC_WR_PERPH_SUBTYPE (at 0x6005)"
        set &access:&cmd_addr %l (0x8060050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_WR_STATUS1"
      sgroup "RTC_WR_STATUS1 (at 0x6008)"
        set &access:&cmd_addr %l (0x8060080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_OK                                   = " "0 (RTC_OFF),1 (RTC_ON)"
    tree.end
    tree "RTC_WR_INT_RT_STS"
      sgroup "RTC_WR_INT_RT_STS (at 0x6010)"
        set &access:&cmd_addr %l (0x8060100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (RTC_1SEC_NOT_EXPIRED),1 (RTC_1SEC_EXPIRED)"
    tree.end
    tree "RTC_WR_INT_SET_TYPE"
      sgroup "RTC_WR_INT_SET_TYPE (at 0x6011)"
        set &access:&cmd_addr %l (0x8060110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_WR_INT_POLARITY_HIGH"
      sgroup "RTC_WR_INT_POLARITY_HIGH (at 0x6012)"
        set &access:&cmd_addr %l (0x8060120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_WR_INT_POLARITY_LOW"
      sgroup "RTC_WR_INT_POLARITY_LOW (at 0x6013)"
        set &access:&cmd_addr %l (0x8060130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_WR_INT_LATCHED_CLR"
      sgroup "RTC_WR_INT_LATCHED_CLR (at 0x6014)"
        set &access:&cmd_addr %l (0x8060140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_WR_INT_EN_SET"
      sgroup "RTC_WR_INT_EN_SET (at 0x6015)"
        set &access:&cmd_addr %l (0x8060150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_WR_INT_EN_CLR"
      sgroup "RTC_WR_INT_EN_CLR (at 0x6016)"
        set &access:&cmd_addr %l (0x8060160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_WR_INT_LATCHED_STS"
      sgroup "RTC_WR_INT_LATCHED_STS (at 0x6018)"
        set &access:&cmd_addr %l (0x8060180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_WR_INT_PENDING_STS"
      sgroup "RTC_WR_INT_PENDING_STS (at 0x6019)"
        set &access:&cmd_addr %l (0x8060190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_WR_INT_MID_SEL"
      sgroup "RTC_WR_INT_MID_SEL (at 0x601a)"
        set &access:&cmd_addr %l (0x80601a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x601a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_WR_INT_PRIORITY"
      sgroup "RTC_WR_INT_PRIORITY (at 0x601b)"
        set &access:&cmd_addr %l (0x80601b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x601b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_WR_WDATA0"
      sgroup "RTC_WR_WDATA0 (at 0x6040)"
        set &access:&cmd_addr %l (0x8060400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA0                               = "
    tree.end
    tree "RTC_WR_WDATA1"
      sgroup "RTC_WR_WDATA1 (at 0x6041)"
        set &access:&cmd_addr %l (0x8060410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA1                               = "
    tree.end
    tree "RTC_WR_WDATA2"
      sgroup "RTC_WR_WDATA2 (at 0x6042)"
        set &access:&cmd_addr %l (0x8060420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA2                               = "
    tree.end
    tree "RTC_WR_WDATA3"
      sgroup "RTC_WR_WDATA3 (at 0x6043)"
        set &access:&cmd_addr %l (0x8060430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA3                               = "
    tree.end
    tree "RTC_WR_TIME_ADJ"
      sgroup "RTC_WR_TIME_ADJ (at 0x6044)"
        set &access:&cmd_addr %l (0x8060440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RTC_TIME_ADJ                             = "
    tree.end
    tree "RTC_WR_EN_CTL1"
      sgroup "RTC_WR_EN_CTL1 (at 0x6046)"
        set &access:&cmd_addr %l (0x8060460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_EN                                   = " "0 (RTC_COUNTER_DIS),1 (RTC_COUNTER_EN)"
    tree.end
    tree "RTC_WR_RDATA0"
      sgroup "RTC_WR_RDATA0 (at 0x6048)"
        set &access:&cmd_addr %l (0x8060480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA0                               = "
    tree.end
    tree "RTC_WR_RDATA1"
      sgroup "RTC_WR_RDATA1 (at 0x6049)"
        set &access:&cmd_addr %l (0x8060490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA1                               = "
    tree.end
    tree "RTC_WR_RDATA2"
      sgroup "RTC_WR_RDATA2 (at 0x604a)"
        set &access:&cmd_addr %l (0x80604a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x604a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA2                               = "
    tree.end
    tree "RTC_WR_RDATA3"
      sgroup "RTC_WR_RDATA3 (at 0x604b)"
        set &access:&cmd_addr %l (0x80604b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x604b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA3                               = "
    tree.end
    tree "RTC_WR_SEC_ACCESS"
      sgroup "RTC_WR_SEC_ACCESS (at 0x60d0)"
        set &access:&cmd_addr %l (0x8060d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL1"
      sgroup "RTC_WR_PERPH_RESET_CTL1 (at 0x60d8)"
        set &access:&cmd_addr %l (0x8060d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL2"
      sgroup "RTC_WR_PERPH_RESET_CTL2 (at 0x60d9)"
        set &access:&cmd_addr %l (0x8060d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL3"
      sgroup "RTC_WR_PERPH_RESET_CTL3 (at 0x60da)"
        set &access:&cmd_addr %l (0x8060da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "RTC_WR_PERPH_RESET_CTL4"
      sgroup "RTC_WR_PERPH_RESET_CTL4 (at 0x60db)"
        set &access:&cmd_addr %l (0x8060db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "RTC_WR_INT_TEST1"
      sgroup "RTC_WR_INT_TEST1 (at 0x60e0)"
        set &access:&cmd_addr %l (0x8060e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_WR_INT_TEST_VAL"
      sgroup "RTC_WR_INT_TEST_VAL (at 0x60e1)"
        set &access:&cmd_addr %l (0x8060e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ_TEST_VAL                         = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "RTC_WR_TEST1"
      sgroup "RTC_WR_TEST1 (at 0x60e2)"
        set &access:&cmd_addr %l (0x8060e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST1                                   = " "0 (NORMAL),1 (RTC_1HZ_ON_DTEST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIV20CLKSEL                              = " "0 (NORMAL),1 (ALT_SLP_ON_DIV20)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIVSEL                                   = " "0 (DIV16384),1 (DIV20)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASSDIV2                               = " "0 (DIV2),1 (BYPASS_DIV2)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (NONE),1 (CLK_1HZ),2 (CLK_1HZ_LATCH),3 (LOAD),4 (ABORT_ALARM),5 (ALARM_INT),6 (RTC_ALARM),7 (ALARM_RST_N)"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      sgroup "S1_CTRL_REVISION1 (at 0x11400)"
        set &access:&cmd_addr %l (0x8014000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      sgroup "S1_CTRL_REVISION2 (at 0x11401)"
        set &access:&cmd_addr %l (0x8014010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      sgroup "S1_CTRL_REVISION3 (at 0x11402)"
        set &access:&cmd_addr %l (0x8014020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      sgroup "S1_CTRL_REVISION4 (at 0x11403)"
        set &access:&cmd_addr %l (0x8014030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      sgroup "S1_CTRL_PERPH_TYPE (at 0x11404)"
        set &access:&cmd_addr %l (0x8014040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      sgroup "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
        set &access:&cmd_addr %l (0x8014050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS_1"
      sgroup "S1_CTRL_STATUS_1 (at 0x11408)"
        set &access:&cmd_addr %l (0x8014080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0 (VREG_OK_FLAG_FALSE),1 (VREG_OK_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS_2"
      sgroup "S1_CTRL_STATUS_2 (at 0x11409)"
        set &access:&cmd_addr %l (0x8014090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS_3"
      sgroup "S1_CTRL_STATUS_3 (at 0x1140a)"
        set &access:&cmd_addr %l (0x80140a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x140a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0 (PS_CAL_DONE_FLAG_FALSE),1 (PS_CAL_DONE_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS_4"
      sgroup "S1_CTRL_STATUS_4 (at 0x1140b)"
        set &access:&cmd_addr %l (0x80140b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x140b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      sgroup "S1_CTRL_INT_RT_STS (at 0x11410)"
        set &access:&cmd_addr %l (0x8014100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      sgroup "S1_CTRL_INT_SET_TYPE (at 0x11411)"
        set &access:&cmd_addr %l (0x8014110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_LEVEL_TRIGGERED),1 (VREG_OK_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      sgroup "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
        set &access:&cmd_addr %l (0x8014120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_OK_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      sgroup "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
        set &access:&cmd_addr %l (0x8014130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_OK_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      sgroup "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
        set &access:&cmd_addr %l (0x8014140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      sgroup "S1_CTRL_INT_EN_SET (at 0x11415)"
        set &access:&cmd_addr %l (0x8014150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_DISABL),1 (LIMIT_ERR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_DISABL),1 (VREG_OK_INT_ENABL)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      sgroup "S1_CTRL_INT_EN_CLR (at 0x11416)"
        set &access:&cmd_addr %l (0x8014160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_DISABL),1 (LIMIT_ERR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_DISABL),1 (VREG_OK_INT_ENABL)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      sgroup "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
        set &access:&cmd_addr %l (0x8014180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_NOT_TRIGGERED),1 (LIMIT_ERR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_NOT_TRIGGERED),1 (VREG_OK_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      sgroup "S1_CTRL_INT_PENDING_STS (at 0x11419)"
        set &access:&cmd_addr %l (0x8014190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_NOT_PENDING),1 (LIMIT_ERR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_NOT_PENDING),1 (VREG_OK_INT_PENDING)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      sgroup "S1_CTRL_INT_MID_SEL (at 0x1141a)"
        set &access:&cmd_addr %l (0x80141a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x141a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      sgroup "S1_CTRL_INT_PRIORITY (at 0x1141b)"
        set &access:&cmd_addr %l (0x80141b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x141b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL1"
      sgroup "S1_CTRL_VOLTAGE_CTL1 (at 0x11440)"
        set &access:&cmd_addr %l (0x8014400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      sgroup "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
        set &access:&cmd_addr %l (0x8014410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S1_CTRL_VSET_VALID"
      sgroup "S1_CTRL_VSET_VALID (at 0x11442)"
        set &access:&cmd_addr %l (0x8014420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL3"
      sgroup "S1_CTRL_VOLTAGE_CTL3 (at 0x11444)"
        set &access:&cmd_addr %l (0x8014440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0 (PFM_VOFFSET_EN_FALSE),1 (PFM_VOFFSET_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      sgroup "S1_CTRL_MODE_CTL (at 0x11445)"
        set &access:&cmd_addr %l (0x8014450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S1_CTRL_EN_CTL"
      sgroup "S1_CTRL_EN_CTL (at 0x11446)"
        set &access:&cmd_addr %l (0x8014460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      sgroup "S1_CTRL_PD_CTL (at 0x11448)"
        set &access:&cmd_addr %l (0x8014480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S1_CTRL_FREQ_CTL"
      sgroup "S1_CTRL_FREQ_CTL (at 0x11450)"
        set &access:&cmd_addr %l (0x8014500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S1_CTRL_MULTIPHASE_CTL"
      sgroup "S1_CTRL_MULTIPHASE_CTL (at 0x11451)"
        set &access:&cmd_addr %l (0x8014510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
    tree.end
    tree "S1_CTRL_PHASE_CTL"
      sgroup "S1_CTRL_PHASE_CTL (at 0x11452)"
        set &access:&cmd_addr %l (0x8014520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0 (DISABL_ACTIVE_PHASE_CURRENT_BALANCING),1 (ENABL_ACTIVE_PHASE_CURRENT_BALANCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S1_CTRL_PHASE_ID"
      sgroup "S1_CTRL_PHASE_ID (at 0x11453)"
        set &access:&cmd_addr %l (0x8014530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0 (PHASE_NUMBER_1),1 (PHASE_NUMBER_2),2 (PHASE_NUMBER_3),3 (PHASE_NUMBER_4)"
    tree.end
    tree "S1_CTRL_PHASE_CNT"
      sgroup "S1_CTRL_PHASE_CNT (at 0x11454)"
        set &access:&cmd_addr %l (0x8014540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0 (PHASE_COUNT_1),1 (PHASE_COUNT_2),2 (PHASE_COUNT_4_NOT_3),3 (PHASE_COUNT_4)"
    tree.end
    tree "S1_CTRL_SPARE"
      sgroup "S1_CTRL_SPARE (at 0x11455)"
        set &access:&cmd_addr %l (0x8014550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (SPARE1_BIT_STATE_0),1 (SPARE1_BIT_STATE_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0 (SPARE0_BIT_STATE_0),1 (SPARE0_BIT_STATE_1)"
    tree.end
    tree "S1_CTRL_SS_CTL"
      sgroup "S1_CTRL_SS_CTL (at 0x11460)"
        set &access:&cmd_addr %l (0x8014600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S1_CTRL_VS_CTL"
      sgroup "S1_CTRL_VS_CTL (at 0x11461)"
        set &access:&cmd_addr %l (0x8014610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S1_CTRL_CORR_CFG"
      sgroup "S1_CTRL_CORR_CFG (at 0x11462)"
        set &access:&cmd_addr %l (0x8014620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S1_CTRL_RAMP_CFG"
      sgroup "S1_CTRL_RAMP_CFG (at 0x11463)"
        set &access:&cmd_addr %l (0x8014630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0 (RAMP_CFG_20MV),1 (RAMP_CFG_30MV),2 (RAMP_CFG_40MV),3 (RAMP_CFG_50MV),4 (DRAMP_CFG_60MV),5 (DRAMP_CFG_70MV),6 (RAMP_CFG_80MV),7 (DRAMP_CFG_90MV)"
    tree.end
    tree "S1_CTRL_COMPENS_CFG"
      sgroup "S1_CTRL_COMPENS_CFG (at 0x11464)"
        set &access:&cmd_addr %l (0x8014640|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14640|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
    tree.end
    tree "S1_CTRL_CFG_VREG_OK"
      sgroup "S1_CTRL_CFG_VREG_OK (at 0x11465)"
        set &access:&cmd_addr %l (0x8014650|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14650|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0 (VREG_OK_COMP_DISABL),1 (VREG_OK_COMP_ENABL_IN_NPM),2 (VREG_OK_COMP_ENABL_IN_NPM_AND_LPM),3 (ILLEGAL_SETTING)"
    tree.end
    tree "S1_CTRL_CFG_VREG_FAULT"
      sgroup "S1_CTRL_CFG_VREG_FAULT (at 0x11466)"
        set &access:&cmd_addr %l (0x8014660|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14660|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0 (VREG_FAULT_FOLDBACK_COMP_DISABL),1 (VREG_FAULT_FOLDBACK_COMP_ENABL_IN_NPM),2 (VREG_FAULT_FOLDBACK_COMP_ENABL_IN_NPM_AND_LPM),3 (ILLEGAL_SETTING)"
    tree.end
    tree "S1_CTRL_CFG_PFM_COMP"
      sgroup "S1_CTRL_CFG_PFM_COMP (at 0x11467)"
        set &access:&cmd_addr %l (0x8014670|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14670|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S1_CTRL_UL_LL_CTL"
      sgroup "S1_CTRL_UL_LL_CTL (at 0x11468)"
        set &access:&cmd_addr %l (0x8014680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S1_CTRL_VSET_ULS"
      sgroup "S1_CTRL_VSET_ULS (at 0x11469)"
        set &access:&cmd_addr %l (0x8014690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S1_CTRL_ULS_VALID"
      sgroup "S1_CTRL_ULS_VALID (at 0x1146a)"
        set &access:&cmd_addr %l (0x80146a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x146a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S1_CTRL_VSET_LLS"
      sgroup "S1_CTRL_VSET_LLS (at 0x1146b)"
        set &access:&cmd_addr %l (0x80146b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x146b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S1_CTRL_LLS_VALID"
      sgroup "S1_CTRL_LLS_VALID (at 0x1146c)"
        set &access:&cmd_addr %l (0x80146c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x146c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S1_CTRL_GPL_HI"
      sgroup "S1_CTRL_GPL_HI (at 0x1146d)"
        set &access:&cmd_addr %l (0x80146d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x146d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S1_CTRL_GPL_LO"
      sgroup "S1_CTRL_GPL_LO (at 0x1146e)"
        set &access:&cmd_addr %l (0x80146e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x146e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S1_CTRL_FB_FILT_CFG"
      sgroup "S1_CTRL_FB_FILT_CFG (at 0x1146f)"
        set &access:&cmd_addr %l (0x80146f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x146f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FB_FILT_CFG                              = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S1_CTRL_CFG_ATEST1"
      sgroup "S1_CTRL_CFG_ATEST1 (at 0x114b0)"
        set &access:&cmd_addr %l (0x8014b00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S1_CTRL_CFG_ATEST2"
      sgroup "S1_CTRL_CFG_ATEST2 (at 0x114b1)"
        set &access:&cmd_addr %l (0x8014b10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S1_CTRL_CFG_ATEST3"
      sgroup "S1_CTRL_CFG_ATEST3 (at 0x114b2)"
        set &access:&cmd_addr %l (0x8014b20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S1_CTRL_CFG_ATEST4"
      sgroup "S1_CTRL_CFG_ATEST4 (at 0x114b3)"
        set &access:&cmd_addr %l (0x8014b30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S1_CTRL_CFG_DTEST1"
      sgroup "S1_CTRL_CFG_DTEST1 (at 0x114b4)"
        set &access:&cmd_addr %l (0x8014b40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_PWM_OUT_DFT),2 (DTEST1_PFM_OUT_DFT),3 (DTEST1_GATE_DRV),4 (DTEST1_SMPS_CLK),5 (DTEST1_BIAS_REQ),6 (DTEST1_IDAC_OUT_DFT),7 (DTEST1_MODE_FSM_0)"
    tree.end
    tree "S1_CTRL_CFG_DTEST2"
      sgroup "S1_CTRL_CFG_DTEST2 (at 0x114b5)"
        set &access:&cmd_addr %l (0x8014b50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_VREG_OK_COMP),2 (DTEST2_SS_DONE_FLAG),3 (DTEST2_FSM_MODE_1),4 (DTEST2_PFM_ENTRY_TRIG),5 (RESERVED_101),6 (RESERVED_110),7 (RESERVED_111)"
    tree.end
    tree "S1_CTRL_CFG_DTEST3"
      sgroup "S1_CTRL_CFG_DTEST3 (at 0x114b6)"
        set &access:&cmd_addr %l (0x8014b60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_VREG_OK_COMP),2 (DTEST3_VREG_FAULT_COMP),3 (FSM_MODE_2),4 (CORROUT_DFT),5 (PFM_EXIT_TRIG),6 (RESERVED_110),7 (RESERVED_111)"
    tree.end
    tree "S1_CTRL_CFG_DTEST4"
      sgroup "S1_CTRL_CFG_DTEST4 (at 0x114b7)"
        set &access:&cmd_addr %l (0x8014b70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14b70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_SS_DONE_FLAG),2 (DTEST4_VS_DONE_FLAGT),3 (DTEST4_FSM_MODE)"
    tree.end
    tree "S1_CTRL_GANG_CTL1"
      sgroup "S1_CTRL_GANG_CTL1 (at 0x114c0)"
        set &access:&cmd_addr %l (0x8014c00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14c00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_CTRL_GANG_CTL2"
      sgroup "S1_CTRL_GANG_CTL2 (at 0x114c1)"
        set &access:&cmd_addr %l (0x8014c10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14c10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      sgroup "S1_CTRL_SEC_ACCESS (at 0x114d0)"
        set &access:&cmd_addr %l (0x8014d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      sgroup "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
        set &access:&cmd_addr %l (0x8014d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      sgroup "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
        set &access:&cmd_addr %l (0x8014d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      sgroup "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
        set &access:&cmd_addr %l (0x8014da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      sgroup "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
        set &access:&cmd_addr %l (0x8014db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      sgroup "S1_CTRL_INT_TEST1 (at 0x114e0)"
        set &access:&cmd_addr %l (0x8014e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      sgroup "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
        set &access:&cmd_addr %l (0x8014e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_0),1 (LIMIT_ERR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0 (VREG_OK_INT_TEST_VAL_0),1 (VREG_OK_INT_TEST_VAL_1)"
    tree.end
    tree "S1_CTRL_MODE_FSM_MASK"
      sgroup "S1_CTRL_MODE_FSM_MASK (at 0x114e2)"
        set &access:&cmd_addr %l (0x8014e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S1_CTRL_GATE_DRV_MUX"
      sgroup "S1_CTRL_GATE_DRV_MUX (at 0x114e3)"
        set &access:&cmd_addr %l (0x8014e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S1_CTRL_CORR_DUTY_MUX"
      sgroup "S1_CTRL_CORR_DUTY_MUX (at 0x114e4)"
        set &access:&cmd_addr %l (0x8014e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S1_CTRL_EN_OPTIONS_DFT"
      sgroup "S1_CTRL_EN_OPTIONS_DFT (at 0x114e5)"
        set &access:&cmd_addr %l (0x8014e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S1_CTRL_MAN_CAL_CTL"
      sgroup "S1_CTRL_MAN_CAL_CTL (at 0x114e7)"
        set &access:&cmd_addr %l (0x8014e70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MAN_IDAC_CAL_EN                          = " "0 (NORMAL_MODE),1 (MAN_IDAC_BUFFER_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MAN_CORR_CAL_EN                          = " "0 (NORMAL_MODE),1 (MAN_CORR_BUFFER_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MAN_PWM_CAL_EN                           = " "0 (NORMAL_MODE),1 (MAN_PWM_COMP_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAN_PFM_CAL_EN                           = " "0 (NORMAL_MODE),1 (MAN_PFM_COMP_CAL_EN_TRUE)"
    tree.end
    tree "S1_CTRL_CAL_REQUEST"
      sgroup "S1_CTRL_CAL_REQUEST (at 0x114e8)"
        set &access:&cmd_addr %l (0x8014e80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S1_CTRL_CAL_CTL"
      sgroup "S1_CTRL_CAL_CTL (at 0x114e9)"
        set &access:&cmd_addr %l (0x8014e90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14e90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0 (IDAC_BUFFER_CAL_DISABL),1 (IDAC_BUFFER_CAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0 (CORR_BUFFER_CAL_DISABL),1 (CORR_BUFFER_CAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0 (PWM_COMP_CAL_DISABL),1 (PWM_COMP_CAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0 (PFM_COMP_CAL_DISABL),1 (PFM_COMP_CAL_ENABL)"
    tree.end
    tree "S1_CTRL_IDAC_CAL_VAL"
      sgroup "S1_CTRL_IDAC_CAL_VAL (at 0x114ea)"
        set &access:&cmd_addr %l (0x8014ea0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14ea0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S1_CTRL_CORR_CAL_VAL"
      sgroup "S1_CTRL_CORR_CAL_VAL (at 0x114eb)"
        set &access:&cmd_addr %l (0x8014eb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14eb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S1_CTRL_PWM_CAL_VAL"
      sgroup "S1_CTRL_PWM_CAL_VAL (at 0x114ec)"
        set &access:&cmd_addr %l (0x8014ec0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14ec0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S1_CTRL_PFM_CAL_VAL"
      sgroup "S1_CTRL_PFM_CAL_VAL (at 0x114ed)"
        set &access:&cmd_addr %l (0x8014ed0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14ed0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S1_CTRL_MPHASE_IDAC"
      sgroup "S1_CTRL_MPHASE_IDAC (at 0x114ee)"
        set &access:&cmd_addr %l (0x8014ee0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14ee0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      sgroup "S1_CTRL_TRIM_NUM (at 0x114f0)"
        set &access:&cmd_addr %l (0x8014f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S1_CTRL_REFDAC_TRIM"
      sgroup "S1_CTRL_REFDAC_TRIM (at 0x114f1)"
        set &access:&cmd_addr %l (0x8014f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S1_CTRL_IDAC_TRIM"
      sgroup "S1_CTRL_IDAC_TRIM (at 0x114f2)"
        set &access:&cmd_addr %l (0x8014f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S1_CTRL_CORR_TRIM"
      sgroup "S1_CTRL_CORR_TRIM (at 0x114f3)"
        set &access:&cmd_addr %l (0x8014f30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S1_CTRL_PWM_TRIM"
      sgroup "S1_CTRL_PWM_TRIM (at 0x114f4)"
        set &access:&cmd_addr %l (0x8014f40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S1_CTRL_PFM_TRIM"
      sgroup "S1_CTRL_PFM_TRIM (at 0x114f5)"
        set &access:&cmd_addr %l (0x8014f50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S1_CTRL_RAMP_TRIM"
      sgroup "S1_CTRL_RAMP_TRIM (at 0x114f6)"
        set &access:&cmd_addr %l (0x8014f60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x14f60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      sgroup "S1_FREQ_REVISION1 (at 0x11600)"
        set &access:&cmd_addr %l (0x8016000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      sgroup "S1_FREQ_REVISION2 (at 0x11601)"
        set &access:&cmd_addr %l (0x8016010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      sgroup "S1_FREQ_PERPH_TYPE (at 0x11604)"
        set &access:&cmd_addr %l (0x8016040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      sgroup "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
        set &access:&cmd_addr %l (0x8016050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      sgroup "S1_FREQ_CLK_ENABLE (at 0x11646)"
        set &access:&cmd_addr %l (0x8016460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      sgroup "S1_FREQ_CLK_DIV (at 0x11650)"
        set &access:&cmd_addr %l (0x8016500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      sgroup "S1_FREQ_CLK_PHASE (at 0x11651)"
        set &access:&cmd_addr %l (0x8016510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      sgroup "S1_FREQ_GANG_CTL1 (at 0x116c0)"
        set &access:&cmd_addr %l (0x8016c00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16c00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      sgroup "S1_FREQ_GANG_CTL2 (at 0x116c1)"
        set &access:&cmd_addr %l (0x8016c10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16c10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      sgroup "S1_FREQ_SEC_ACCESS (at 0x116d0)"
        set &access:&cmd_addr %l (0x8016d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      sgroup "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
        set &access:&cmd_addr %l (0x8016d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      sgroup "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
        set &access:&cmd_addr %l (0x8016da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      sgroup "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
        set &access:&cmd_addr %l (0x8016db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S1_FREQ_TEST1"
      sgroup "S1_FREQ_TEST1 (at 0x116e2)"
        set &access:&cmd_addr %l (0x8016e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      sgroup "S1_PS_REVISION1 (at 0x11500)"
        set &access:&cmd_addr %l (0x8015000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      sgroup "S1_PS_REVISION2 (at 0x11501)"
        set &access:&cmd_addr %l (0x8015010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      sgroup "S1_PS_REVISION3 (at 0x11502)"
        set &access:&cmd_addr %l (0x8015020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      sgroup "S1_PS_REVISION4 (at 0x11503)"
        set &access:&cmd_addr %l (0x8015030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      sgroup "S1_PS_PERPH_TYPE (at 0x11504)"
        set &access:&cmd_addr %l (0x8015040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      sgroup "S1_PS_PERPH_SUBTYPE (at 0x11505)"
        set &access:&cmd_addr %l (0x8015050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_VOLTAGE_CTL1"
      sgroup "S1_PS_VOLTAGE_CTL1 (at 0x11540)"
        set &access:&cmd_addr %l (0x8015400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S1_PS_VOLTAGE_CTL2"
      sgroup "S1_PS_VOLTAGE_CTL2 (at 0x11541)"
        set &access:&cmd_addr %l (0x8015410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S1_PS_FREQ_CTL"
      sgroup "S1_PS_FREQ_CTL (at 0x11550)"
        set &access:&cmd_addr %l (0x8015500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S1_PS_MULTIPHASE_CTL"
      sgroup "S1_PS_MULTIPHASE_CTL (at 0x11551)"
        set &access:&cmd_addr %l (0x8015510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
    tree.end
    tree "S1_PS_PHASE_CTL"
      sgroup "S1_PS_PHASE_CTL (at 0x11552)"
        set &access:&cmd_addr %l (0x8015520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0 (DISABLE_ACTIVE_PHASE_CURRENT_BALANCING),1 (ENABLE_ACTIVE_PHASE_CURRENT_BALANCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S1_PS_PHASE_ID"
      sgroup "S1_PS_PHASE_ID (at 0x11553)"
        set &access:&cmd_addr %l (0x8015530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0 (PHASE_NUMBER_1),1 (PHASE_NUMBER_2),2 (PHASE_NUMBER_3),3 (PHASE_NUMBER_4)"
    tree.end
    tree "S1_PS_PHASE_CNT"
      sgroup "S1_PS_PHASE_CNT (at 0x11554)"
        set &access:&cmd_addr %l (0x8015540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0 (PHASE_COUNT_1),1 (PHASE_COUNT_2),2 (PHASE_COUNT_4_NOT_3),3 (PHASE_COUNT_4)"
    tree.end
    tree "S1_PS_PWM_CL_CTL"
      sgroup "S1_PS_PWM_CL_CTL (at 0x11560)"
        set &access:&cmd_addr %l (0x8015600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0 (PWM_ILIM_1P0A),1 (PWM_ILIM_1P5A),2 (PWM_ILIM_2P0A),3 (PWM_ILIM_2P5A),4 (PWM_ILIM_3P0A),5 (PWM_ILIM_3P5A),6 (PWM_ILIM_4P0A),7 (PWM_ILIM_4P5A)"
    tree.end
    tree "S1_PS_LPM_CL_CTL"
      sgroup "S1_PS_LPM_CL_CTL (at 0x11561)"
        set &access:&cmd_addr %l (0x8015610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_CL_FINE                              = " "0 (LPM_CL_FINE_OFF),1 (LPM_CL_FINE_0P167A),2 (LPM_CL_FINE_0P334A),3 (LPM_CL_FINE_0P501A),4 (LPM_CL_FINE_0P668A),5 (LPM_CL_FINE_0P835A),6 (LPM_CL_FINE_1P002A),7 (LPM_CL_FINE_1P169A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0 (LPM_CL_0P5A),1 (LPM_CL_1P0A),2 (LPM_CL_1P5A),3 (LPM_CL_2P0A),4 (LPM_CL_2P5A),5 (LPM_CL_3P0A),6 (LPM_CL_3P5A),7 (LPM_CL_4P0A)"
    tree.end
    tree "S1_PS_AUTO_CTL"
      sgroup "S1_PS_AUTO_CTL (at 0x11562)"
        set &access:&cmd_addr %l (0x8015620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0 (LPM_EXIT_CYCLES_2),1 (LPM_EXIT_CYCLES_4),2 (LPM_EXIT_CYCLES_6),3 (LPM_EXIT_CYCLES_8),4 (LPM_EXIT_CYCLES_12),5 (LPM_EXIT_CYCLES_16),6 (LPM_EXIT_CYCLES_24),7 (LPM_EXIT_CYCLES_32)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
    tree.end
    tree "S1_PS_ZX_ADAPT_CTL"
      sgroup "S1_PS_ZX_ADAPT_CTL (at 0x11563)"
        set &access:&cmd_addr %l (0x8015630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (OVERRIDE_IADC_WITH_ZEROS_WHEN_TRISTATE_ASSERTED_FOR_ANY_PART_OF_TRISTATE_SAMPLE_WINDOW),1 (OVERRIDE_IADC_WITH_ZEROS_WHEN_TRISTATE_ASSERTED_FOR_FULL_TRISTATE_SAMPLE_WINDOW),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S1_PS_ZX_ADAPT_VAL"
      sgroup "S1_PS_ZX_ADAPT_VAL (at 0x11564)"
        set &access:&cmd_addr %l (0x8015640|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15640|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S1_PS_FSM_MINON_CFG"
      sgroup "S1_PS_FSM_MINON_CFG (at 0x11570)"
        set &access:&cmd_addr %l (0x8015700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_ILLEGAL),1 (NMOS_MIN_ON_TIME_10NS),2 (NMOS_MIN_ON_TIME_20NS),3 (NMOS_MIN_ON_TIME_30NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_ILLEGAL),1 (PMOS_MIN_ON_TIME_10NS),2 (PMOS_MIN_ON_TIME_20NS),3 (PMOS_MIN_ON_TIME_30NS)"
    tree.end
    tree "S1_PS_ICOMP_EN_CFG"
      sgroup "S1_PS_ICOMP_EN_CFG (at 0x11571)"
        set &access:&cmd_addr %l (0x8015710|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15710|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_TEST_EN                               = " "0 (CL_TEST_MODE_DISABLED_FOR_NORMAL_OP),1 (CL_TEST_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_TEST_EN                              = " "0 (ADC_TEST_MODE_DISABLED_FOR_NORMAL_OP),1 (ADC_TEST_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0 (CURRENT_LIMIT_DISABLED),1 (CURRENT_LIMIT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0 (ZX_COMP_DISABLED),1 (ZX_COMP_ENABLED_FOR_PWM_LPM_BURSTS_WARMUP),2 (ILLEGAL),3 (ZX_COMP_ALWAYS_ENABLED)"
    tree.end
    tree "S1_PS_ZX_CAL_CFG"
      sgroup "S1_PS_ZX_CAL_CFG (at 0x11572)"
        set &access:&cmd_addr %l (0x8015720|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15720|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0 (ZX_CAL_USES_OPT_TRIM_CODE_PLUS_ZX_VOS_NOM),1 (ZX_CAL_USES_ZERO_TRIM_CODE_PLUS_ZX_VOS_NOM),2 (ZX_CAL_USES_POWERON_CAL_PLUS_ZX_VOS_NOM),3 (ZX_CAL_ADAPTIVE_ZX_ENABLED_AND_USES_POWERON_CAL_PLUS_ZX_VOS_NOM)"
    tree.end
    tree "S1_PS_NONOVLAP_CFG"
      sgroup "S1_PS_NONOVLAP_CFG (at 0x11573)"
        set &access:&cmd_addr %l (0x8015730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S1_PS_MPHASE_PI_CFG1"
      sgroup "S1_PS_MPHASE_PI_CFG1 (at 0x11574)"
        set &access:&cmd_addr %l (0x8015740|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15740|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S1_PS_MPHASE_PI_CFG2"
      sgroup "S1_PS_MPHASE_PI_CFG2 (at 0x11575)"
        set &access:&cmd_addr %l (0x8015750|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15750|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S1_PS_MPHASE_PI_CFG3"
      sgroup "S1_PS_MPHASE_PI_CFG3 (at 0x11576)"
        set &access:&cmd_addr %l (0x8015760|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15760|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S1_PS_MPHASE_PI_CFG4"
      sgroup "S1_PS_MPHASE_PI_CFG4 (at 0x11577)"
        set &access:&cmd_addr %l (0x8015770|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15770|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S1_PS_MPHASE_PI_CFG5"
      sgroup "S1_PS_MPHASE_PI_CFG5 (at 0x11578)"
        set &access:&cmd_addr %l (0x8015780|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15780|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S1_PS_MPHASE_PI_CFG6"
      sgroup "S1_PS_MPHASE_PI_CFG6 (at 0x11579)"
        set &access:&cmd_addr %l (0x8015790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S1_PS_CAL_FAULT"
      sgroup "S1_PS_CAL_FAULT (at 0x1157a)"
        set &access:&cmd_addr %l (0x80157a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x157a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S1_PS_ADC_OUT"
      sgroup "S1_PS_ADC_OUT (at 0x1157b)"
        set &access:&cmd_addr %l (0x80157b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x157b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S1_PS_MP_IAVG2"
      sgroup "S1_PS_MP_IAVG2 (at 0x1157c)"
        set &access:&cmd_addr %l (0x80157c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x157c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S1_PS_MP_IAVG1"
      sgroup "S1_PS_MP_IAVG1 (at 0x1157d)"
        set &access:&cmd_addr %l (0x80157d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x157d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S1_PS_MP_DAC_DATA"
      sgroup "S1_PS_MP_DAC_DATA (at 0x1157e)"
        set &access:&cmd_addr %l (0x80157e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x157e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S1_PS_MP_IAVG_DFT"
      sgroup "S1_PS_MP_IAVG_DFT (at 0x1157f)"
        set &access:&cmd_addr %l (0x80157f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x157f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MP_IAVG_DFT                              = " "0 (MP_IAVG_DFT_NOT_FORCED_FOR_NORMAL_OP),1 (MP_IAVG_DFT_FORCED_TO_A5),2 (MP_IAVG_DFT_FORCED_TO_15),3 (MP_IAVG_DFT_FORCED_TO_FF)"
    tree.end
    tree "S1_PS_GANG_CTL1"
      sgroup "S1_PS_GANG_CTL1 (at 0x115c0)"
        set &access:&cmd_addr %l (0x8015c00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15c00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_PS_GANG_CTL2"
      sgroup "S1_PS_GANG_CTL2 (at 0x115c1)"
        set &access:&cmd_addr %l (0x8015c10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15c10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      sgroup "S1_PS_SEC_ACCESS (at 0x115d0)"
        set &access:&cmd_addr %l (0x8015d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      sgroup "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
        set &access:&cmd_addr %l (0x8015d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      sgroup "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
        set &access:&cmd_addr %l (0x8015da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      sgroup "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
        set &access:&cmd_addr %l (0x8015db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_PS_ATEST12"
      sgroup "S1_PS_ATEST12 (at 0x115e2)"
        set &access:&cmd_addr %l (0x8015e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST2_NOT_USED1),2 (ATEST2_NOT_USED2),3 (ILLEGAL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST1_ADC_DAC_OUT),2 (ATEST1_NOT_USED),3 (ILLEGAL)"
    tree.end
    tree "S1_PS_ATEST34"
      sgroup "S1_PS_ATEST34 (at 0x115e3)"
        set &access:&cmd_addr %l (0x8015e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ILLEGAL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_NOT_USED),3 (ILLEGAL)"
    tree.end
    tree "S1_PS_DTEST12"
      sgroup "S1_PS_DTEST12 (at 0x115e4)"
        set &access:&cmd_addr %l (0x8015e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S1_PS_DTEST43"
      sgroup "S1_PS_DTEST43 (at 0x115e5)"
        set &access:&cmd_addr %l (0x8015e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S1_PS_MAN_CAL_CTL"
      sgroup "S1_PS_MAN_CAL_CTL (at 0x115e7)"
        set &access:&cmd_addr %l (0x8015e70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAN_ZX_CAL_EN                            = " "0 (MAN_ZX_CAL_EN_FALSE),1 (MAN_ZX_CAL_EN_TRUE)"
    tree.end
    tree "S1_PS_CAL_REQUEST"
      sgroup "S1_PS_CAL_REQUEST (at 0x115e8)"
        set &access:&cmd_addr %l (0x8015e80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S1_PS_TRIM_NUM"
      sgroup "S1_PS_TRIM_NUM (at 0x115f0)"
        set &access:&cmd_addr %l (0x8015f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S1_PS_ZX_TRIM"
      sgroup "S1_PS_ZX_TRIM (at 0x115f1)"
        set &access:&cmd_addr %l (0x8015f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S1_PS_CL_TRIM"
      sgroup "S1_PS_CL_TRIM (at 0x115f2)"
        set &access:&cmd_addr %l (0x8015f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0 (CL_TRIM_OFF),1 (CL_TRIM_0P167A),2 (CL_TRIM_0P334A),3 (CL_TRIM_0P501A),4 (CL_TRIM_0P668A),5 (CL_TRIM_0P835A),6 (CL_TRIM_1P002A),7 (CL_TRIM_1P169A)"
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      sgroup "S2_CTRL_REVISION1 (at 0x11700)"
        set &access:&cmd_addr %l (0x8017000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      sgroup "S2_CTRL_REVISION2 (at 0x11701)"
        set &access:&cmd_addr %l (0x8017010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      sgroup "S2_CTRL_REVISION3 (at 0x11702)"
        set &access:&cmd_addr %l (0x8017020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      sgroup "S2_CTRL_REVISION4 (at 0x11703)"
        set &access:&cmd_addr %l (0x8017030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      sgroup "S2_CTRL_PERPH_TYPE (at 0x11704)"
        set &access:&cmd_addr %l (0x8017040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      sgroup "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
        set &access:&cmd_addr %l (0x8017050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS_1"
      sgroup "S2_CTRL_STATUS_1 (at 0x11708)"
        set &access:&cmd_addr %l (0x8017080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0 (VREG_OK_FLAG_FALSE),1 (VREG_OK_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0 (VREG_FAULT_FLAG_FALSE),1 (VREG_FAULT_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0 (NPM_FLAG_FALSE),1 (NPM_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0 (STEPPER_DONE_FLAG_FALSE),1 (STEPPER_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_2"
      sgroup "S2_CTRL_STATUS_2 (at 0x11709)"
        set &access:&cmd_addr %l (0x8017090|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17090|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0 (ILS_FLAG_FALSE),1 (ILS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0 (ULS_FLAG_FALSE),1 (ULS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0 (LLS_FLAG_FALSE),1 (LLS_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0 (GPL_HI_FLAG_FALSE),1 (GPL_HI_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0 (GPL_LO_FLAG_FALSE),1 (GPL_LO_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_3"
      sgroup "S2_CTRL_STATUS_3 (at 0x1170a)"
        set &access:&cmd_addr %l (0x80170a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x170a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0 (IDAC_CAL_FAULT_FALSE),1 (IDAC_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0 (CORR_CAL_FAULT_FALSE),1 (CORR_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0 (PWM_CAL_FAULT_FALSE),1 (PWM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0 (PFM_CAL_FAULT_FALSE),1 (PFM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0 (PS_CAL_DONE_FLAG_FALSE),1 (PS_CAL_DONE_FLAG_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS_4"
      sgroup "S2_CTRL_STATUS_4 (at 0x1170b)"
        set &access:&cmd_addr %l (0x80170b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x170b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0 (MODE_FSM_3_IS_0),1 (MODE_FSM_3_IS_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0 (MODE_FSM_2_IS_0),1 (MODE_FSM_2_IS_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0 (MODE_FSM_1_IS_0),1 (MODE_FSM_1_IS_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0 (MODE_FSM_0_IS_0),1 (MODE_FSM_0_IS_1)"
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      sgroup "S2_CTRL_INT_RT_STS (at 0x11710)"
        set &access:&cmd_addr %l (0x8017100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALSE),1 (VREG_FAULT_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      sgroup "S2_CTRL_INT_SET_TYPE (at 0x11711)"
        set &access:&cmd_addr %l (0x8017110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_LEVEL_TRIGGERED),1 (VREG_FAULT_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_LEVEL_TRIGGERED),1 (LIMIT_ERR_INT_EDGE_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_LEVEL_TRIGGERED),1 (VREG_OK_INT_EDGE_TRIGGERED)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      sgroup "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
        set &access:&cmd_addr %l (0x8017120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_RISING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERR_INT_RISING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_RISING_EDGE_TRIGGER_DISABL),1 (VREG_OK_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      sgroup "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
        set &access:&cmd_addr %l (0x8017130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_FAULT_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALLING_EDGE_TRIGGER_DISABL),1 (LIMIT_ERR_INT_FALLING_EDGE_TRIGGER_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALLING_EDGE_TRIGGER_DISABL),1 (VREG_OK_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      sgroup "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
        set &access:&cmd_addr %l (0x8017140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      sgroup "S2_CTRL_INT_EN_SET (at 0x11715)"
        set &access:&cmd_addr %l (0x8017150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_DISABL),1 (LIMIT_ERR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_DISABL),1 (VREG_OK_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      sgroup "S2_CTRL_INT_EN_CLR (at 0x11716)"
        set &access:&cmd_addr %l (0x8017160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_DISABL),1 (VREG_FAULT_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_DISABL),1 (LIMIT_ERR_INT_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_DISABL),1 (VREG_OK_INT_ENABL)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      sgroup "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
        set &access:&cmd_addr %l (0x8017180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_TRIGGERED),1 (VREG_FAULT_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_NOT_TRIGGERED),1 (LIMIT_ERR_INT_TRIGGERED_AND_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_NOT_TRIGGERED),1 (VREG_OK_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      sgroup "S2_CTRL_INT_PENDING_STS (at 0x11719)"
        set &access:&cmd_addr %l (0x8017190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0 (VREG_FAULT_INT_NOT_PENDING),1 (VREG_FAULT_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_NOT_PENDING),1 (LIMIT_ERR_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_NOT_PENDING),1 (VREG_OK_INT_PENDING)"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      sgroup "S2_CTRL_INT_MID_SEL (at 0x1171a)"
        set &access:&cmd_addr %l (0x80171a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x171a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      sgroup "S2_CTRL_INT_PRIORITY (at 0x1171b)"
        set &access:&cmd_addr %l (0x80171b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x171b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_0),1 (INT_PRIORITY_1)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL1"
      sgroup "S2_CTRL_VOLTAGE_CTL1 (at 0x11740)"
        set &access:&cmd_addr %l (0x8017400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (MV_RANGE_FALSE),1 (MV_RANGE_TRUE)"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      sgroup "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
        set &access:&cmd_addr %l (0x8017410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_CTRL_VSET_VALID"
      sgroup "S2_CTRL_VSET_VALID (at 0x11742)"
        set &access:&cmd_addr %l (0x8017420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL3"
      sgroup "S2_CTRL_VOLTAGE_CTL3 (at 0x11744)"
        set &access:&cmd_addr %l (0x8017440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0 (PFM_VOFFSET_EN_FALSE),1 (PFM_VOFFSET_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      sgroup "S2_CTRL_MODE_CTL (at 0x11745)"
        set &access:&cmd_addr %l (0x8017450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0 (NPM_NOT_FORCED),1 (NPM_FORCED_IF_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_MODE_FALSE),1 (AUTO_MODE_TRUE)"
    tree.end
    tree "S2_CTRL_EN_CTL"
      sgroup "S2_CTRL_EN_CTL (at 0x11746)"
        set &access:&cmd_addr %l (0x8017460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (FTS_DISABL),1 (FTS_ENABL)"
    tree.end
    tree "S2_CTRL_PD_CTL"
      sgroup "S2_CTRL_PD_CTL (at 0x11748)"
        set &access:&cmd_addr %l (0x8017480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_ON_WHEN_FTS_IS_DISABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABL_IN_PMIC_OFF_STATE),1 (SWEAK_PD_ENABL_IN_PMIC_OFF_STATE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_DISABL_IN_PFM),1 (WEAK_PD_ENABL_IN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_DISABL_IN_PWM_AND_HCPFM),1 (WEAK_PD_ENABL_IN_PWM_AND_HCPFM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_OFF),1 (LEAKAGE_PD_ALWAYS_ENABL)"
    tree.end
    tree "S2_CTRL_FREQ_CTL"
      sgroup "S2_CTRL_FREQ_CTL (at 0x11750)"
        set &access:&cmd_addr %l (0x8017500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_CTRL_MULTIPHASE_CTL"
      sgroup "S2_CTRL_MULTIPHASE_CTL (at 0x11751)"
        set &access:&cmd_addr %l (0x8017510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
    tree.end
    tree "S2_CTRL_PHASE_CTL"
      sgroup "S2_CTRL_PHASE_CTL (at 0x11752)"
        set &access:&cmd_addr %l (0x8017520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0 (DISABL_ACTIVE_PHASE_CURRENT_BALANCING),1 (ENABL_ACTIVE_PHASE_CURRENT_BALANCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_CTRL_PHASE_ID"
      sgroup "S2_CTRL_PHASE_ID (at 0x11753)"
        set &access:&cmd_addr %l (0x8017530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0 (PHASE_NUMBER_1),1 (PHASE_NUMBER_2),2 (PHASE_NUMBER_3),3 (PHASE_NUMBER_4)"
    tree.end
    tree "S2_CTRL_PHASE_CNT"
      sgroup "S2_CTRL_PHASE_CNT (at 0x11754)"
        set &access:&cmd_addr %l (0x8017540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0 (PHASE_COUNT_1),1 (PHASE_COUNT_2),2 (PHASE_COUNT_4_NOT_3),3 (PHASE_COUNT_4)"
    tree.end
    tree "S2_CTRL_SPARE"
      sgroup "S2_CTRL_SPARE (at 0x11755)"
        set &access:&cmd_addr %l (0x8017550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (SPARE1_BIT_STATE_0),1 (SPARE1_BIT_STATE_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0 (SPARE0_BIT_STATE_0),1 (SPARE0_BIT_STATE_1)"
    tree.end
    tree "S2_CTRL_SS_CTL"
      sgroup "S2_CTRL_SS_CTL (at 0x11760)"
        set &access:&cmd_addr %l (0x8017600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0 (SOFT_START_VSTEP_1_LSB),1 (SOFT_START_VSTEP_2_LSB),2 (SOFT_START_VSTEP_4_LSB),3 (SOFT_START_VSTEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0 (SOFT_START_TIME_STEP_417NS),1 (SOFT_START_TIME_STEP_833NS),2 (SOFT_START_TIME_STEP_1U67S),3 (SOFT_START_TIME_STEP_3U3S),4 (SOFT_START_TIME_STEP_6U7S),5 (SOFT_START_TIME_STEP_13U3S),6 (SOFT_START_TIME_STEP_26U7S),7 (SOFT_START_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_VS_CTL"
      sgroup "S2_CTRL_VS_CTL (at 0x11761)"
        set &access:&cmd_addr %l (0x8017610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0 (VSTEPPER_DISABL),1 (VSTEPPER_ENABL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0 (VSTEPPER_STEP_SIZE_1_LSB),1 (VSTEPPER_STEP_SIZE_2_LSB),2 (VSTEPPER_STEP_SIZE_4_LSB),3 (VSTEPPER_STEP_SIZE_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0 (VSTEPPER_TIME_STEP_417NS),1 (VSTEPPER_TIME_STEP_833NS),2 (VSTEPPER_TIME_STEP_1U67S),3 (VSTEPPER_TIME_STEP_3U3S),4 (VSTEPPER_TIME_STEP_6U7S),5 (VSTEPPER_TIME_STEP_13U3S),6 (VSTEPPER_TIME_STEP_26U7S),7 (VSTEPPER_TIME_STEP_53U3S)"
    tree.end
    tree "S2_CTRL_CORR_CFG"
      sgroup "S2_CTRL_CORR_CFG (at 0x11762)"
        set &access:&cmd_addr %l (0x8017620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0 (DC_ERROR_CORR_MAG_20MV),1 (DC_ERROR_CORR_MAG_30MV),2 (DC_ERROR_CORR_MAG_40MV),3 (DC_ERROR_CORR_MAG_50MV),4 (DC_ERROR_CORR_MAG_60MV),5 (DC_ERROR_CORR_MAG_70MV),6 (DC_ERROR_CORR_MAG_80MV),7 (DC_ERROR_CORR_MAG_90MV)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S2_CTRL_RAMP_CFG"
      sgroup "S2_CTRL_RAMP_CFG (at 0x11763)"
        set &access:&cmd_addr %l (0x8017630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0 (RAMP_CFG_20MV),1 (RAMP_CFG_30MV),2 (RAMP_CFG_40MV),3 (RAMP_CFG_50MV),4 (DRAMP_CFG_60MV),5 (DRAMP_CFG_70MV),6 (RAMP_CFG_80MV),7 (DRAMP_CFG_90MV)"
    tree.end
    tree "S2_CTRL_COMPENS_CFG"
      sgroup "S2_CTRL_COMPENS_CFG (at 0x11764)"
        set &access:&cmd_addr %l (0x8017640|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17640|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0 (BP_HPF_10KHZ),1 (BP_HPF_20KHZ),2 (BP_HPF_40KHZ),3 (BP_HPF_80KHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0 (BP_LPF_200KHZ),1 (BP_LPF_400KHZ),2 (BP_LPF_600KHZ),3 (BP_LPF_800KHZ),4 (BP_LPF_1000KHZ),5 (BP_LPF_1200KHZ),6 (BP_LPF_NOT_SUPPORTED_110),7 (BP_LPF_NOT_SUPPORTED_111)"
    tree.end
    tree "S2_CTRL_CFG_VREG_OK"
      sgroup "S2_CTRL_CFG_VREG_OK (at 0x11765)"
        set &access:&cmd_addr %l (0x8017650|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17650|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0 (VREG_OK_COMP_DISABL),1 (VREG_OK_COMP_ENABL_IN_NPM),2 (VREG_OK_COMP_ENABL_IN_NPM_AND_LPM),3 (ILLEGAL_SETTING)"
    tree.end
    tree "S2_CTRL_CFG_VREG_FAULT"
      sgroup "S2_CTRL_CFG_VREG_FAULT (at 0x11766)"
        set &access:&cmd_addr %l (0x8017660|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17660|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0 (VREG_FAULT_FOLDBACK_COMP_DISABL),1 (VREG_FAULT_FOLDBACK_COMP_ENABL_IN_NPM),2 (VREG_FAULT_FOLDBACK_COMP_ENABL_IN_NPM_AND_LPM),3 (ILLEGAL_SETTING)"
    tree.end
    tree "S2_CTRL_CFG_PFM_COMP"
      sgroup "S2_CTRL_CFG_PFM_COMP (at 0x11767)"
        set &access:&cmd_addr %l (0x8017670|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17670|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_HYS                                  = " "0 (PFM_COMPARATOR_HYSTERESIS_5MV),1 (PFM_COMPARATOR_HYSTERESIS_10MV),2 (PFM_COMPARATOR_HYSTERESIS_20MV),3 (PFM_COMPARATOR_HYSTERESIS_40MV)"
    tree.end
    tree "S2_CTRL_UL_LL_CTL"
      sgroup "S2_CTRL_UL_LL_CTL (at 0x11768)"
        set &access:&cmd_addr %l (0x8017680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0 (UL_STOP_DISABL),1 (UL_STOP_ENABL)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0 (LL_STOP_DISABL),1 (LL_STOP_ENABL)"
    tree.end
    tree "S2_CTRL_VSET_ULS"
      sgroup "S2_CTRL_VSET_ULS (at 0x11769)"
        set &access:&cmd_addr %l (0x8017690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S2_CTRL_ULS_VALID"
      sgroup "S2_CTRL_ULS_VALID (at 0x1176a)"
        set &access:&cmd_addr %l (0x80176a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x176a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S2_CTRL_VSET_LLS"
      sgroup "S2_CTRL_VSET_LLS (at 0x1176b)"
        set &access:&cmd_addr %l (0x80176b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x176b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S2_CTRL_LLS_VALID"
      sgroup "S2_CTRL_LLS_VALID (at 0x1176c)"
        set &access:&cmd_addr %l (0x80176c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x176c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S2_CTRL_GPL_HI"
      sgroup "S2_CTRL_GPL_HI (at 0x1176d)"
        set &access:&cmd_addr %l (0x80176d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x176d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S2_CTRL_GPL_LO"
      sgroup "S2_CTRL_GPL_LO (at 0x1176e)"
        set &access:&cmd_addr %l (0x80176e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x176e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S2_CTRL_FB_FILT_CFG"
      sgroup "S2_CTRL_FB_FILT_CFG (at 0x1176f)"
        set &access:&cmd_addr %l (0x80176f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x176f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FB_FILT_SERIES                           = " "0 (SERIES_FILTER_UNCONNECTED),1 (SERIES_FILTER_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FB_FILT_CFG                              = " "0 (PWM_COMP_TAIL_CURRENT_2UA),1 (PWM_COMP_TAIL_CURRENT_4UA),2 (PWM_COMP_TAIL_CURRENT_10UA),3 (PWM_COMP_TAIL_CURRENT_20UA)"
    tree.end
    tree "S2_CTRL_CFG_ATEST1"
      sgroup "S2_CTRL_CFG_ATEST1 (at 0x117b0)"
        set &access:&cmd_addr %l (0x8017b00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0 (ATEST1_UNCONNECTED),1 (ATEST1_REFLO),2 (ATEST1_REFMID),3 (ATEST1_REFHI),4 (ATEST1_RBUFF_TERM),5 (ATEST1_IDACREF),6 (ATEST1_DACREF),7 (ATEST1_FB)"
    tree.end
    tree "S2_CTRL_CFG_ATEST2"
      sgroup "S2_CTRL_CFG_ATEST2 (at 0x117b1)"
        set &access:&cmd_addr %l (0x8017b10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0 (ATEST2_UNCONNECTED),1 (ATEST2_VREG),2 (ATEST2_RMT_GND),3 (ATEST2_REF_GND),4 (ATEST2_REFVALL),5 (ATEST2_HOLDVALL),6 (ATEST2_RVDD_CTRL),7 (ATEST2_RVDD)"
    tree.end
    tree "S2_CTRL_CFG_ATEST3"
      sgroup "S2_CTRL_CFG_ATEST3 (at 0x117b2)"
        set &access:&cmd_addr %l (0x8017b20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0 (ATEST3_UNCONNECTED),1 (ATEST3_FAULTREF),2 (ATEST3_REFPK),3 (ATEST3_HOLDPK)"
    tree.end
    tree "S2_CTRL_CFG_ATEST4"
      sgroup "S2_CTRL_CFG_ATEST4 (at 0x117b3)"
        set &access:&cmd_addr %l (0x8017b30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0 (ATEST4_UNCONNECTED),1 (ATEST4_AVDD),2 (ATEST4_1B1U_UNTRIM_DFT),3 (ATEST4_REFCOMM)"
    tree.end
    tree "S2_CTRL_CFG_DTEST1"
      sgroup "S2_CTRL_CFG_DTEST1 (at 0x117b4)"
        set &access:&cmd_addr %l (0x8017b40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0 (DTEST1_UNCONNECTED),1 (DTEST1_PWM_OUT_DFT),2 (DTEST1_PFM_OUT_DFT),3 (DTEST1_GATE_DRV),4 (DTEST1_SMPS_CLK),5 (DTEST1_BIAS_REQ),6 (DTEST1_IDAC_OUT_DFT),7 (DTEST1_MODE_FSM_0)"
    tree.end
    tree "S2_CTRL_CFG_DTEST2"
      sgroup "S2_CTRL_CFG_DTEST2 (at 0x117b5)"
        set &access:&cmd_addr %l (0x8017b50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0 (DTEST2_UNCONNECTED),1 (DTEST2_VREG_OK_COMP),2 (DTEST2_SS_DONE_FLAG),3 (DTEST2_FSM_MODE_1),4 (DTEST2_PFM_ENTRY_TRIG),5 (RESERVED_101),6 (RESERVED_110),7 (RESERVED_111)"
    tree.end
    tree "S2_CTRL_CFG_DTEST3"
      sgroup "S2_CTRL_CFG_DTEST3 (at 0x117b6)"
        set &access:&cmd_addr %l (0x8017b60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0 (DTEST3_UNCONNECTED),1 (DTEST3_VREG_OK_COMP),2 (DTEST3_VREG_FAULT_COMP),3 (FSM_MODE_2),4 (CORROUT_DFT),5 (PFM_EXIT_TRIG),6 (RESERVED_110),7 (RESERVED_111)"
    tree.end
    tree "S2_CTRL_CFG_DTEST4"
      sgroup "S2_CTRL_CFG_DTEST4 (at 0x117b7)"
        set &access:&cmd_addr %l (0x8017b70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17b70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0 (DTEST4_UNCONNECTED),1 (DTEST4_SS_DONE_FLAG),2 (DTEST4_VS_DONE_FLAGT),3 (DTEST4_FSM_MODE)"
    tree.end
    tree "S2_CTRL_GANG_CTL1"
      sgroup "S2_CTRL_GANG_CTL1 (at 0x117c0)"
        set &access:&cmd_addr %l (0x8017c00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17c00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_CTRL_GANG_CTL2"
      sgroup "S2_CTRL_GANG_CTL2 (at 0x117c1)"
        set &access:&cmd_addr %l (0x8017c10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17c10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      sgroup "S2_CTRL_SEC_ACCESS (at 0x117d0)"
        set &access:&cmd_addr %l (0x8017d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      sgroup "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
        set &access:&cmd_addr %l (0x8017d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABL_PRESET_FALSE),1 (ENABL_PRESET_TRUE)"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      sgroup "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
        set &access:&cmd_addr %l (0x8017d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      sgroup "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
        set &access:&cmd_addr %l (0x8017da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      sgroup "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
        set &access:&cmd_addr %l (0x8017db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      sgroup "S2_CTRL_INT_TEST1 (at 0x117e0)"
        set &access:&cmd_addr %l (0x8017e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      sgroup "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
        set &access:&cmd_addr %l (0x8017e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_0),1 (VREG_FAULT_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_0),1 (LIMIT_ERR_INT_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0 (VREG_OK_INT_TEST_VAL_0),1 (VREG_OK_INT_TEST_VAL_1)"
    tree.end
    tree "S2_CTRL_MODE_FSM_MASK"
      sgroup "S2_CTRL_MODE_FSM_MASK (at 0x117e2)"
        set &access:&cmd_addr %l (0x8017e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0 (MODE_FSM_MASK_EN_0),1 (MODE_FSM_MASK_EN_1)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S2_CTRL_GATE_DRV_MUX"
      sgroup "S2_CTRL_GATE_DRV_MUX (at 0x117e3)"
        set &access:&cmd_addr %l (0x8017e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0 (GATE_DRV_MUX1_NORMAL_MODE),1 (GATE_DRV_MUX1_DET_BY_MUX2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0 (GATE_DRV_MUX2_PFM_COMP),1 (GATE_DRV_MUX2_DET_BY_MUX3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0 (GATE_DRV_MUX3_FORCED_TO_1),1 (GATE_DRV_MUX3_SMPS_CLK),2 (GATE_DRV_MUX3_DTEST1),3 (GATE_DRV_MUX3_FORCED_TO_0)"
    tree.end
    tree "S2_CTRL_CORR_DUTY_MUX"
      sgroup "S2_CTRL_CORR_DUTY_MUX (at 0x117e4)"
        set &access:&cmd_addr %l (0x8017e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0 (CORR_DUTY_MUX_NORMAL_MODE),1 (CORR_DUTY_MUX_FORCED_TO_1),2 (CORR_DUTY_MUX_FORCED_TO_0),3 (CORR_DUTY_MUX_DTEST2)"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT"
      sgroup "S2_CTRL_EN_OPTIONS_DFT (at 0x117e5)"
        set &access:&cmd_addr %l (0x8017e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0 (SOFTSTART_DISABL),1 (SOFTSTART_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0 (CORR_SHIFT_DISABL),1 (CORR_SHIFT_ENABL_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0 (SAMPLE_CLK_DISABL),1 (SAMPLE_CLK_NORMAL_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0 (SAMPLE_AMP_NORMAL_MODE),1 (SAMPLE_AMP_TRI_STATE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0 (RAMP_EN_FALSE),1 (RAMP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0 (COMPENS_EN_FALSE),1 (COMPENS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0 (SAMPLE_PREBIAS_EN_FALSE),1 (SAMPLE_PREBIAS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0 (GDRV_EN_FALSE),1 (GDRV_EN_TRUE)"
    tree.end
    tree "S2_CTRL_MAN_CAL_CTL"
      sgroup "S2_CTRL_MAN_CAL_CTL (at 0x117e7)"
        set &access:&cmd_addr %l (0x8017e70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MAN_IDAC_CAL_EN                          = " "0 (NORMAL_MODE),1 (MAN_IDAC_BUFFER_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MAN_CORR_CAL_EN                          = " "0 (NORMAL_MODE),1 (MAN_CORR_BUFFER_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MAN_PWM_CAL_EN                           = " "0 (NORMAL_MODE),1 (MAN_PWM_COMP_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAN_PFM_CAL_EN                           = " "0 (NORMAL_MODE),1 (MAN_PFM_COMP_CAL_EN_TRUE)"
    tree.end
    tree "S2_CTRL_CAL_REQUEST"
      sgroup "S2_CTRL_CAL_REQUEST (at 0x117e8)"
        set &access:&cmd_addr %l (0x8017e80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S2_CTRL_CAL_CTL"
      sgroup "S2_CTRL_CAL_CTL (at 0x117e9)"
        set &access:&cmd_addr %l (0x8017e90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0 (IDAC_BUFFER_CAL_DISABL),1 (IDAC_BUFFER_CAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0 (CORR_BUFFER_CAL_DISABL),1 (CORR_BUFFER_CAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0 (PWM_COMP_CAL_DISABL),1 (PWM_COMP_CAL_ENABL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0 (PFM_COMP_CAL_DISABL),1 (PFM_COMP_CAL_ENABL)"
    tree.end
    tree "S2_CTRL_IDAC_CAL_VAL"
      sgroup "S2_CTRL_IDAC_CAL_VAL (at 0x117ea)"
        set &access:&cmd_addr %l (0x8017ea0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17ea0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_CORR_CAL_VAL"
      sgroup "S2_CTRL_CORR_CAL_VAL (at 0x117eb)"
        set &access:&cmd_addr %l (0x8017eb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17eb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_PWM_CAL_VAL"
      sgroup "S2_CTRL_PWM_CAL_VAL (at 0x117ec)"
        set &access:&cmd_addr %l (0x8017ec0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17ec0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_PFM_CAL_VAL"
      sgroup "S2_CTRL_PFM_CAL_VAL (at 0x117ed)"
        set &access:&cmd_addr %l (0x8017ed0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17ed0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_MPHASE_IDAC"
      sgroup "S2_CTRL_MPHASE_IDAC (at 0x117ee)"
        set &access:&cmd_addr %l (0x8017ee0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17ee0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0 (MPHASE_IDAC_OVERRIDE_FALSE),1 (MPHASE_IDAC_OVERRIDE_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      sgroup "S2_CTRL_TRIM_NUM (at 0x117f0)"
        set &access:&cmd_addr %l (0x8017f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_REFDAC_TRIM"
      sgroup "S2_CTRL_REFDAC_TRIM (at 0x117f1)"
        set &access:&cmd_addr %l (0x8017f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0 (REFDAC_TRIM_EN_FALSE),1 (REFDAC_TRIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S2_CTRL_IDAC_TRIM"
      sgroup "S2_CTRL_IDAC_TRIM (at 0x117f2)"
        set &access:&cmd_addr %l (0x8017f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S2_CTRL_CORR_TRIM"
      sgroup "S2_CTRL_CORR_TRIM (at 0x117f3)"
        set &access:&cmd_addr %l (0x8017f30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17f30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S2_CTRL_PWM_TRIM"
      sgroup "S2_CTRL_PWM_TRIM (at 0x117f4)"
        set &access:&cmd_addr %l (0x8017f40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17f40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S2_CTRL_PFM_TRIM"
      sgroup "S2_CTRL_PFM_TRIM (at 0x117f5)"
        set &access:&cmd_addr %l (0x8017f50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17f50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_RAMP_TRIM"
      sgroup "S2_CTRL_RAMP_TRIM (at 0x117f6)"
        set &access:&cmd_addr %l (0x8017f60|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17f60|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      sgroup "S2_FREQ_REVISION1 (at 0x11900)"
        set &access:&cmd_addr %l (0x8019000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      sgroup "S2_FREQ_REVISION2 (at 0x11901)"
        set &access:&cmd_addr %l (0x8019010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      sgroup "S2_FREQ_PERPH_TYPE (at 0x11904)"
        set &access:&cmd_addr %l (0x8019040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      sgroup "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
        set &access:&cmd_addr %l (0x8019050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      sgroup "S2_FREQ_CLK_ENABLE (at 0x11946)"
        set &access:&cmd_addr %l (0x8019460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      sgroup "S2_FREQ_CLK_DIV (at 0x11950)"
        set &access:&cmd_addr %l (0x8019500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      sgroup "S2_FREQ_CLK_PHASE (at 0x11951)"
        set &access:&cmd_addr %l (0x8019510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      sgroup "S2_FREQ_GANG_CTL1 (at 0x119c0)"
        set &access:&cmd_addr %l (0x8019c00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19c00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      sgroup "S2_FREQ_GANG_CTL2 (at 0x119c1)"
        set &access:&cmd_addr %l (0x8019c10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19c10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      sgroup "S2_FREQ_SEC_ACCESS (at 0x119d0)"
        set &access:&cmd_addr %l (0x8019d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      sgroup "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
        set &access:&cmd_addr %l (0x8019d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      sgroup "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
        set &access:&cmd_addr %l (0x8019da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      sgroup "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
        set &access:&cmd_addr %l (0x8019db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S2_FREQ_TEST1"
      sgroup "S2_FREQ_TEST1 (at 0x119e2)"
        set &access:&cmd_addr %l (0x8019e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x19e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      sgroup "S2_PS_REVISION1 (at 0x11800)"
        set &access:&cmd_addr %l (0x8018000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      sgroup "S2_PS_REVISION2 (at 0x11801)"
        set &access:&cmd_addr %l (0x8018010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      sgroup "S2_PS_REVISION3 (at 0x11802)"
        set &access:&cmd_addr %l (0x8018020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      sgroup "S2_PS_REVISION4 (at 0x11803)"
        set &access:&cmd_addr %l (0x8018030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      sgroup "S2_PS_PERPH_TYPE (at 0x11804)"
        set &access:&cmd_addr %l (0x8018040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      sgroup "S2_PS_PERPH_SUBTYPE (at 0x11805)"
        set &access:&cmd_addr %l (0x8018050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_VOLTAGE_CTL1"
      sgroup "S2_PS_VOLTAGE_CTL1 (at 0x11840)"
        set &access:&cmd_addr %l (0x8018400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0 (LV_RANGE),1 (MV_RANGE)"
    tree.end
    tree "S2_PS_VOLTAGE_CTL2"
      sgroup "S2_PS_VOLTAGE_CTL2 (at 0x11841)"
        set &access:&cmd_addr %l (0x8018410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_PS_FREQ_CTL"
      sgroup "S2_PS_FREQ_CTL (at 0x11850)"
        set &access:&cmd_addr %l (0x8018500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_PS_MULTIPHASE_CTL"
      sgroup "S2_PS_MULTIPHASE_CTL (at 0x11851)"
        set &access:&cmd_addr %l (0x8018510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0 (SINGLE_PHASE_CONFIG),1 (MULTI_PHASE_CONFIG)"
    tree.end
    tree "S2_PS_PHASE_CTL"
      sgroup "S2_PS_PHASE_CTL (at 0x11852)"
        set &access:&cmd_addr %l (0x8018520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0 (DISABLE_ACTIVE_PHASE_CURRENT_BALANCING),1 (ENABLE_ACTIVE_PHASE_CURRENT_BALANCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE_STANDBY_MODE                       = " "0 (STANDBY_OFF),1 (WARM_STANDBY)"
    tree.end
    tree "S2_PS_PHASE_ID"
      sgroup "S2_PS_PHASE_ID (at 0x11853)"
        set &access:&cmd_addr %l (0x8018530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0 (PHASE_NUMBER_1),1 (PHASE_NUMBER_2),2 (PHASE_NUMBER_3),3 (PHASE_NUMBER_4)"
    tree.end
    tree "S2_PS_PHASE_CNT"
      sgroup "S2_PS_PHASE_CNT (at 0x11854)"
        set &access:&cmd_addr %l (0x8018540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0 (PHASE_COUNT_1),1 (PHASE_COUNT_2),2 (PHASE_COUNT_4_NOT_3),3 (PHASE_COUNT_4)"
    tree.end
    tree "S2_PS_PWM_CL_CTL"
      sgroup "S2_PS_PWM_CL_CTL (at 0x11860)"
        set &access:&cmd_addr %l (0x8018600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0 (PWM_ILIM_1P0A),1 (PWM_ILIM_1P5A),2 (PWM_ILIM_2P0A),3 (PWM_ILIM_2P5A),4 (PWM_ILIM_3P0A),5 (PWM_ILIM_3P5A),6 (PWM_ILIM_4P0A),7 (PWM_ILIM_4P5A)"
    tree.end
    tree "S2_PS_LPM_CL_CTL"
      sgroup "S2_PS_LPM_CL_CTL (at 0x11861)"
        set &access:&cmd_addr %l (0x8018610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_CL_FINE                              = " "0 (LPM_CL_FINE_OFF),1 (LPM_CL_FINE_0P167A),2 (LPM_CL_FINE_0P334A),3 (LPM_CL_FINE_0P501A),4 (LPM_CL_FINE_0P668A),5 (LPM_CL_FINE_0P835A),6 (LPM_CL_FINE_1P002A),7 (LPM_CL_FINE_1P169A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0 (LPM_CL_0P5A),1 (LPM_CL_1P0A),2 (LPM_CL_1P5A),3 (LPM_CL_2P0A),4 (LPM_CL_2P5A),5 (LPM_CL_3P0A),6 (LPM_CL_3P5A),7 (LPM_CL_4P0A)"
    tree.end
    tree "S2_PS_AUTO_CTL"
      sgroup "S2_PS_AUTO_CTL (at 0x11862)"
        set &access:&cmd_addr %l (0x8018620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0 (LPM_EXIT_CYCLES_2),1 (LPM_EXIT_CYCLES_4),2 (LPM_EXIT_CYCLES_6),3 (LPM_EXIT_CYCLES_8),4 (LPM_EXIT_CYCLES_12),5 (LPM_EXIT_CYCLES_16),6 (LPM_EXIT_CYCLES_24),7 (LPM_EXIT_CYCLES_32)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0 (LPM_ENTRY_CYCLES_1),1 (LPM_ENTRY_CYCLES_5),2 (LPM_ENTRY_CYCLES_9),3 (LPM_ENTRY_CYCLES_13),4 (LPM_ENTRY_CYCLES_17),5 (LPM_ENTRY_CYCLES_21),6 (LPM_ENTRY_CYCLES_25),7 (LPM_ENTRY_CYCLES_29)"
    tree.end
    tree "S2_PS_ZX_ADAPT_CTL"
      sgroup "S2_PS_ZX_ADAPT_CTL (at 0x11863)"
        set &access:&cmd_addr %l (0x8018630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZX_SAMPLE_CTL                            = " "0 (OVERRIDE_IADC_WITH_ZEROS_WHEN_TRISTATE_ASSERTED_FOR_ANY_PART_OF_TRISTATE_SAMPLE_WINDOW),1 (OVERRIDE_IADC_WITH_ZEROS_WHEN_TRISTATE_ASSERTED_FOR_FULL_TRISTATE_SAMPLE_WINDOW),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ZX_UP_CYCLES                             = " "0 (ZX_UP_CYCLES_4),1 (ZX_UP_CYCLES_12),2 (ZX_UP_CYCLES_20),3 (ZX_UP_CYCLES_28)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_DOWN_CYCLES                           = " "0 (ZX_DOWN_CYCLES_4),1 (ZX_DOWN_CYCLES_12),2 (ZX_DOWN_CYCLES_20),3 (ZX_DOWN_CYCLES_28)"
    tree.end
    tree "S2_PS_ZX_ADAPT_VAL"
      sgroup "S2_PS_ZX_ADAPT_VAL (at 0x11864)"
        set &access:&cmd_addr %l (0x8018640|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18640|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_ADAPT_VAL                             = "
    tree.end
    tree "S2_PS_FSM_MINON_CFG"
      sgroup "S2_PS_FSM_MINON_CFG (at 0x11870)"
        set &access:&cmd_addr %l (0x8018700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0 (CL_EXTEND_BLANK_DISABLED),1 (CL_EXTEND_BLANK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0 (NMOS_MIN_ON_TIME_ILLEGAL),1 (NMOS_MIN_ON_TIME_10NS),2 (NMOS_MIN_ON_TIME_20NS),3 (NMOS_MIN_ON_TIME_30NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0 (PMOS_MIN_ON_TIME_ILLEGAL),1 (PMOS_MIN_ON_TIME_10NS),2 (PMOS_MIN_ON_TIME_20NS),3 (PMOS_MIN_ON_TIME_30NS)"
    tree.end
    tree "S2_PS_ICOMP_EN_CFG"
      sgroup "S2_PS_ICOMP_EN_CFG (at 0x11871)"
        set &access:&cmd_addr %l (0x8018710|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18710|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_TEST_EN                               = " "0 (CL_TEST_MODE_DISABLED_FOR_NORMAL_OP),1 (CL_TEST_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADC_TEST_EN                              = " "0 (ADC_TEST_MODE_DISABLED_FOR_NORMAL_OP),1 (ADC_TEST_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0 (CURRENT_LIMIT_DISABLED),1 (CURRENT_LIMIT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0 (ZX_COMP_DISABLED),1 (ZX_COMP_ENABLED_FOR_PWM_LPM_BURSTS_WARMUP),2 (ILLEGAL),3 (ZX_COMP_ALWAYS_ENABLED)"
    tree.end
    tree "S2_PS_ZX_CAL_CFG"
      sgroup "S2_PS_ZX_CAL_CFG (at 0x11872)"
        set &access:&cmd_addr %l (0x8018720|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18720|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0 (ZX_CAL_USES_OPT_TRIM_CODE_PLUS_ZX_VOS_NOM),1 (ZX_CAL_USES_ZERO_TRIM_CODE_PLUS_ZX_VOS_NOM),2 (ZX_CAL_USES_POWERON_CAL_PLUS_ZX_VOS_NOM),3 (ZX_CAL_ADAPTIVE_ZX_ENABLED_AND_USES_POWERON_CAL_PLUS_ZX_VOS_NOM)"
    tree.end
    tree "S2_PS_NONOVLAP_CFG"
      sgroup "S2_PS_NONOVLAP_CFG (at 0x11873)"
        set &access:&cmd_addr %l (0x8018730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0 (NDRV_ON_DEL_0NS),1 (NDRV_ON_DEL_0P5NS),2 (NDRV_ON_DEL_1NS),3 (NDRV_ON_DEL_2NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0 (PDRV_ON_DEL_0NS),1 (PDRV_ON_DEL_0P5NS),2 (PDRV_ON_DEL_1NS),3 (PDRV_ON_DEL_2NS)"
    tree.end
    tree "S2_PS_MPHASE_PI_CFG1"
      sgroup "S2_PS_MPHASE_PI_CFG1 (at 0x11874)"
        set &access:&cmd_addr %l (0x8018740|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18740|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG2"
      sgroup "S2_PS_MPHASE_PI_CFG2 (at 0x11875)"
        set &access:&cmd_addr %l (0x8018750|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18750|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG3"
      sgroup "S2_PS_MPHASE_PI_CFG3 (at 0x11876)"
        set &access:&cmd_addr %l (0x8018760|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18760|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG4"
      sgroup "S2_PS_MPHASE_PI_CFG4 (at 0x11877)"
        set &access:&cmd_addr %l (0x8018770|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18770|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG5"
      sgroup "S2_PS_MPHASE_PI_CFG5 (at 0x11878)"
        set &access:&cmd_addr %l (0x8018780|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18780|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG6"
      sgroup "S2_PS_MPHASE_PI_CFG6 (at 0x11879)"
        set &access:&cmd_addr %l (0x8018790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S2_PS_CAL_FAULT"
      sgroup "S2_PS_CAL_FAULT (at 0x1187a)"
        set &access:&cmd_addr %l (0x80187a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x187a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0 (ZX_CAL_FAULT_FALSE),1 (ZX_CAL_FAULT_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S2_PS_ADC_OUT"
      sgroup "S2_PS_ADC_OUT (at 0x1187b)"
        set &access:&cmd_addr %l (0x80187b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x187b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S2_PS_MP_IAVG2"
      sgroup "S2_PS_MP_IAVG2 (at 0x1187c)"
        set &access:&cmd_addr %l (0x80187c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x187c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S2_PS_MP_IAVG1"
      sgroup "S2_PS_MP_IAVG1 (at 0x1187d)"
        set &access:&cmd_addr %l (0x80187d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x187d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S2_PS_MP_DAC_DATA"
      sgroup "S2_PS_MP_DAC_DATA (at 0x1187e)"
        set &access:&cmd_addr %l (0x80187e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x187e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S2_PS_MP_IAVG_DFT"
      sgroup "S2_PS_MP_IAVG_DFT (at 0x1187f)"
        set &access:&cmd_addr %l (0x80187f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x187f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MP_IAVG_DFT                              = " "0 (MP_IAVG_DFT_NOT_FORCED_FOR_NORMAL_OP),1 (MP_IAVG_DFT_FORCED_TO_A5),2 (MP_IAVG_DFT_FORCED_TO_15),3 (MP_IAVG_DFT_FORCED_TO_FF)"
    tree.end
    tree "S2_PS_GANG_CTL1"
      sgroup "S2_PS_GANG_CTL1 (at 0x118c0)"
        set &access:&cmd_addr %l (0x8018c00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18c00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_PS_GANG_CTL2"
      sgroup "S2_PS_GANG_CTL2 (at 0x118c1)"
        set &access:&cmd_addr %l (0x8018c10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18c10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_PS_SEC_ACCESS"
      sgroup "S2_PS_SEC_ACCESS (at 0x118d0)"
        set &access:&cmd_addr %l (0x8018d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      sgroup "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
        set &access:&cmd_addr %l (0x8018d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      sgroup "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
        set &access:&cmd_addr %l (0x8018da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      sgroup "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
        set &access:&cmd_addr %l (0x8018db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_PS_ATEST12"
      sgroup "S2_PS_ATEST12 (at 0x118e2)"
        set &access:&cmd_addr %l (0x8018e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0 (ATEST2_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST2_NOT_USED1),2 (ATEST2_NOT_USED2),3 (ILLEGAL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0 (ATEST1_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST1_ADC_DAC_OUT),2 (ATEST1_NOT_USED),3 (ILLEGAL)"
    tree.end
    tree "S2_PS_ATEST34"
      sgroup "S2_PS_ATEST34 (at 0x118e3)"
        set &access:&cmd_addr %l (0x8018e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0 (ATEST4_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST4_PGND),2 (ATEST4_VDDIN),3 (ILLEGAL)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0 (ATEST3_NOT_CONNECTED_FOR_NORMAL_OP),1 (ATEST3_VSW),2 (ATEST3_NOT_USED),3 (ILLEGAL)"
    tree.end
    tree "S2_PS_DTEST12"
      sgroup "S2_PS_DTEST12 (at 0x118e4)"
        set &access:&cmd_addr %l (0x8018e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S2_PS_DTEST43"
      sgroup "S2_PS_DTEST43 (at 0x118e5)"
        set &access:&cmd_addr %l (0x8018e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S2_PS_MAN_CAL_CTL"
      sgroup "S2_PS_MAN_CAL_CTL (at 0x118e7)"
        set &access:&cmd_addr %l (0x8018e70|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18e70|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAN_ZX_CAL_EN                            = " "0 (MAN_ZX_CAL_EN_FALSE),1 (MAN_ZX_CAL_EN_TRUE)"
    tree.end
    tree "S2_PS_CAL_REQUEST"
      sgroup "S2_PS_CAL_REQUEST (at 0x118e8)"
        set &access:&cmd_addr %l (0x8018e80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18e80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "S2_PS_TRIM_NUM"
      sgroup "S2_PS_TRIM_NUM (at 0x118f0)"
        set &access:&cmd_addr %l (0x8018f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_PS_ZX_TRIM"
      sgroup "S2_PS_ZX_TRIM (at 0x118f1)"
        set &access:&cmd_addr %l (0x8018f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S2_PS_CL_TRIM"
      sgroup "S2_PS_CL_TRIM (at 0x118f2)"
        set &access:&cmd_addr %l (0x8018f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x18f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0 (CL_TRIM_OFF),1 (CL_TRIM_0P167A),2 (CL_TRIM_0P334A),3 (CL_TRIM_0P501A),4 (CL_TRIM_0P668A),5 (CL_TRIM_0P835A),6 (CL_TRIM_1P002A),7 (CL_TRIM_1P169A)"
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      sgroup "S3_CTRL_REVISION1 (at 0x11a00)"
        set &access:&cmd_addr %l (0x801a000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      sgroup "S3_CTRL_REVISION2 (at 0x11a01)"
        set &access:&cmd_addr %l (0x801a010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      sgroup "S3_CTRL_REVISION3 (at 0x11a02)"
        set &access:&cmd_addr %l (0x801a020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      sgroup "S3_CTRL_REVISION4 (at 0x11a03)"
        set &access:&cmd_addr %l (0x801a030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      sgroup "S3_CTRL_PERPH_TYPE (at 0x11a04)"
        set &access:&cmd_addr %l (0x801a040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      sgroup "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
        set &access:&cmd_addr %l (0x801a050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS"
      sgroup "S3_CTRL_STATUS (at 0x11a08)"
        set &access:&cmd_addr %l (0x801a080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      sgroup "S3_CTRL_INT_RT_STS (at 0x11a10)"
        set &access:&cmd_addr %l (0x801a100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      sgroup "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
        set &access:&cmd_addr %l (0x801a110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      sgroup "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
        set &access:&cmd_addr %l (0x801a120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      sgroup "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
        set &access:&cmd_addr %l (0x801a130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      sgroup "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
        set &access:&cmd_addr %l (0x801a140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      sgroup "S3_CTRL_INT_EN_SET (at 0x11a15)"
        set &access:&cmd_addr %l (0x801a150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      sgroup "S3_CTRL_INT_EN_CLR (at 0x11a16)"
        set &access:&cmd_addr %l (0x801a160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      sgroup "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
        set &access:&cmd_addr %l (0x801a180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      sgroup "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
        set &access:&cmd_addr %l (0x801a190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      sgroup "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
        set &access:&cmd_addr %l (0x801a1a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a1a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      sgroup "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
        set &access:&cmd_addr %l (0x801a1b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a1b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL1"
      sgroup "S3_CTRL_VOLTAGE_CTL1 (at 0x11a40)"
        set &access:&cmd_addr %l (0x801a400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL2"
      sgroup "S3_CTRL_VOLTAGE_CTL2 (at 0x11a41)"
        set &access:&cmd_addr %l (0x801a410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_PFM_CTL"
      sgroup "S3_CTRL_PFM_CTL (at 0x11a44)"
        set &access:&cmd_addr %l (0x801a440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S3_CTRL_MODE_CTL"
      sgroup "S3_CTRL_MODE_CTL (at 0x11a45)"
        set &access:&cmd_addr %l (0x801a450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S3_CTRL_EN_CTL"
      sgroup "S3_CTRL_EN_CTL (at 0x11a46)"
        set &access:&cmd_addr %l (0x801a460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S3_CTRL_PD_CTL"
      sgroup "S3_CTRL_PD_CTL (at 0x11a48)"
        set &access:&cmd_addr %l (0x801a480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S3_CTRL_COMP_CAP_CTL"
      sgroup "S3_CTRL_COMP_CAP_CTL (at 0x11a51)"
        set &access:&cmd_addr %l (0x801a510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S3_CTRL_GM_CTL"
      sgroup "S3_CTRL_GM_CTL (at 0x11a52)"
        set &access:&cmd_addr %l (0x801a520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S3_CTRL_RZ_CTL"
      sgroup "S3_CTRL_RZ_CTL (at 0x11a53)"
        set &access:&cmd_addr %l (0x801a530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S3_CTRL_ISNS_CTRL"
      sgroup "S3_CTRL_ISNS_CTRL (at 0x11a55)"
        set &access:&cmd_addr %l (0x801a550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S3_CTRL_SAW_CTL"
      sgroup "S3_CTRL_SAW_CTL (at 0x11a56)"
        set &access:&cmd_addr %l (0x801a560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S3_CTRL_DMAX_CTL"
      sgroup "S3_CTRL_DMAX_CTL (at 0x11a58)"
        set &access:&cmd_addr %l (0x801a580|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a580|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_CTL"
      sgroup "S3_CTRL_PULSE_SKIP_CTL (at 0x11a59)"
        set &access:&cmd_addr %l (0x801a590|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a590|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_THRES"
      sgroup "S3_CTRL_PULSE_SKIP_THRES (at 0x11a5a)"
        set &access:&cmd_addr %l (0x801a5a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a5a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S3_CTRL_AUTO_MODE_CTL"
      sgroup "S3_CTRL_AUTO_MODE_CTL (at 0x11a5b)"
        set &access:&cmd_addr %l (0x801a5b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a5b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S3_CTRL_INZERO_COUNT_CTL"
      sgroup "S3_CTRL_INZERO_COUNT_CTL (at 0x11a5c)"
        set &access:&cmd_addr %l (0x801a5c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a5c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PFM_COUNT_CTL"
      sgroup "S3_CTRL_PFM_COUNT_CTL (at 0x11a5d)"
        set &access:&cmd_addr %l (0x801a5d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a5d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PS_VGA_CTL"
      sgroup "S3_CTRL_PS_VGA_CTL (at 0x11a5e)"
        set &access:&cmd_addr %l (0x801a5e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a5e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S3_CTRL_STEPPER_SS_CTL"
      sgroup "S3_CTRL_STEPPER_SS_CTL (at 0x11a60)"
        set &access:&cmd_addr %l (0x801a600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_STEPPER_VS_CTL"
      sgroup "S3_CTRL_STEPPER_VS_CTL (at 0x11a61)"
        set &access:&cmd_addr %l (0x801a610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_FT_CTL"
      sgroup "S3_CTRL_FT_CTL (at 0x11a62)"
        set &access:&cmd_addr %l (0x801a620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S3_CTRL_QMODE_SHADOW"
      sgroup "S3_CTRL_QMODE_SHADOW (at 0x11a63)"
        set &access:&cmd_addr %l (0x801a630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S3_CTRL_UL_LL_CTRL"
      sgroup "S3_CTRL_UL_LL_CTRL (at 0x11a68)"
        set &access:&cmd_addr %l (0x801a680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S3_CTRL_UL_VOLTAGE"
      sgroup "S3_CTRL_UL_VOLTAGE (at 0x11a69)"
        set &access:&cmd_addr %l (0x801a690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_LL_VOLTAGE"
      sgroup "S3_CTRL_LL_VOLTAGE (at 0x11a6b)"
        set &access:&cmd_addr %l (0x801a6b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a6b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_CTLR_MISC"
      sgroup "S3_CTRL_CTLR_MISC (at 0x11a7a)"
        set &access:&cmd_addr %l (0x801a7a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1a7a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S3_CTRL_SEC_ACCESS"
      sgroup "S3_CTRL_SEC_ACCESS (at 0x11ad0)"
        set &access:&cmd_addr %l (0x801ad00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ad00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      sgroup "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
        set &access:&cmd_addr %l (0x801ad80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ad80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      sgroup "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
        set &access:&cmd_addr %l (0x801ad90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ad90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      sgroup "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
        set &access:&cmd_addr %l (0x801ada0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ada0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      sgroup "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
        set &access:&cmd_addr %l (0x801adb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1adb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      sgroup "S3_CTRL_INT_TEST1 (at 0x11ae0)"
        set &access:&cmd_addr %l (0x801ae00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ae00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      sgroup "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
        set &access:&cmd_addr %l (0x801ae10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ae10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S3_CTRL_CTLR_TEST"
      sgroup "S3_CTRL_CTLR_TEST (at 0x11ae2)"
        set &access:&cmd_addr %l (0x801ae20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ae20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      sgroup "S3_CTRL_TRIM_NUM (at 0x11af0)"
        set &access:&cmd_addr %l (0x801af00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1af00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_CTRL_CTL_TRIM1"
      sgroup "S3_CTRL_CTL_TRIM1 (at 0x11af1)"
        set &access:&cmd_addr %l (0x801af10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1af10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S3_CTRL_CTL_TRIM2"
      sgroup "S3_CTRL_CTL_TRIM2 (at 0x11af2)"
        set &access:&cmd_addr %l (0x801af20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1af20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S3_CTRL_CTL_TRIM3"
      sgroup "S3_CTRL_CTL_TRIM3 (at 0x11af3)"
        set &access:&cmd_addr %l (0x801af30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1af30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S3_CTRL_CTL_TRIM4"
      sgroup "S3_CTRL_CTL_TRIM4 (at 0x11af4)"
        set &access:&cmd_addr %l (0x801af40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1af40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      sgroup "S3_FREQ_REVISION1 (at 0x11c00)"
        set &access:&cmd_addr %l (0x801c000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1c000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      sgroup "S3_FREQ_REVISION2 (at 0x11c01)"
        set &access:&cmd_addr %l (0x801c010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1c010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      sgroup "S3_FREQ_PERPH_TYPE (at 0x11c04)"
        set &access:&cmd_addr %l (0x801c040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1c040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      sgroup "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
        set &access:&cmd_addr %l (0x801c050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1c050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      sgroup "S3_FREQ_CLK_ENABLE (at 0x11c46)"
        set &access:&cmd_addr %l (0x801c460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1c460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      sgroup "S3_FREQ_CLK_DIV (at 0x11c50)"
        set &access:&cmd_addr %l (0x801c500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1c500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      sgroup "S3_FREQ_CLK_PHASE (at 0x11c51)"
        set &access:&cmd_addr %l (0x801c510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1c510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      sgroup "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
        set &access:&cmd_addr %l (0x801cc00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1cc00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      sgroup "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
        set &access:&cmd_addr %l (0x801cc10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1cc10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      sgroup "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
        set &access:&cmd_addr %l (0x801cd00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1cd00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      sgroup "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
        set &access:&cmd_addr %l (0x801cd90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1cd90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      sgroup "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
        set &access:&cmd_addr %l (0x801cda0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1cda0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      sgroup "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
        set &access:&cmd_addr %l (0x801cdb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1cdb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S3_FREQ_TEST1"
      sgroup "S3_FREQ_TEST1 (at 0x11ce2)"
        set &access:&cmd_addr %l (0x801ce20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ce20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      sgroup "S3_PS_REVISION1 (at 0x11b00)"
        set &access:&cmd_addr %l (0x801b000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      sgroup "S3_PS_REVISION2 (at 0x11b01)"
        set &access:&cmd_addr %l (0x801b010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      sgroup "S3_PS_REVISION3 (at 0x11b02)"
        set &access:&cmd_addr %l (0x801b020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      sgroup "S3_PS_REVISION4 (at 0x11b03)"
        set &access:&cmd_addr %l (0x801b030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      sgroup "S3_PS_PERPH_TYPE (at 0x11b04)"
        set &access:&cmd_addr %l (0x801b040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      sgroup "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
        set &access:&cmd_addr %l (0x801b050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PWM_CURRENT_LIM_CTL (at 0x11b4a)"
        set &access:&cmd_addr %l (0x801b4a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b4a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S3_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PFM_CURRENT_LIM_CTL (at 0x11b4b)"
        set &access:&cmd_addr %l (0x801b4b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b4b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S3_PS_SOFT_START_CTL"
      sgroup "S3_PS_SOFT_START_CTL (at 0x11b4c)"
        set &access:&cmd_addr %l (0x801b4c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b4c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S3_PS_SWITCH_SIZE_CTL"
      sgroup "S3_PS_SWITCH_SIZE_CTL (at 0x11b70)"
        set &access:&cmd_addr %l (0x801b700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL1"
      sgroup "S3_PS_DEAD_TIME_CTRL1 (at 0x11b71)"
        set &access:&cmd_addr %l (0x801b710|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b710|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL2"
      sgroup "S3_PS_DEAD_TIME_CTRL2 (at 0x11b72)"
        set &access:&cmd_addr %l (0x801b720|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b720|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S3_PS_BLNK_TIME_CTL"
      sgroup "S3_PS_BLNK_TIME_CTL (at 0x11b73)"
        set &access:&cmd_addr %l (0x801b730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S3_PS_INZERO_CTL"
      sgroup "S3_PS_INZERO_CTL (at 0x11b74)"
        set &access:&cmd_addr %l (0x801b740|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b740|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S3_PS_DIG_FSM_CTL"
      sgroup "S3_PS_DIG_FSM_CTL (at 0x11b75)"
        set &access:&cmd_addr %l (0x801b750|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b750|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S3_PS_PWR_STG_MISC"
      sgroup "S3_PS_PWR_STG_MISC (at 0x11b79)"
        set &access:&cmd_addr %l (0x801b790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1b790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S3_PS_SEC_ACCESS"
      sgroup "S3_PS_SEC_ACCESS (at 0x11bd0)"
        set &access:&cmd_addr %l (0x801bd00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1bd00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      sgroup "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
        set &access:&cmd_addr %l (0x801bd90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1bd90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      sgroup "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
        set &access:&cmd_addr %l (0x801bda0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1bda0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      sgroup "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
        set &access:&cmd_addr %l (0x801bdb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1bdb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S3_PS_FORCE_FET_TEST"
      sgroup "S3_PS_FORCE_FET_TEST (at 0x11be3)"
        set &access:&cmd_addr %l (0x801be30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1be30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S3_PS_PWR_STG_TEST"
      sgroup "S3_PS_PWR_STG_TEST (at 0x11be4)"
        set &access:&cmd_addr %l (0x801be40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1be40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_PS_TRIM_NUM"
      sgroup "S3_PS_TRIM_NUM (at 0x11bf0)"
        set &access:&cmd_addr %l (0x801bf00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1bf00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_PS_PS_TRIM1"
      sgroup "S3_PS_PS_TRIM1 (at 0x11bf1)"
        set &access:&cmd_addr %l (0x801bf10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1bf10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S3_PS_PS_TRIM2"
      sgroup "S3_PS_PS_TRIM2 (at 0x11bf2)"
        set &access:&cmd_addr %l (0x801bf20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1bf20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      sgroup "S4_CTRL_REVISION1 (at 0x11d00)"
        set &access:&cmd_addr %l (0x801d000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      sgroup "S4_CTRL_REVISION2 (at 0x11d01)"
        set &access:&cmd_addr %l (0x801d010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      sgroup "S4_CTRL_REVISION3 (at 0x11d02)"
        set &access:&cmd_addr %l (0x801d020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      sgroup "S4_CTRL_REVISION4 (at 0x11d03)"
        set &access:&cmd_addr %l (0x801d030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      sgroup "S4_CTRL_PERPH_TYPE (at 0x11d04)"
        set &access:&cmd_addr %l (0x801d040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      sgroup "S4_CTRL_PERPH_SUBTYPE (at 0x11d05)"
        set &access:&cmd_addr %l (0x801d050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS"
      sgroup "S4_CTRL_STATUS (at 0x11d08)"
        set &access:&cmd_addr %l (0x801d080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      sgroup "S4_CTRL_INT_RT_STS (at 0x11d10)"
        set &access:&cmd_addr %l (0x801d100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      sgroup "S4_CTRL_INT_SET_TYPE (at 0x11d11)"
        set &access:&cmd_addr %l (0x801d110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      sgroup "S4_CTRL_INT_POLARITY_HIGH (at 0x11d12)"
        set &access:&cmd_addr %l (0x801d120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      sgroup "S4_CTRL_INT_POLARITY_LOW (at 0x11d13)"
        set &access:&cmd_addr %l (0x801d130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      sgroup "S4_CTRL_INT_LATCHED_CLR (at 0x11d14)"
        set &access:&cmd_addr %l (0x801d140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      sgroup "S4_CTRL_INT_EN_SET (at 0x11d15)"
        set &access:&cmd_addr %l (0x801d150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      sgroup "S4_CTRL_INT_EN_CLR (at 0x11d16)"
        set &access:&cmd_addr %l (0x801d160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      sgroup "S4_CTRL_INT_LATCHED_STS (at 0x11d18)"
        set &access:&cmd_addr %l (0x801d180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      sgroup "S4_CTRL_INT_PENDING_STS (at 0x11d19)"
        set &access:&cmd_addr %l (0x801d190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      sgroup "S4_CTRL_INT_MID_SEL (at 0x11d1a)"
        set &access:&cmd_addr %l (0x801d1a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d1a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      sgroup "S4_CTRL_INT_PRIORITY (at 0x11d1b)"
        set &access:&cmd_addr %l (0x801d1b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d1b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL1"
      sgroup "S4_CTRL_VOLTAGE_CTL1 (at 0x11d40)"
        set &access:&cmd_addr %l (0x801d400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL2"
      sgroup "S4_CTRL_VOLTAGE_CTL2 (at 0x11d41)"
        set &access:&cmd_addr %l (0x801d410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_PFM_CTL"
      sgroup "S4_CTRL_PFM_CTL (at 0x11d44)"
        set &access:&cmd_addr %l (0x801d440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S4_CTRL_MODE_CTL"
      sgroup "S4_CTRL_MODE_CTL (at 0x11d45)"
        set &access:&cmd_addr %l (0x801d450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S4_CTRL_EN_CTL"
      sgroup "S4_CTRL_EN_CTL (at 0x11d46)"
        set &access:&cmd_addr %l (0x801d460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S4_CTRL_PD_CTL"
      sgroup "S4_CTRL_PD_CTL (at 0x11d48)"
        set &access:&cmd_addr %l (0x801d480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S4_CTRL_COMP_CAP_CTL"
      sgroup "S4_CTRL_COMP_CAP_CTL (at 0x11d51)"
        set &access:&cmd_addr %l (0x801d510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S4_CTRL_GM_CTL"
      sgroup "S4_CTRL_GM_CTL (at 0x11d52)"
        set &access:&cmd_addr %l (0x801d520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S4_CTRL_RZ_CTL"
      sgroup "S4_CTRL_RZ_CTL (at 0x11d53)"
        set &access:&cmd_addr %l (0x801d530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S4_CTRL_ISNS_CTRL"
      sgroup "S4_CTRL_ISNS_CTRL (at 0x11d55)"
        set &access:&cmd_addr %l (0x801d550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S4_CTRL_SAW_CTL"
      sgroup "S4_CTRL_SAW_CTL (at 0x11d56)"
        set &access:&cmd_addr %l (0x801d560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S4_CTRL_DMAX_CTL"
      sgroup "S4_CTRL_DMAX_CTL (at 0x11d58)"
        set &access:&cmd_addr %l (0x801d580|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d580|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_CTL"
      sgroup "S4_CTRL_PULSE_SKIP_CTL (at 0x11d59)"
        set &access:&cmd_addr %l (0x801d590|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d590|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_THRES"
      sgroup "S4_CTRL_PULSE_SKIP_THRES (at 0x11d5a)"
        set &access:&cmd_addr %l (0x801d5a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d5a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S4_CTRL_AUTO_MODE_CTL"
      sgroup "S4_CTRL_AUTO_MODE_CTL (at 0x11d5b)"
        set &access:&cmd_addr %l (0x801d5b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d5b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S4_CTRL_INZERO_COUNT_CTL"
      sgroup "S4_CTRL_INZERO_COUNT_CTL (at 0x11d5c)"
        set &access:&cmd_addr %l (0x801d5c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d5c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PFM_COUNT_CTL"
      sgroup "S4_CTRL_PFM_COUNT_CTL (at 0x11d5d)"
        set &access:&cmd_addr %l (0x801d5d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d5d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PS_VGA_CTL"
      sgroup "S4_CTRL_PS_VGA_CTL (at 0x11d5e)"
        set &access:&cmd_addr %l (0x801d5e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d5e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S4_CTRL_STEPPER_SS_CTL"
      sgroup "S4_CTRL_STEPPER_SS_CTL (at 0x11d60)"
        set &access:&cmd_addr %l (0x801d600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_STEPPER_VS_CTL"
      sgroup "S4_CTRL_STEPPER_VS_CTL (at 0x11d61)"
        set &access:&cmd_addr %l (0x801d610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_FT_CTL"
      sgroup "S4_CTRL_FT_CTL (at 0x11d62)"
        set &access:&cmd_addr %l (0x801d620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S4_CTRL_QMODE_SHADOW"
      sgroup "S4_CTRL_QMODE_SHADOW (at 0x11d63)"
        set &access:&cmd_addr %l (0x801d630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S4_CTRL_UL_LL_CTRL"
      sgroup "S4_CTRL_UL_LL_CTRL (at 0x11d68)"
        set &access:&cmd_addr %l (0x801d680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S4_CTRL_UL_VOLTAGE"
      sgroup "S4_CTRL_UL_VOLTAGE (at 0x11d69)"
        set &access:&cmd_addr %l (0x801d690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_LL_VOLTAGE"
      sgroup "S4_CTRL_LL_VOLTAGE (at 0x11d6b)"
        set &access:&cmd_addr %l (0x801d6b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d6b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S4_CTRL_CTLR_MISC"
      sgroup "S4_CTRL_CTLR_MISC (at 0x11d7a)"
        set &access:&cmd_addr %l (0x801d7a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1d7a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_SEC_ACCESS"
      sgroup "S4_CTRL_SEC_ACCESS (at 0x11dd0)"
        set &access:&cmd_addr %l (0x801dd00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1dd00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      sgroup "S4_CTRL_PERPH_RESET_CTL1 (at 0x11dd8)"
        set &access:&cmd_addr %l (0x801dd80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1dd80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      sgroup "S4_CTRL_PERPH_RESET_CTL2 (at 0x11dd9)"
        set &access:&cmd_addr %l (0x801dd90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1dd90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      sgroup "S4_CTRL_PERPH_RESET_CTL3 (at 0x11dda)"
        set &access:&cmd_addr %l (0x801dda0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1dda0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      sgroup "S4_CTRL_PERPH_RESET_CTL4 (at 0x11ddb)"
        set &access:&cmd_addr %l (0x801ddb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ddb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      sgroup "S4_CTRL_INT_TEST1 (at 0x11de0)"
        set &access:&cmd_addr %l (0x801de00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1de00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      sgroup "S4_CTRL_INT_TEST_VAL (at 0x11de1)"
        set &access:&cmd_addr %l (0x801de10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1de10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S4_CTRL_CTLR_TEST"
      sgroup "S4_CTRL_CTLR_TEST (at 0x11de2)"
        set &access:&cmd_addr %l (0x801de20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1de20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      sgroup "S4_CTRL_TRIM_NUM (at 0x11df0)"
        set &access:&cmd_addr %l (0x801df00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1df00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_CTRL_CTL_TRIM1"
      sgroup "S4_CTRL_CTL_TRIM1 (at 0x11df1)"
        set &access:&cmd_addr %l (0x801df10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1df10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S4_CTRL_CTL_TRIM2"
      sgroup "S4_CTRL_CTL_TRIM2 (at 0x11df2)"
        set &access:&cmd_addr %l (0x801df20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1df20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S4_CTRL_CTL_TRIM3"
      sgroup "S4_CTRL_CTL_TRIM3 (at 0x11df3)"
        set &access:&cmd_addr %l (0x801df30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1df30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S4_CTRL_CTL_TRIM4"
      sgroup "S4_CTRL_CTL_TRIM4 (at 0x11df4)"
        set &access:&cmd_addr %l (0x801df40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1df40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      sgroup "S4_FREQ_REVISION1 (at 0x11f00)"
        set &access:&cmd_addr %l (0x801f000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1f000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      sgroup "S4_FREQ_REVISION2 (at 0x11f01)"
        set &access:&cmd_addr %l (0x801f010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1f010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      sgroup "S4_FREQ_PERPH_TYPE (at 0x11f04)"
        set &access:&cmd_addr %l (0x801f040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1f040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      sgroup "S4_FREQ_PERPH_SUBTYPE (at 0x11f05)"
        set &access:&cmd_addr %l (0x801f050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1f050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      sgroup "S4_FREQ_CLK_ENABLE (at 0x11f46)"
        set &access:&cmd_addr %l (0x801f460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1f460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      sgroup "S4_FREQ_CLK_DIV (at 0x11f50)"
        set &access:&cmd_addr %l (0x801f500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1f500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      sgroup "S4_FREQ_CLK_PHASE (at 0x11f51)"
        set &access:&cmd_addr %l (0x801f510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1f510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      sgroup "S4_FREQ_GANG_CTL1 (at 0x11fc0)"
        set &access:&cmd_addr %l (0x801fc00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1fc00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      sgroup "S4_FREQ_GANG_CTL2 (at 0x11fc1)"
        set &access:&cmd_addr %l (0x801fc10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1fc10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      sgroup "S4_FREQ_SEC_ACCESS (at 0x11fd0)"
        set &access:&cmd_addr %l (0x801fd00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1fd00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      sgroup "S4_FREQ_PERPH_RESET_CTL2 (at 0x11fd9)"
        set &access:&cmd_addr %l (0x801fd90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1fd90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      sgroup "S4_FREQ_PERPH_RESET_CTL3 (at 0x11fda)"
        set &access:&cmd_addr %l (0x801fda0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1fda0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      sgroup "S4_FREQ_PERPH_RESET_CTL4 (at 0x11fdb)"
        set &access:&cmd_addr %l (0x801fdb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1fdb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S4_FREQ_TEST1"
      sgroup "S4_FREQ_TEST1 (at 0x11fe2)"
        set &access:&cmd_addr %l (0x801fe20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1fe20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      sgroup "S4_PS_REVISION1 (at 0x11e00)"
        set &access:&cmd_addr %l (0x801e000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      sgroup "S4_PS_REVISION2 (at 0x11e01)"
        set &access:&cmd_addr %l (0x801e010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      sgroup "S4_PS_REVISION3 (at 0x11e02)"
        set &access:&cmd_addr %l (0x801e020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      sgroup "S4_PS_REVISION4 (at 0x11e03)"
        set &access:&cmd_addr %l (0x801e030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      sgroup "S4_PS_PERPH_TYPE (at 0x11e04)"
        set &access:&cmd_addr %l (0x801e040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      sgroup "S4_PS_PERPH_SUBTYPE (at 0x11e05)"
        set &access:&cmd_addr %l (0x801e050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S4_PS_PWM_CURRENT_LIM_CTL (at 0x11e4a)"
        set &access:&cmd_addr %l (0x801e4a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e4a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S4_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S4_PS_PFM_CURRENT_LIM_CTL (at 0x11e4b)"
        set &access:&cmd_addr %l (0x801e4b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e4b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S4_PS_SOFT_START_CTL"
      sgroup "S4_PS_SOFT_START_CTL (at 0x11e4c)"
        set &access:&cmd_addr %l (0x801e4c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e4c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S4_PS_SWITCH_SIZE_CTL"
      sgroup "S4_PS_SWITCH_SIZE_CTL (at 0x11e70)"
        set &access:&cmd_addr %l (0x801e700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL1"
      sgroup "S4_PS_DEAD_TIME_CTRL1 (at 0x11e71)"
        set &access:&cmd_addr %l (0x801e710|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e710|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL2"
      sgroup "S4_PS_DEAD_TIME_CTRL2 (at 0x11e72)"
        set &access:&cmd_addr %l (0x801e720|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e720|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S4_PS_BLNK_TIME_CTL"
      sgroup "S4_PS_BLNK_TIME_CTL (at 0x11e73)"
        set &access:&cmd_addr %l (0x801e730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S4_PS_INZERO_CTL"
      sgroup "S4_PS_INZERO_CTL (at 0x11e74)"
        set &access:&cmd_addr %l (0x801e740|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e740|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S4_PS_DIG_FSM_CTL"
      sgroup "S4_PS_DIG_FSM_CTL (at 0x11e75)"
        set &access:&cmd_addr %l (0x801e750|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e750|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S4_PS_PWR_STG_MISC"
      sgroup "S4_PS_PWR_STG_MISC (at 0x11e79)"
        set &access:&cmd_addr %l (0x801e790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1e790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S4_PS_SEC_ACCESS"
      sgroup "S4_PS_SEC_ACCESS (at 0x11ed0)"
        set &access:&cmd_addr %l (0x801ed00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ed00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      sgroup "S4_PS_PERPH_RESET_CTL2 (at 0x11ed9)"
        set &access:&cmd_addr %l (0x801ed90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ed90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      sgroup "S4_PS_PERPH_RESET_CTL3 (at 0x11eda)"
        set &access:&cmd_addr %l (0x801eda0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1eda0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      sgroup "S4_PS_PERPH_RESET_CTL4 (at 0x11edb)"
        set &access:&cmd_addr %l (0x801edb0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1edb0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S4_PS_FORCE_FET_TEST"
      sgroup "S4_PS_FORCE_FET_TEST (at 0x11ee3)"
        set &access:&cmd_addr %l (0x801ee30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ee30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S4_PS_PWR_STG_TEST"
      sgroup "S4_PS_PWR_STG_TEST (at 0x11ee4)"
        set &access:&cmd_addr %l (0x801ee40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ee40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_PS_TRIM_NUM"
      sgroup "S4_PS_TRIM_NUM (at 0x11ef0)"
        set &access:&cmd_addr %l (0x801ef00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ef00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_PS_PS_TRIM1"
      sgroup "S4_PS_PS_TRIM1 (at 0x11ef1)"
        set &access:&cmd_addr %l (0x801ef10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ef10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S4_PS_PS_TRIM2"
      sgroup "S4_PS_PS_TRIM2 (at 0x11ef2)"
        set &access:&cmd_addr %l (0x801ef20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x1ef20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S5_CTRL"
  tree "S5_CTRL"
    tree "S5_CTRL_REVISION1"
      sgroup "S5_CTRL_REVISION1 (at 0x12000)"
        set &access:&cmd_addr %l (0x8020000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION2"
      sgroup "S5_CTRL_REVISION2 (at 0x12001)"
        set &access:&cmd_addr %l (0x8020010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_CTRL_REVISION3"
      sgroup "S5_CTRL_REVISION3 (at 0x12002)"
        set &access:&cmd_addr %l (0x8020020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION4"
      sgroup "S5_CTRL_REVISION4 (at 0x12003)"
        set &access:&cmd_addr %l (0x8020030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_CTRL_PERPH_TYPE"
      sgroup "S5_CTRL_PERPH_TYPE (at 0x12004)"
        set &access:&cmd_addr %l (0x8020040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_CTRL_PERPH_SUBTYPE"
      sgroup "S5_CTRL_PERPH_SUBTYPE (at 0x12005)"
        set &access:&cmd_addr %l (0x8020050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_CTRL_STATUS"
      sgroup "S5_CTRL_STATUS (at 0x12008)"
        set &access:&cmd_addr %l (0x8020080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0 (ILEGAL_LIMIT_STOP_FALSE),1 (ILEGAL_LIMIT_STOP_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0 (UL_INT_FALSE),1 (UL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0 (LL_INT_FALSE),1 (LL_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0 (PS_FALSE),1 (PS_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
    tree.end
    tree "S5_CTRL_INT_RT_STS"
      sgroup "S5_CTRL_INT_RT_STS (at 0x12010)"
        set &access:&cmd_addr %l (0x8020100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_SET_TYPE"
      sgroup "S5_CTRL_INT_SET_TYPE (at 0x12011)"
        set &access:&cmd_addr %l (0x8020110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_HIGH"
      sgroup "S5_CTRL_INT_POLARITY_HIGH (at 0x12012)"
        set &access:&cmd_addr %l (0x8020120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_LOW"
      sgroup "S5_CTRL_INT_POLARITY_LOW (at 0x12013)"
        set &access:&cmd_addr %l (0x8020130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_CLR"
      sgroup "S5_CTRL_INT_LATCHED_CLR (at 0x12014)"
        set &access:&cmd_addr %l (0x8020140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_EN_SET"
      sgroup "S5_CTRL_INT_EN_SET (at 0x12015)"
        set &access:&cmd_addr %l (0x8020150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_EN_CLR"
      sgroup "S5_CTRL_INT_EN_CLR (at 0x12016)"
        set &access:&cmd_addr %l (0x8020160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_STS"
      sgroup "S5_CTRL_INT_LATCHED_STS (at 0x12018)"
        set &access:&cmd_addr %l (0x8020180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_PENDING_STS"
      sgroup "S5_CTRL_INT_PENDING_STS (at 0x12019)"
        set &access:&cmd_addr %l (0x8020190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0 (LIMIT_ERR_INT_FALSE),1 (LIMIT_ERR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0 (VREG_OK_INT_FALSE),1 (VREG_OK_INT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_MID_SEL"
      sgroup "S5_CTRL_INT_MID_SEL (at 0x1201a)"
        set &access:&cmd_addr %l (0x80201a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x201a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S5_CTRL_INT_PRIORITY"
      sgroup "S5_CTRL_INT_PRIORITY (at 0x1201b)"
        set &access:&cmd_addr %l (0x80201b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x201b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL1"
      sgroup "S5_CTRL_VOLTAGE_CTL1 (at 0x12040)"
        set &access:&cmd_addr %l (0x8020400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0 (RANGE_HV_FALSE),1 (RANGE_HV_TRUE)"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL2"
      sgroup "S5_CTRL_VOLTAGE_CTL2 (at 0x12041)"
        set &access:&cmd_addr %l (0x8020410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_PFM_CTL"
      sgroup "S5_CTRL_PFM_CTL (at 0x12044)"
        set &access:&cmd_addr %l (0x8020440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0 (PFM_VOLT_BOOST),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0 (PFM_ADVANCED),1 (PFM_LEGACY)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S5_CTRL_MODE_CTL"
      sgroup "S5_CTRL_MODE_CTL (at 0x12045)"
        set &access:&cmd_addr %l (0x8020450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0 (PWM_NO_FORCE),1 (PWM_FORCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0 (AUTO_FALSE),1 (AUTO_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0 (FOLLOW_PMIC_AWAKE_FALSE),1 (FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S5_CTRL_EN_CTL"
      sgroup "S5_CTRL_EN_CTL (at 0x12046)"
        set &access:&cmd_addr %l (0x8020460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0 (FOLLOW_HWEN3_FALSE),1 (FOLLOW_HWEN3_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0 (FOLLOW_HWEN2_FALSE),1 (FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0 (FOLLOW_HWEN1_FALSE),1 (FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0 (FOLLOW_HWEN0_FALSE),1 (FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S5_CTRL_PD_CTL"
      sgroup "S5_CTRL_PD_CTL (at 0x12048)"
        set &access:&cmd_addr %l (0x8020480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PD_ENABLE_FALSE),1 (PD_ENABLE_TRUE)"
    tree.end
    tree "S5_CTRL_COMP_CAP_CTL"
      sgroup "S5_CTRL_COMP_CAP_CTL (at 0x12051)"
        set &access:&cmd_addr %l (0x8020510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0 (CP_CAP_0PF),1 (CP_CAP_1PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0 (CZ_CAP_30PF),1 (CZ_CAP_40PF),2 (CZ_CAP_50PF),3 (CZ_CAP_60PF)"
    tree.end
    tree "S5_CTRL_GM_CTL"
      sgroup "S5_CTRL_GM_CTL (at 0x12052)"
        set &access:&cmd_addr %l (0x8020520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S5_CTRL_RZ_CTL"
      sgroup "S5_CTRL_RZ_CTL (at 0x12053)"
        set &access:&cmd_addr %l (0x8020530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S5_CTRL_ISNS_CTRL"
      sgroup "S5_CTRL_ISNS_CTRL (at 0x12055)"
        set &access:&cmd_addr %l (0x8020550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0 (SA_COMP_CAP_100FF),1 (SA_COMP_CAP_200FF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0 (ISNS_RES_IOS_8KOHMS_24UA),1 (ISNS_RES_IOS_16KOHMS_12UA)"
    tree.end
    tree "S5_CTRL_SAW_CTL"
      sgroup "S5_CTRL_SAW_CTL (at 0x12056)"
        set &access:&cmd_addr %l (0x8020560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CURRENT_CTRL                             = " "0 (SAW_CURRENT_CTRL_1UA),1 (SAW_CURRENT_CTRL_2UA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NSAW_CTRL                                = " "0 (NSAW_CTRL_4X),1 (NSAW_CTRL_8X),2 (NSAW_CTRL_12X),3 (NSAW_CTRL_16X),4 (NSAW_CTRL_20X),5 (NSAW_CTRL_24X),6 (NSAW_CTRL_28X),7 (NSAW_CTRL_32X)"
    tree.end
    tree "S5_CTRL_DMAX_CTL"
      sgroup "S5_CTRL_DMAX_CTL (at 0x12058)"
        set &access:&cmd_addr %l (0x8020580|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20580|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S5_CTRL_PULSE_SKIP_CTL"
      sgroup "S5_CTRL_PULSE_SKIP_CTL (at 0x12059)"
        set &access:&cmd_addr %l (0x8020590|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20590|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_2CYCLE),1 (PS_TIME_HYST_4CYCLE),2 (PS_TIME_HYST_8CYCLE),3 (PS_TIME_HYST_16CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0 (PSKIP_EXIT_SEL_ERR_AMP),1 (PSKIP_EXIT_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S5_CTRL_PULSE_SKIP_THRES"
      sgroup "S5_CTRL_PULSE_SKIP_THRES (at 0x1205a)"
        set &access:&cmd_addr %l (0x80205a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x205a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0 (PS_VSET_VRSET_450MV_ILOAD_THRESH_25MA),1 (PS_VSET_VRSET_475MV_ILOAD_THRESH_37P5MA),2 (PS_VSET_VRSET_500MV_ILOAD_THRESH_50MA),3 (PS_VSET_VRSET_525MV_ILOAD_THRESH_62P5MA),4 (PS_VSET_VRSET_550MV_ILOAD_THRESH_75MA),5 (PS_VSET_VRSET_575MV_ILOAD_THRESH_87P5MA),6 (PS_VSET_VRSET_600MV_ILOAD_THRESH_100MA),7 (PS_VSET_VRSET_625MV_ILOAD_THRESH_112P5MA)"
    tree.end
    tree "S5_CTRL_AUTO_MODE_CTL"
      sgroup "S5_CTRL_AUTO_MODE_CTL (at 0x1205b)"
        set &access:&cmd_addr %l (0x80205b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x205b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_16CYCLES_ALSO)"
    tree.end
    tree "S5_CTRL_INZERO_COUNT_CTL"
      sgroup "S5_CTRL_INZERO_COUNT_CTL (at 0x1205c)"
        set &access:&cmd_addr %l (0x80205c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x205c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PFM_COUNT_CTL"
      sgroup "S5_CTRL_PFM_COUNT_CTL (at 0x1205d)"
        set &access:&cmd_addr %l (0x80205d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x205d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PS_VGA_CTL"
      sgroup "S5_CTRL_PS_VGA_CTL (at 0x1205e)"
        set &access:&cmd_addr %l (0x80205e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x205e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S5_CTRL_STEPPER_SS_CTL"
      sgroup "S5_CTRL_STEPPER_SS_CTL (at 0x12060)"
        set &access:&cmd_addr %l (0x8020600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_STEPPER_VS_CTL"
      sgroup "S5_CTRL_STEPPER_VS_CTL (at 0x12061)"
        set &access:&cmd_addr %l (0x8020610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0 (STEP_1_LSB),1 (STEP_2_LSB),2 (STEP_4_LSB),3 (STEP_8_LSB)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0 (DELAY_20_CLK_CYCLES),1 (DELAY_40_CLK_CYCLES),2 (DELAY_80_CLK_CYCLES),3 (DELAY_160_CLK_CYCLES),4 (DELAY_320_CLK_CYCLES),5 (DELAY_640_CLK_CYLES),6 (DELAY_1280_CLK_CYCLES),7 (DELAY_2560_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_FT_CTL"
      sgroup "S5_CTRL_FT_CTL (at 0x12062)"
        set &access:&cmd_addr %l (0x8020620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0 (FT_EN_FALSE),1 (FT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0 (GM_BOOST_FALSE),1 (GM_BOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0 (NL_DEAD_ZONE_0A),1 (NL_DEAD_ZONE_0P125A),2 (NL_DEAD_ZONE_0P25A),3 (NL_DEAD_ZONE_0P375A),4 (NL_DEAD_ZONE_0P5A),5 (NL_DEAD_ZONE_0P625A),6 (NL_DEAD_ZONE_0P75A),7 (NL_DEAD_ZONE_0P875A)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0 (NL_CUR_CTL_0A),1 (NL_CUR_CTL_0P125A),2 (NL_CUR_CTL_0P25A),3 (NL_CUR_CTL_0P375A),4 (NL_CUR_CTL_0P5A),5 (NL_CUR_CTL_0P625A),6 (NL_CUR_CTL_0P75A),7 (NL_CUR_CTL_0P875A)"
    tree.end
    tree "S5_CTRL_QMODE_SHADOW"
      sgroup "S5_CTRL_QMODE_SHADOW (at 0x12063)"
        set &access:&cmd_addr %l (0x8020630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S5_CTRL_UL_LL_CTRL"
      sgroup "S5_CTRL_UL_LL_CTRL (at 0x12068)"
        set &access:&cmd_addr %l (0x8020680|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20680|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_INT_EN                                = " "0 (UL_INT_EN_FALSE),1 (UL_INT_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_INT_EN                                = " "0 (LL_INT_EN_FALSE),1 (LL_INT_EN_TRUE)"
    tree.end
    tree "S5_CTRL_UL_VOLTAGE"
      sgroup "S5_CTRL_UL_VOLTAGE (at 0x12069)"
        set &access:&cmd_addr %l (0x8020690|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20690|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_LL_VOLTAGE"
      sgroup "S5_CTRL_LL_VOLTAGE (at 0x1206b)"
        set &access:&cmd_addr %l (0x80206b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x206b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S5_CTRL_CTLR_MISC"
      sgroup "S5_CTRL_CTLR_MISC (at 0x1207a)"
        set &access:&cmd_addr %l (0x80207a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x207a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_SEC_ACCESS"
      sgroup "S5_CTRL_SEC_ACCESS (at 0x120d0)"
        set &access:&cmd_addr %l (0x8020d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL1"
      sgroup "S5_CTRL_PERPH_RESET_CTL1 (at 0x120d8)"
        set &access:&cmd_addr %l (0x8020d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL2"
      sgroup "S5_CTRL_PERPH_RESET_CTL2 (at 0x120d9)"
        set &access:&cmd_addr %l (0x8020d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL3"
      sgroup "S5_CTRL_PERPH_RESET_CTL3 (at 0x120da)"
        set &access:&cmd_addr %l (0x8020da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL4"
      sgroup "S5_CTRL_PERPH_RESET_CTL4 (at 0x120db)"
        set &access:&cmd_addr %l (0x8020db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST1"
      sgroup "S5_CTRL_INT_TEST1 (at 0x120e0)"
        set &access:&cmd_addr %l (0x8020e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST_VAL"
      sgroup "S5_CTRL_INT_TEST_VAL (at 0x120e1)"
        set &access:&cmd_addr %l (0x8020e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_FALSE),1 (LIMIT_ERR_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S5_CTRL_CTLR_TEST"
      sgroup "S5_CTRL_CTLR_TEST (at 0x120e2)"
        set &access:&cmd_addr %l (0x8020e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_VREF_LOCAL_BUFFER_ATEST2_AVSS),2 (ATEST_SEL_ATEST1_LOOP_FILTER_ATEST2_AVSS),3 (ATEST_SEL_ATEST1_VREF_OUT_ATEST2_AVSS_CLEAN),4 (ATEST_SEL_ATEST1_V_SAWTOOTH_ATEST2_AVDD),5 (ATEST_SEL_ATEST1_PULSE_SKIP_VGA_OUT_ATEST2_VREF_PULSE_SKIP_RESET),6 (ATEST_SEL_ATEST1_SLOPE_COMP_OUT_ATEST2_VREF_PULSE_SKIP_SET),7 (ATEST_SEL_ATEST1_RES_DIV_OUT_ATEST2_BUCK_FB_PAD)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_PWM_CLOCK_DTEST2_CLK_1P2M),2 (DTEST_SEL_DTEST1_PWM_COMP_DTEST2_DVSS),3 (DTEST_SEL_DTEST1_PULSE_SKIP_COMP_DTEST2_IPLIMIT_COMP_PFM),4 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_AUTOPFM_COUNT_DONE),5 (DTEST_SEL_DTEST1_MODE_DTEST2_INZ_COUNT_DONE),6 (DTEST_SEL_DTEST1_PULSE_SKIP_ENTER_DTEST2_PULSE_SKIP_EXIT),7 (DTEST_SEL_DTEST1_PFM_COMP_DTEST2_VDIP_COMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_CTRL_TRIM_NUM"
      sgroup "S5_CTRL_TRIM_NUM (at 0x120f0)"
        set &access:&cmd_addr %l (0x8020f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_CTRL_CTL_TRIM1"
      sgroup "S5_CTRL_CTL_TRIM1 (at 0x120f1)"
        set &access:&cmd_addr %l (0x8020f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S5_CTRL_CTL_TRIM2"
      sgroup "S5_CTRL_CTL_TRIM2 (at 0x120f2)"
        set &access:&cmd_addr %l (0x8020f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S5_CTRL_CTL_TRIM3"
      sgroup "S5_CTRL_CTL_TRIM3 (at 0x120f3)"
        set &access:&cmd_addr %l (0x8020f30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20f30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S5_CTRL_CTL_TRIM4"
      sgroup "S5_CTRL_CTL_TRIM4 (at 0x120f4)"
        set &access:&cmd_addr %l (0x8020f40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x20f40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0 (ACTIVE_PD_OFF),1 (ACTIVE_PD_ON)"
    tree.end
  tree.end
tree.end
tree "S5_FREQ"
  tree "S5_FREQ"
    tree "S5_FREQ_REVISION1"
      sgroup "S5_FREQ_REVISION1 (at 0x12200)"
        set &access:&cmd_addr %l (0x8022000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION2"
      sgroup "S5_FREQ_REVISION2 (at 0x12201)"
        set &access:&cmd_addr %l (0x8022010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_FREQ_PERPH_TYPE"
      sgroup "S5_FREQ_PERPH_TYPE (at 0x12204)"
        set &access:&cmd_addr %l (0x8022040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_FREQ_PERPH_SUBTYPE"
      sgroup "S5_FREQ_PERPH_SUBTYPE (at 0x12205)"
        set &access:&cmd_addr %l (0x8022050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_FREQ_CLK_ENABLE"
      sgroup "S5_FREQ_CLK_ENABLE (at 0x12246)"
        set &access:&cmd_addr %l (0x8022460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S5_FREQ_CLK_DIV"
      sgroup "S5_FREQ_CLK_DIV (at 0x12250)"
        set &access:&cmd_addr %l (0x8022500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S5_FREQ_CLK_PHASE"
      sgroup "S5_FREQ_CLK_PHASE (at 0x12251)"
        set &access:&cmd_addr %l (0x8022510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S5_FREQ_GANG_CTL1"
      sgroup "S5_FREQ_GANG_CTL1 (at 0x122c0)"
        set &access:&cmd_addr %l (0x8022c00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22c00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_FREQ_GANG_CTL2"
      sgroup "S5_FREQ_GANG_CTL2 (at 0x122c1)"
        set &access:&cmd_addr %l (0x8022c10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22c10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S5_FREQ_SEC_ACCESS"
      sgroup "S5_FREQ_SEC_ACCESS (at 0x122d0)"
        set &access:&cmd_addr %l (0x8022d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL2"
      sgroup "S5_FREQ_PERPH_RESET_CTL2 (at 0x122d9)"
        set &access:&cmd_addr %l (0x8022d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL3"
      sgroup "S5_FREQ_PERPH_RESET_CTL3 (at 0x122da)"
        set &access:&cmd_addr %l (0x8022da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL4"
      sgroup "S5_FREQ_PERPH_RESET_CTL4 (at 0x122db)"
        set &access:&cmd_addr %l (0x8022db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S5_FREQ_TEST1"
      sgroup "S5_FREQ_TEST1 (at 0x122e2)"
        set &access:&cmd_addr %l (0x8022e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x22e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S5_PS"
  tree "S5_PS"
    tree "S5_PS_REVISION1"
      sgroup "S5_PS_REVISION1 (at 0x12100)"
        set &access:&cmd_addr %l (0x8021000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION2"
      sgroup "S5_PS_REVISION2 (at 0x12101)"
        set &access:&cmd_addr %l (0x8021010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_PS_REVISION3"
      sgroup "S5_PS_REVISION3 (at 0x12102)"
        set &access:&cmd_addr %l (0x8021020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION4"
      sgroup "S5_PS_REVISION4 (at 0x12103)"
        set &access:&cmd_addr %l (0x8021030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_PS_PERPH_TYPE"
      sgroup "S5_PS_PERPH_TYPE (at 0x12104)"
        set &access:&cmd_addr %l (0x8021040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_PS_PERPH_SUBTYPE"
      sgroup "S5_PS_PERPH_SUBTYPE (at 0x12105)"
        set &access:&cmd_addr %l (0x8021050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S5_PS_PWM_CURRENT_LIM_CTL (at 0x1214a)"
        set &access:&cmd_addr %l (0x80214a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x214a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0 (CURRENT_LIM_AUTOINT_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_AUTOINT_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_AUTOINT_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_AUTOINT_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_AUTOINT_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_AUTOINT_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_AUTOINT_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_AUTOINT_SEL_2X_600MA_3X_700MA)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0 (CURRENT_LIM_PWM_SEL_2X_2700MA_3X_3500MA),1 (CURRENT_LIM_PWM_SEL_2X_2400MA_3X_3100MA),2 (CURRENT_LIM_PWM_SEL_2X_2100MA_3X_2700MA),3 (CURRENT_LIM_PWM_SEL_2X_1800MA_3X_2300MA),4 (CURRENT_LIM_PWM_SEL_2X_1500MA_3X_1900MA),5 (CURRENT_LIM_PWM_SEL_2X_1200MA_3X_1500MA),6 (CURRENT_LIM_PWM_SEL_2X_900MA_3X_1100MA),7 (CURRENT_LIM_PWM_SEL_2X_600MA_3X_700MA)"
    tree.end
    tree "S5_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S5_PS_PFM_CURRENT_LIM_CTL (at 0x1214b)"
        set &access:&cmd_addr %l (0x80214b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x214b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0 (CURRENT_LIM_SEL_600MA),1 (CURRENT_LIM_SEL_540MA),2 (CURRENT_LIM_SEL_480MA),3 (CURRENT_LIM_SEL_420MA),4 (CURRENT_LIM_SEL_360MA),5 (CURRENT_LIM_SEL_300MA),6 (CURRENT_LIM_SEL_240MA),7 (CURRENT_LIM_SEL_180MA)"
    tree.end
    tree "S5_PS_SOFT_START_CTL"
      sgroup "S5_PS_SOFT_START_CTL (at 0x1214c)"
        set &access:&cmd_addr %l (0x80214c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x214c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0 (SOFT_START_ILIM_STEP_EN_FALSE),1 (SOFT_START_ILIM_STEP_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0 (SOFT_START_MODE_SEL_FAST),1 (SOFT_START_MODE_SEL_NORMAL)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0 (SOFT_START_ILIM_SEL_400MA),1 (SOFT_START_ILIM_SEL_600MA),2 (SOFT_START_ILIM_SEL_800MA),3 (SOFT_START_ILIM_SEL_1000MA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0 (SOFT_START_ILIM_STEP_DLY_FAST_20US_NORMAL_40US),1 (SOFT_START_ILIM_STEP_DLY_FAST_40US_NORMAL_80US)"
    tree.end
    tree "S5_PS_SWITCH_SIZE_CTL"
      sgroup "S5_PS_SWITCH_SIZE_CTL (at 0x12170)"
        set &access:&cmd_addr %l (0x8021700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_DIV_8),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_DIV_8),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S5_PS_DEAD_TIME_CTRL1"
      sgroup "S5_PS_DEAD_TIME_CTRL1 (at 0x12171)"
        set &access:&cmd_addr %l (0x8021710|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21710|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0 (DIG_DEADTIME_CTRL_DISABLE),1 (DIG_DEADTIME_CTRL_1_NS),2 (DIG_DEADTIME_CTRL_1P5_NS),3 (DIG_DEADTIME_CTRL_2P5_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0 (ANA_DEADTIME_CTRL_DISABLE),1 (ANA_DEADTIME_CTRL_ENABLE)"
    tree.end
    tree "S5_PS_DEAD_TIME_CTRL2"
      sgroup "S5_PS_DEAD_TIME_CTRL2 (at 0x12172)"
        set &access:&cmd_addr %l (0x8021720|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21720|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0 (EN_PSW_DEAD_TIME_DISABLE),1 (EN_PSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0 (EN_NSW_DEAD_TIME_DISABLE),1 (EN_NSW_DEAD_TIME_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S5_PS_BLNK_TIME_CTL"
      sgroup "S5_PS_BLNK_TIME_CTL (at 0x12173)"
        set &access:&cmd_addr %l (0x8021730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S5_PS_INZERO_CTL"
      sgroup "S5_PS_INZERO_CTL (at 0x12174)"
        set &access:&cmd_addr %l (0x8021740|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21740|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S5_PS_DIG_FSM_CTL"
      sgroup "S5_PS_DIG_FSM_CTL (at 0x12175)"
        set &access:&cmd_addr %l (0x8021750|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21750|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0 (FSM_SEL_FMS2),1 (FSM_SEL_FMS1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0 (FSM_CTL4_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL4_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0 (FSM_CTL3_DISABLE_PULSE_FILTER_COMP1),1 (FSM_CTL3_ENABLE_PULSE_FILTER_COMP1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0 (FSM_CTL2_DISABLE_PULSE_FILTER_COMP2),1 (FSM_CTL2_ENABLE_PULSE_FILTER_COMP2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0 (FSM_CTL1_DISABLE_PULSE_FILTER_INZERO_PS_COMP),1 (FMS_CTL1_ENABLE_PULSE_FILTER_INZERO_PS_COMP)"
    tree.end
    tree "S5_PS_PWR_STG_MISC"
      sgroup "S5_PS_PWR_STG_MISC (at 0x12179)"
        set &access:&cmd_addr %l (0x8021790|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21790|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0 (ISNS_RATIO_54P4K),1 (ISNS_RATIO_27P2K)"
    tree.end
    tree "S5_PS_SEC_ACCESS"
      sgroup "S5_PS_SEC_ACCESS (at 0x121d0)"
        set &access:&cmd_addr %l (0x8021d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_PS_PERPH_RESET_CTL2"
      sgroup "S5_PS_PERPH_RESET_CTL2 (at 0x121d9)"
        set &access:&cmd_addr %l (0x8021d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL3"
      sgroup "S5_PS_PERPH_RESET_CTL3 (at 0x121da)"
        set &access:&cmd_addr %l (0x8021da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL4"
      sgroup "S5_PS_PERPH_RESET_CTL4 (at 0x121db)"
        set &access:&cmd_addr %l (0x8021db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S5_PS_FORCE_FET_TEST"
      sgroup "S5_PS_FORCE_FET_TEST (at 0x121e3)"
        set &access:&cmd_addr %l (0x8021e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S5_PS_PWR_STG_TEST"
      sgroup "S5_PS_PWR_STG_TEST (at 0x121e4)"
        set &access:&cmd_addr %l (0x8021e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0 (ATEST_SEL_ATEST1_NORMAL_ATEST2_NORMAL),1 (ATEST_SEL_ATEST1_RESERVED1_ATEST2_RESERVED1),2 (ATEST_SEL_ATEST1_RESERVED2_ATEST2_RESERVED2),3 (ATEST_SEL_ATEST1_RESERVED3_ATEST2_RESERVED3),4 (ATEST_SEL_ATEST1_RESERVED4_ATEST2_RESERVED4),5 (ATEST_SEL_ATEST1_RESERVED5_ATEST2_RESERVED5),6 (ATEST_SEL_ATEST1_KELVIN_SENSE1_ATEST2_KELVIN_SENSE2),7 (ATEST_SEL_ATEST1_RESERVED7_ATEST2_RESERVED7)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0 (DTEST_SEL_DTEST1_NORMAL_DTEST2_NORMAL),1 (DTEST_SEL_DTEST1_END_MIN_PON_DTEST2_FSM_STATE_0),2 (DTEST_SEL_DTEST1_IPLIMIT_TIMER1_DTEST2_FSM_STATE_1),3 (DTEST_SEL_DTEST1_IPLIMIT_TIMER2_DTEST2_FSM_STATE_2),4 (DTEST_SEL_DTEST1_INZERO_COMP_NMOS_DTEST2_FSM_STATE_3),5 (DTEST_SEL_DTEST1_IPLIMIT_COMP_PMOS_DTEST2_FSM_STATE_4),6 (DTEST_SEL_DTEST1_PMOS_DRIVE_SIGNAL_DTEST2_PGATE_BLANKING_PMOS),7 (DTEST_SEL_DTEST1_NMOS_DRIVE_SIGNAL_DTEST2_INZERO_COMP_EXTEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_PS_TRIM_NUM"
      sgroup "S5_PS_TRIM_NUM (at 0x121f0)"
        set &access:&cmd_addr %l (0x8021f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_PS_PS_TRIM1"
      sgroup "S5_PS_PS_TRIM1 (at 0x121f1)"
        set &access:&cmd_addr %l (0x8021f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S5_PS_PS_TRIM2"
      sgroup "S5_PS_PS_TRIM2 (at 0x121f2)"
        set &access:&cmd_addr %l (0x8021f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x21f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SLEEP_CLK1"
  tree "SLEEP_CLK1"
    tree "SLEEP_CLK1_REVISION1"
      sgroup "SLEEP_CLK1_REVISION1 (at 0x5a00)"
        set &access:&cmd_addr %l (0x805a000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SLEEP_CLK1_REVISION2"
      sgroup "SLEEP_CLK1_REVISION2 (at 0x5a01)"
        set &access:&cmd_addr %l (0x805a010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SLEEP_CLK1_PERPH_TYPE"
      sgroup "SLEEP_CLK1_PERPH_TYPE (at 0x5a04)"
        set &access:&cmd_addr %l (0x805a040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SLEEP_CLK1_PERPH_SUBTYPE"
      sgroup "SLEEP_CLK1_PERPH_SUBTYPE (at 0x5a05)"
        set &access:&cmd_addr %l (0x805a050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SLEEP_CLK1_STATUS1"
      sgroup "SLEEP_CLK1_STATUS1 (at 0x5a08)"
        set &access:&cmd_addr %l (0x805a080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_OK                               = " "0 (SLP_CLK_BUFFER_OFF),1 (SLP_CLK_BUFFER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLP_CLK_SOURCE                           = " "0 (XO_32K),1 (EXT_32K),2 (CALRC),3 (LFRC),4 (RC19M_DIV),5 (XO19M_DIV),6 (RESERVED),7 (reserved)"
    tree.end
    tree "SLEEP_CLK1_INT_RT_STS"
      sgroup "SLEEP_CLK1_INT_RT_STS (at 0x5a10)"
        set &access:&cmd_addr %l (0x805a100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_RT_STS                    = " "0 (XO32K_NOT_HALT),1 (XO32K_HALT)"
    tree.end
    tree "SLEEP_CLK1_INT_SET_TYPE"
      sgroup "SLEEP_CLK1_INT_SET_TYPE (at 0x5a11)"
        set &access:&cmd_addr %l (0x805a110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_HIGH"
      sgroup "SLEEP_CLK1_INT_POLARITY_HIGH (at 0x5a12)"
        set &access:&cmd_addr %l (0x805a120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_POLARITY_LOW"
      sgroup "SLEEP_CLK1_INT_POLARITY_LOW (at 0x5a13)"
        set &access:&cmd_addr %l (0x805a130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_CLR"
      sgroup "SLEEP_CLK1_INT_LATCHED_CLR (at 0x5a14)"
        set &access:&cmd_addr %l (0x805a140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_EN_SET"
      sgroup "SLEEP_CLK1_INT_EN_SET (at 0x5a15)"
        set &access:&cmd_addr %l (0x805a150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_EN_CLR"
      sgroup "SLEEP_CLK1_INT_EN_CLR (at 0x5a16)"
        set &access:&cmd_addr %l (0x805a160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_INT_LATCHED_STS"
      sgroup "SLEEP_CLK1_INT_LATCHED_STS (at 0x5a18)"
        set &access:&cmd_addr %l (0x805a180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "SLEEP_CLK1_INT_PENDING_STS"
      sgroup "SLEEP_CLK1_INT_PENDING_STS (at 0x5a19)"
        set &access:&cmd_addr %l (0x805a190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "SLEEP_CLK1_INT_MID_SEL"
      sgroup "SLEEP_CLK1_INT_MID_SEL (at 0x5a1a)"
        set &access:&cmd_addr %l (0x805a1a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a1a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SLEEP_CLK1_INT_PRIORITY"
      sgroup "SLEEP_CLK1_INT_PRIORITY (at 0x5a1b)"
        set &access:&cmd_addr %l (0x805a1b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a1b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SLEEP_CLK1_DRV_CTL1"
      sgroup "SLEEP_CLK1_DRV_CTL1 (at 0x5a44)"
        set &access:&cmd_addr %l (0x805a440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "SLEEP_CLK1_HALT_CTL"
      sgroup "SLEEP_CLK1_HALT_CTL (at 0x5a45)"
        set &access:&cmd_addr %l (0x805a450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_HALT_EN                            = " "0 (XO32K_HALT_DISABLED),1 (XO32K_HALT_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO32K_OSC_HALT                     = " "0 (XO32K_HALT_NOT_FORCED),1 (XO32K_HALT_FORCED)"
    tree.end
    tree "SLEEP_CLK1_EN_CTL"
      sgroup "SLEEP_CLK1_EN_CTL (at 0x5a46)"
        set &access:&cmd_addr %l (0x805a460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_PAD_EN                           = " "0 (SLP_CLK_BUF_DISABLED),1 (SLP_CLK_BUF_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_SMPL_CTL1"
      sgroup "SLEEP_CLK1_SMPL_CTL1 (at 0x5a48)"
        set &access:&cmd_addr %l (0x805a480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SMPL_EN                                  = " "0 (SMPL_DISABLE),1 (SMPL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_SEL                              = " "0 (SHUTDOWN2_RB_TRIGGER),1 (PON_RB_TRIGGER)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SMPL_DELAY                               = " "0 (HALF_SEC),1 (ONE_SEC),2 (ONEANDHALF_SEC),3 (TWO_SEC)"
    tree.end
    tree "SLEEP_CLK1_SLPSRC_CTL1"
      sgroup "SLEEP_CLK1_SLPSRC_CTL1 (at 0x5a49)"
        set &access:&cmd_addr %l (0x805a490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO32K_EN                                 = " "0 (XO32K_DISABLED),1 (XO32K_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_OSC_SEL2I                          = " "0 (NORMAL_CURRENT),1 (MORE_CURRENT)"
    tree.end
    tree "SLEEP_CLK1_LFRC_CTL"
      sgroup "SLEEP_CLK1_LFRC_CTL (at 0x5a57)"
        set &access:&cmd_addr %l (0x805a570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   CLKS_XVDD_BLEED                          = " "0 (NA_0),1 (NA_200),2 (reserved),3 (NA_600),4 (reserved),5 (reserved),6 (reserved),7 (NA_1600)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC1"
      sgroup "SLEEP_CLK1_CAL_RC1 (at 0x5a58)"
        set &access:&cmd_addr %l (0x805a580|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a580|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CAL_FREQ_RTC_DEFAULT                     = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC2"
      sgroup "SLEEP_CLK1_CAL_RC2 (at 0x5a59)"
        set &access:&cmd_addr %l (0x805a590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DRIFT_LMT_RTC                            = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC3"
      sgroup "SLEEP_CLK1_CAL_RC3 (at 0x5a5a)"
        set &access:&cmd_addr %l (0x805a5a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a5a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_BATT                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC4"
      sgroup "SLEEP_CLK1_CAL_RC4 (at 0x5a5b)"
        set &access:&cmd_addr %l (0x805a5b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a5b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CALRC_EN                                 = " "0 (CALRC_DISABLED),1 (CALRC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   COINCELL_GOOD                            = " "0 (WEAK_COINCAP),1 (STRONG_COINCAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LFRC_DRIFT_DET_EN_COIN                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_DTEST_EN                           = " "0 (NORMAL),1 (CALRC_STATE_ON_DTEST)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC5"
      sgroup "SLEEP_CLK1_CAL_RC5 (at 0x5a5c)"
        set &access:&cmd_addr %l (0x805a5c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5a5c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MIN_XO_COUNT_LMT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_XO_COUNT_LMT                         = "
    tree.end
    tree "SLEEP_CLK1_SEC_ACCESS"
      sgroup "SLEEP_CLK1_SEC_ACCESS (at 0x5ad0)"
        set &access:&cmd_addr %l (0x805ad00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ad00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL1"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL1 (at 0x5ad8)"
        set &access:&cmd_addr %l (0x805ad80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ad80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL2"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL2 (at 0x5ad9)"
        set &access:&cmd_addr %l (0x805ad90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ad90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL3"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL3 (at 0x5ada)"
        set &access:&cmd_addr %l (0x805ada0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ada0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL4"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL4 (at 0x5adb)"
        set &access:&cmd_addr %l (0x805adb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5adb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL5"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL5 (at 0x5adc)"
        set &access:&cmd_addr %l (0x805adc0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5adc0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL6"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL6 (at 0x5add)"
        set &access:&cmd_addr %l (0x805add0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5add0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SLEEP_CLK1_INT_TEST1"
      sgroup "SLEEP_CLK1_INT_TEST1 (at 0x5ae0)"
        set &access:&cmd_addr %l (0x805ae00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ae00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "SLEEP_CLK1_INT_TEST_VAL"
      sgroup "SLEEP_CLK1_INT_TEST_VAL (at 0x5ae1)"
        set &access:&cmd_addr %l (0x805ae10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ae10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_HALT_DET_TEST_VAL                  = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "SLEEP_CLK1_TEST1"
      sgroup "SLEEP_CLK1_TEST1 (at 0x5ae2)"
        set &access:&cmd_addr %l (0x805ae20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x5ae20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SMPL_TRIGGER_SEL                         = " "0 (HIZ),1 (CONNECT_TO_DTEST)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CXVDD_ATEST_EN                           = " "0 (HIZ),1 (CONNECT_TO_ATEST)"
    tree.end
  tree.end
tree.end
tree "SMBBP_BAT_IF"
  tree "SMBBP_BAT_IF"
    tree "SMBBP_BAT_IF_PERPH_TYPE"
      sgroup "SMBBP_BAT_IF_PERPH_TYPE (at 0x1204)"
        set &access:&cmd_addr %l (0x8012040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBBP_BAT_IF_PERPH_SUBTYPE"
      sgroup "SMBBP_BAT_IF_PERPH_SUBTYPE (at 0x1205)"
        set &access:&cmd_addr %l (0x8012050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBBP_BAT_IF_BAT_PRES_STATUS"
      sgroup "SMBBP_BAT_IF_BAT_PRES_STATUS (at 0x1208)"
        set &access:&cmd_addr %l (0x8012080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_PRES                                 = " "0 (BATTERY_GONE),1 (BATTERY_PRESENT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_REMOVED_OFFMODE                      = " "0 (BATTERY_NEVER_REMOVED),1 (BATTERY_WAS_REMOVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_THM_PRES                             = " "0 (BAT_THM_GONE),1 (BAT_THM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_ID_PRES                              = " "0 (BAT_ID_GONE),1 (BAT_ID_PRESENT)"
    tree.end
    tree "SMBBP_BAT_IF_BAT_TEMP_STATUS"
      sgroup "SMBBP_BAT_IF_BAT_TEMP_STATUS (at 0x1209)"
        set &access:&cmd_addr %l (0x8012090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   BAT_TEMP                                 = " "0 (BAT_TEMP_TOO_COLD),1 (BAT_TEMP_TOO_HOT),2 (BAT_TEMP_OK),3 (reserved)"
    tree.end
    tree "SMBBP_BAT_IF_VREF_BAT_THM_STATUS"
      sgroup "SMBBP_BAT_IF_VREF_BAT_THM_STATUS (at 0x120a)"
        set &access:&cmd_addr %l (0x80120a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x120a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_BAT_THM_ON                          = " "0 (VREF_BAT_THM_OFF),1 (VREF_BAT_THM_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOURCE_AVDD                              = " "0 (NO),1 (YES)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOURCE_VADC                              = " "0 (NO),1 (YES)"
    tree.end
    tree "SMBBP_BAT_IF_BAT_FET_STATUS"
      sgroup "SMBBP_BAT_IF_BAT_FET_STATUS (at 0x120b)"
        set &access:&cmd_addr %l (0x80120b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x120b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_FET_ON                               = " "0 (BAT_FET_OFF),1 (BAT_FET_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_FET_CP_MODE                          = " "0 (BFCP_OFF),1 (BFCP_ON_LPM),2 (BFCP_ON_NPM),3 (BFCP_ON_HPM)"
    tree.end
    tree "SMBBP_BAT_IF_VCP_STATUS"
      sgroup "SMBBP_BAT_IF_VCP_STATUS (at 0x120c)"
        set &access:&cmd_addr %l (0x80120c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x120c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VCP_ON                                   = " "0 (VCP_OFF),1 (VCP_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VCP_DET_COMP                             = " "0 (VCP_NOT_NEEDED),1 (VCP_NEEDED)"
    tree.end
    tree "SMBBP_BAT_IF_INT_RT_STS"
      sgroup "SMBBP_BAT_IF_INT_RT_STS (at 0x1210)"
        set &access:&cmd_addr %l (0x8012100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_RT_STS                            = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_RT_STS                        = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "SMBBP_BAT_IF_INT_SET_TYPE"
      sgroup "SMBBP_BAT_IF_INT_SET_TYPE (at 0x1211)"
        set &access:&cmd_addr %l (0x8012110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_SET_TYPE                          = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_SET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_SET_TYPE                        = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SMBBP_BAT_IF_INT_POLARITY_HIGH"
      sgroup "SMBBP_BAT_IF_INT_POLARITY_HIGH (at 0x1212)"
        set &access:&cmd_addr %l (0x8012120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_POLARITY_HIGH                     = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_POLARITY_HIGH                 = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_POLARITY_HIGH                   = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_INT_POLARITY_LOW"
      sgroup "SMBBP_BAT_IF_INT_POLARITY_LOW (at 0x1213)"
        set &access:&cmd_addr %l (0x8012130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_POLARITY_LOW                      = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_POLARITY_LOW                  = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_POLARITY_LOW                    = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_INT_LATCHED_CLR"
      sgroup "SMBBP_BAT_IF_INT_LATCHED_CLR (at 0x1214)"
        set &access:&cmd_addr %l (0x8012140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_INT_EN_SET"
      sgroup "SMBBP_BAT_IF_INT_EN_SET (at 0x1215)"
        set &access:&cmd_addr %l (0x8012150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_EN_SET                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_INT_EN_CLR"
      sgroup "SMBBP_BAT_IF_INT_EN_CLR (at 0x1216)"
        set &access:&cmd_addr %l (0x8012160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_EN_CLR                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_INT_LATCHED_STS"
      sgroup "SMBBP_BAT_IF_INT_LATCHED_STS (at 0x1218)"
        set &access:&cmd_addr %l (0x8012180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "SMBBP_BAT_IF_INT_PENDING_STS"
      sgroup "SMBBP_BAT_IF_INT_PENDING_STS (at 0x1219)"
        set &access:&cmd_addr %l (0x8012190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_PRES_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "SMBBP_BAT_IF_INT_MID_SEL"
      sgroup "SMBBP_BAT_IF_INT_MID_SEL (at 0x121a)"
        set &access:&cmd_addr %l (0x80121a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x121a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SMBBP_BAT_IF_INT_PRIORITY"
      sgroup "SMBBP_BAT_IF_INT_PRIORITY (at 0x121b)"
        set &access:&cmd_addr %l (0x80121b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x121b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SMBBP_BAT_IF_VCP"
      sgroup "SMBBP_BAT_IF_VCP (at 0x1247)"
        set &access:&cmd_addr %l (0x8012470|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12470|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0 (VCP_DISABLED),1 (VCP_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_BPD_CTRL"
      sgroup "SMBBP_BAT_IF_BPD_CTRL (at 0x1248)"
        set &access:&cmd_addr %l (0x8012480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BPD_OFFMODE_EN                           = " "0 (BPD_OFFMODE_DISABLED),1 (BPD_OFFMODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATID_BATTHM_B_SEL                       = " "0 (BAT_THM),1 (BAT_ID)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_THM_EN                               = " "0 (BPD_BAT_THM_DISABLED),1 (BPD_BAT_THM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_ID_EN                                = " "0 (BPD_BAT_ID_DISABLED),1 (BPD_BAT_ID_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_BTC_CTRL"
      sgroup "SMBBP_BAT_IF_BTC_CTRL (at 0x1249)"
        set &access:&cmd_addr %l (0x8012490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TEMP_COMP_EN                         = " "0 (BTC_DISABLED),1 (BTC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_COLD_THD                        = " "0 (COLD_THD_70_PCT),1 (COLD_THD_80_PCT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_HOT_THD                         = " "0 (HOT_THD_25_PCT),1 (HOT_THD_35_PCT)"
    tree.end
    tree "SMBBP_BAT_IF_VREF_BAT_THM_CTRL"
      sgroup "SMBBP_BAT_IF_VREF_BAT_THM_CTRL (at 0x124a)"
        set &access:&cmd_addr %l (0x80124a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x124a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   EN                                       = " "0 (VREF_BAT_THM_DISABLED),1 (reserved),2 (VREF_BAT_THM_ENABLED_FSM),3 (VREF_BAT_THM_FORCED_ON)"
    tree.end
    tree "SMBBP_BAT_IF_VBAT_DISCHG"
      sgroup "SMBBP_BAT_IF_VBAT_DISCHG (at 0x124e)"
        set &access:&cmd_addr %l (0x80124e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x124e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (PM8026_ONLY_VBAT_DISCHG_DISABLED),1 (PM8026_ONLY_VBAT_DISCHG_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_BAT_REMOVED_OFFMODE"
      sgroup "SMBBP_BAT_IF_BAT_REMOVED_OFFMODE (at 0x124f)"
        set &access:&cmd_addr %l (0x80124f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x124f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLR                                      = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_BATFET_CTRL1"
      sgroup "SMBBP_BAT_IF_BATFET_CTRL1 (at 0x1290)"
        set &access:&cmd_addr %l (0x8012900|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12900|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CNST_RDS_EN                              = " "0 (CNST_RDS_DISABLED),1 (CNST_RDS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   INTEG_COMP_EN                            = " "0 (INTEG_COMP_DISABLED),1 (INTEG_COMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RDS_BIAS_CTRL                            = " "0 (RDS_BIAS_4UA),1 (RDS_BIAS_6UA),2 (RDS_BIAS_8UA),3 (RDS_BIAS_10UA)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CP_BIAS                                  = " "0 (CP_BIAS_0UA),1 (CP_BIAS_0P1UA),2 (CP_BIAS_1P1UA),3 (CP_BIAS_2P1UA)"
    tree.end
    tree "SMBBP_BAT_IF_BATFET_CTRL2"
      sgroup "SMBBP_BAT_IF_BATFET_CTRL2 (at 0x1291)"
        set &access:&cmd_addr %l (0x8012910|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12910|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_COMP_EN                             = " "0 (TEMP_COMP_DISABLED),1 (TEMP_COMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TEMP_CTRL                                = " "0 (TEMP_COMP_1X),1 (TEMP_COMP_2X),2 (TEMP_COMP_3X),3 (TEMP_COMP_4X)"
    tree.end
    tree "SMBBP_BAT_IF_BATFET_CTRL3"
      sgroup "SMBBP_BAT_IF_BATFET_CTRL3 (at 0x1292)"
        set &access:&cmd_addr %l (0x8012920|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12920|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BF_PDRV                                  = " "0 (PFET_50OHM),1 (PFET_10OHM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VG_DISCHG_LNG_DLY                        = " "0 (VG_DISCHG_1US),1 (VG_DISCHG_10US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CP_VGS_SEL                               = " "0 (BFCP_VGS_5P5V),1 (BFCP_VGS_6P0V),2 (BFCP_VGS_6P5V),3 (BFCP_VGS_7P0V)"
    tree.end
    tree "SMBBP_BAT_IF_BATFET_CTRL4"
      sgroup "SMBBP_BAT_IF_BATFET_CTRL4 (at 0x1293)"
        set &access:&cmd_addr %l (0x8012930|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12930|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATFET_SLEEP_ULTRA_LOW_POWER_ENABLE      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATFET_SLEEP_BMS_SNS_NPM_ENABLE          = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_BFCP_CLK_CTRL1"
      sgroup "SMBBP_BAT_IF_BFCP_CLK_CTRL1 (at 0x1294)"
        set &access:&cmd_addr %l (0x8012940|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12940|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HP_CLK_SEL                               = " "0 (HPM_CLK_1P2MHZ),1 (HPM_CLK_19P2MHZ)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HP_CP_CTRL                               = " "0 (HPM_CLK_DIV_1),1 (HPM_CLK_DIV_2),2 (HPM_CLK_DIV_4),3 (HPM_CLK_DIV_8)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NP_CLK_SEL                               = " "0 (NPM_CLK_1P2MHZ),1 (NPM_CLK_19P2MHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   NP_CP_CTRL                               = " "0 (NPM_CLK_DIV_1),1 (NPM_CLK_DIV_2),2 (NPM_CLK_DIV_4),3 (NPM_CLK_DIV_8)"
    tree.end
    tree "SMBBP_BAT_IF_BFCP_CLK_CTRL2"
      sgroup "SMBBP_BAT_IF_BFCP_CLK_CTRL2 (at 0x1295)"
        set &access:&cmd_addr %l (0x8012950|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12950|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LP_CLK_SEL                               = " "0 (LPM_CLK_1P2MHZ),1 (LPM_CLK_32KHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INTEG_CLK_CTRL                           = " "0 (CLK_100KHZ),1 (CLK_50KHZ),2 (CLK_25KHZ),3 (CLK_12P5KHZ)"
    tree.end
    tree "SMBBP_BAT_IF_NFC_OFFMODE"
      sgroup "SMBBP_BAT_IF_NFC_OFFMODE (at 0x1296)"
        set &access:&cmd_addr %l (0x8012960|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12960|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (N_BFET_OFF_DURING_PMIC_OFF),1 (N_BFET_ON_DURING_PMIC_OFF)"
    tree.end
    tree "SMBBP_BAT_IF_SEC_ACCESS"
      sgroup "SMBBP_BAT_IF_SEC_ACCESS (at 0x12d0)"
        set &access:&cmd_addr %l (0x8012d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBBP_BAT_IF_PERPH_RESET_CTL2"
      sgroup "SMBBP_BAT_IF_PERPH_RESET_CTL2 (at 0x12d9)"
        set &access:&cmd_addr %l (0x8012d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_PERPH_RESET_CTL3"
      sgroup "SMBBP_BAT_IF_PERPH_RESET_CTL3 (at 0x12da)"
        set &access:&cmd_addr %l (0x8012da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_PERPH_RESET_CTL4"
      sgroup "SMBBP_BAT_IF_PERPH_RESET_CTL4 (at 0x12db)"
        set &access:&cmd_addr %l (0x8012db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_BAT_IF_PERPH_RESET_CTL5"
      sgroup "SMBBP_BAT_IF_PERPH_RESET_CTL5 (at 0x12dc)"
        set &access:&cmd_addr %l (0x8012dc0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12dc0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_PERPH_RESET_CTL6"
      sgroup "SMBBP_BAT_IF_PERPH_RESET_CTL6 (at 0x12dd)"
        set &access:&cmd_addr %l (0x8012dd0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12dd0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_BAT_IF_BAT_IF_SPARE"
      sgroup "SMBBP_BAT_IF_BAT_IF_SPARE (at 0x12df)"
        set &access:&cmd_addr %l (0x8012df0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12df0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBBP_BAT_IF_INT_TEST1"
      sgroup "SMBBP_BAT_IF_INT_TEST1 (at 0x12e0)"
        set &access:&cmd_addr %l (0x8012e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SMBBP_BAT_IF_INT_TEST_VAL"
      sgroup "SMBBP_BAT_IF_INT_TEST_VAL (at 0x12e1)"
        set &access:&cmd_addr %l (0x8012e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_ON_INT_VAL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_FET_ON_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_OK_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_PRES_INT_VAL                        = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_BAT_IF_TEST1"
      sgroup "SMBBP_BAT_IF_BAT_IF_TEST1 (at 0x12e2)"
        set &access:&cmd_addr %l (0x8012e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BPD_OFFMODE_SPEEDUP                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ATEST                                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   DTEST                                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RDS_TEST                                 = " "0 (RDS_TEST_DISABLED_FULL_BATFET),1 (RDS_TEST_ENABLED_1_10TH_BATFET)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HP_CLK_TM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VCP_OFF_BLANK_EN                         = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_BAT_IF_TEST2"
      sgroup "SMBBP_BAT_IF_BAT_IF_TEST2 (at 0x12e3)"
        set &access:&cmd_addr %l (0x8012e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FORCE_BAT_FET                            = " "0 (NO_FORCE_FSM_CONTROL),1 (reserved),2 (FORCE_OFF),3 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   FORCE_PW_EN                              = " "0 (NO_FORCE_FSM_CONTROL),1 (reserved),2 (FORCE_P_BFET_OFF),3 (FORCE_P_BFET_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FORCE_CP_PM                              = " "0 (NO_FORCE_FSM_CONTROL),1 (FORCE_LPM),2 (FORCE_NPM),3 (FORCE_HPM)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_CP_EN                              = " "0 (NO_FORCE_FSM_CONTROL),1 (reserved),2 (FORCE_OFF),3 (FORCE_ON)"
    tree.end
    tree "SMBBP_BAT_IF_BAT_IF_TEST3"
      sgroup "SMBBP_BAT_IF_BAT_IF_TEST3 (at 0x12e4)"
        set &access:&cmd_addr %l (0x8012e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FORCE_VCP_EN                             = " "0 (NO_FORCE_FSM_CONTROL),1 (reserved),2 (FORCE_OFF),3 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   FORCE_VCP_DET                            = " "0 (NO_FORCE_FSM_CONTROL),1 (reserved),2 (FORCE_LOW),3 (FORCE_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCP_DET_EN_MASK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VPH_PWR_OK_FORCE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BMS_SIGN_VCP_TERM_EN                     = " "0, 1"
    tree.end
    tree "SMBBP_BAT_IF_COMP_OVR0"
      sgroup "SMBBP_BAT_IF_COMP_OVR0 (at 0x12e5)"
        set &access:&cmd_addr %l (0x8012e50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   VCP_DET                                  = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BAT_TOO_COLD                             = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BAT_TOO_HOT                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_GONE                                 = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_BAT_IF_COMP_OVR1"
      sgroup "SMBBP_BAT_IF_COMP_OVR1 (at 0x12e6)"
        set &access:&cmd_addr %l (0x8012e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BPD_OFFMODE_COMP                         = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_XOADC                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_BAT_IF_BAT_IF_COMP_OVR_GLOBAL"
      sgroup "SMBBP_BAT_IF_BAT_IF_COMP_OVR_GLOBAL (at 0x12e7)"
        set &access:&cmd_addr %l (0x8012e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
    tree "SMBBP_BAT_IF_BF_TRIM_NUM"
      sgroup "SMBBP_BAT_IF_BF_TRIM_NUM (at 0x12f0)"
        set &access:&cmd_addr %l (0x8012f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBBP_BAT_IF_TRIM_CNST_RDS"
      sgroup "SMBBP_BAT_IF_TRIM_CNST_RDS (at 0x12f1)"
        set &access:&cmd_addr %l (0x8012f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x12f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CNST_RDS_TRIM                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SEG_CTRL_TRIM                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SMBBP_BOOST"
  tree "SMBBP_BOOST"
    tree "SMBBP_BOOST_PERPH_TYPE"
      sgroup "SMBBP_BOOST_PERPH_TYPE (at 0x1504)"
        set &access:&cmd_addr %l (0x8015040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBBP_BOOST_PERPH_SUBTYPE"
      sgroup "SMBBP_BOOST_PERPH_SUBTYPE (at 0x1505)"
        set &access:&cmd_addr %l (0x8015050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBBP_BOOST_STATUS"
      sgroup "SMBBP_BOOST_STATUS (at 0x1508)"
        set &access:&cmd_addr %l (0x8015080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BOOST_PWR_OK                             = " "0 (BOOST_PWR_NOK),1 (BOOST_PWR_OK)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ISL_DETECTED                             = " "0 (BOOST_VSET_LL_UL_NOK),1 (BOOST_VSET_LL_UL_OK)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0 (BOOST_VSET_UL_NOK),1 (BOOST_VSET_UL_OK)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0 (BOOST_VSET_LL_NOK),1 (BOOST_VSET_LL_OK)"
    tree.end
    tree "SMBBP_BOOST_INT_RT_STS"
      sgroup "SMBBP_BOOST_INT_RT_STS (at 0x1510)"
        set &access:&cmd_addr %l (0x8015100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_RT_STS                      = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "SMBBP_BOOST_INT_SET_TYPE"
      sgroup "SMBBP_BOOST_INT_SET_TYPE (at 0x1511)"
        set &access:&cmd_addr %l (0x8015110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_TYPE                        = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SMBBP_BOOST_INT_POLARITY_HIGH"
      sgroup "SMBBP_BOOST_INT_POLARITY_HIGH (at 0x1512)"
        set &access:&cmd_addr %l (0x8015120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_HIGH                        = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_INT_POLARITY_LOW"
      sgroup "SMBBP_BOOST_INT_POLARITY_LOW (at 0x1513)"
        set &access:&cmd_addr %l (0x8015130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_LOW                         = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_INT_LATCHED_CLR"
      sgroup "SMBBP_BOOST_INT_LATCHED_CLR (at 0x1514)"
        set &access:&cmd_addr %l (0x8015140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_LATCHED_CLR                 = " "0, 1"
    tree.end
    tree "SMBBP_BOOST_INT_EN_SET"
      sgroup "SMBBP_BOOST_INT_EN_SET (at 0x1515)"
        set &access:&cmd_addr %l (0x8015150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_INT_EN_CLR"
      sgroup "SMBBP_BOOST_INT_EN_CLR (at 0x1516)"
        set &access:&cmd_addr %l (0x8015160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_INT_LATCHED_STS"
      sgroup "SMBBP_BOOST_INT_LATCHED_STS (at 0x1518)"
        set &access:&cmd_addr %l (0x8015180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "SMBBP_BOOST_INT_PENDING_STS"
      sgroup "SMBBP_BOOST_INT_PENDING_STS (at 0x1519)"
        set &access:&cmd_addr %l (0x8015190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_OK_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "SMBBP_BOOST_INT_MID_SEL"
      sgroup "SMBBP_BOOST_INT_MID_SEL (at 0x151a)"
        set &access:&cmd_addr %l (0x80151a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x151a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SMBBP_BOOST_INT_PRIORITY"
      sgroup "SMBBP_BOOST_INT_PRIORITY (at 0x151b)"
        set &access:&cmd_addr %l (0x80151b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x151b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SMBBP_BOOST_BOOST_VSET"
      sgroup "SMBBP_BOOST_BOOST_VSET (at 0x1541)"
        set &access:&cmd_addr %l (0x8015410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BOOST_VSET                               = "
    tree.end
    tree "SMBBP_BOOST_ADAPTIVE_BOOST_MODE"
      sgroup "SMBBP_BOOST_ADAPTIVE_BOOST_MODE (at 0x1544)"
        set &access:&cmd_addr %l (0x8015440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADAPTIVE_BOOST_MODE_EN                   = " "0 (BOOST_ADAPTIVE_MODE_DISABLED),1 (BOOST_ADAPTIVE_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_ABM                            = " "0 (IGNORE_HW_ABM),1 (FOLLOW_HW_ABM)"
    tree.end
    tree "SMBBP_BOOST_BOOST_PASS_MODE"
      sgroup "SMBBP_BOOST_BOOST_PASS_MODE (at 0x1545)"
        set &access:&cmd_addr %l (0x8015450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BOOST_PASS_MODE                       = " "0 (BOOST_PASS_MODE_DISABLED),1 (BOOST_PASS_MODE_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_ENABLE_CONTROL"
      sgroup "SMBBP_BOOST_ENABLE_CONTROL (at 0x1546)"
        set &access:&cmd_addr %l (0x8015460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BOOST_PWR_EN                             = " "0 (BOOST_NOT_FORCED_ON),1 (BOOST_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (IGNORE_HW_EN),1 (FOLLOW_HW_EN)"
    tree.end
    tree "SMBBP_BOOST_BOOST_SOFT_START"
      sgroup "SMBBP_BOOST_BOOST_SOFT_START (at 0x154c)"
        set &access:&cmd_addr %l (0x80154c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x154c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BOOST_SOFT_START                      = " "0 (BOOST_SOFT_START_DISABLED),1 (BOOST_SOFT_START_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_AUTO_BOOST_MODE"
      sgroup "SMBBP_BOOST_AUTO_BOOST_MODE (at 0x154d)"
        set &access:&cmd_addr %l (0x80154d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x154d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (BOOST_AUTO_MODE_DISABLED),1 (BOOST_AUTO_MODE_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_BOOST_VSET_UL"
      sgroup "SMBBP_BOOST_BOOST_VSET_UL (at 0x1569)"
        set &access:&cmd_addr %l (0x8015690|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15690|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BOOST_VSET_UL                            = "
    tree.end
    tree "SMBBP_BOOST_BOOST_VSET_LL"
      sgroup "SMBBP_BOOST_BOOST_VSET_LL (at 0x156b)"
        set &access:&cmd_addr %l (0x80156b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x156b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BOOST_VSET_LL                            = "
    tree.end
    tree "SMBBP_BOOST_BOOST_OVP_SEL"
      sgroup "SMBBP_BOOST_BOOST_OVP_SEL (at 0x1570)"
        set &access:&cmd_addr %l (0x8015700|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15700|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BOOST_OVP_SEL                            = "
    tree.end
    tree "SMBBP_BOOST_BOOST_GM_CTRL"
      sgroup "SMBBP_BOOST_BOOST_GM_CTRL (at 0x1572)"
        set &access:&cmd_addr %l (0x8015720|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15720|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BOOST_GM_CTRL                            = "
    tree.end
    tree "SMBBP_BOOST_BOOST_RZERO_CTRL"
      sgroup "SMBBP_BOOST_BOOST_RZERO_CTRL (at 0x1573)"
        set &access:&cmd_addr %l (0x8015730|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15730|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BOOST_RZERO_CTRL                         = "
    tree.end
    tree "SMBBP_BOOST_BOOST_CZERO_CTRL"
      sgroup "SMBBP_BOOST_BOOST_CZERO_CTRL (at 0x1574)"
        set &access:&cmd_addr %l (0x8015740|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15740|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_CZERO_CTRL                         = " "0 (C1_50PF),1 (C1_60PF),2 (C1_70PF),3 (C1_80PF)"
    tree.end
    tree "SMBBP_BOOST_BOOST_HIPOLE_CTRL"
      sgroup "SMBBP_BOOST_BOOST_HIPOLE_CTRL (at 0x1575)"
        set &access:&cmd_addr %l (0x8015750|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15750|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_HIPOLE_CTRL                        = " "0 (C1_0PF),1 (C1_1PF),2 (C1_2PF),3 (C1_3PF)"
    tree.end
    tree "SMBBP_BOOST_BOOST_MAX_DUTY"
      sgroup "SMBBP_BOOST_BOOST_MAX_DUTY (at 0x1576)"
        set &access:&cmd_addr %l (0x8015760|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15760|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_MAX_DUTY                           = " "0 (DMAX_92P_3P2MHZ_25NS),1 (DMAX_84P_3P2MHZ_50NS),2 (DMAX_68P_3P2MHZ_100NS),3 (DMAX_52P_3P2MHZ_150NS)"
    tree.end
    tree "SMBBP_BOOST_BOOST_SLOPE_COMP"
      sgroup "SMBBP_BOOST_BOOST_SLOPE_COMP (at 0x1577)"
        set &access:&cmd_addr %l (0x8015770|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15770|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_SLOPE_COMP                         = " "0 (SLOPE_COMP_320KV_S),1 (SLOPE_COMP_640KV_S),2 (SLOPE_COMP_960KV_S),3 (SLOPE_COMP_1300KV_S)"
    tree.end
    tree "SMBBP_BOOST_BOOST_ILIM"
      sgroup "SMBBP_BOOST_BOOST_ILIM (at 0x1578)"
        set &access:&cmd_addr %l (0x8015780|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15780|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BOOST_ILIM                               = " "0 (INLIMIT_4P5A),1 (INLIMIT_4P0A),2 (INLIMIT_3P5A),3 (INLIMIT_3P0A),4 (INLIMIT_2P5A),5 (INLIMIT_2P0A),6 (INLIMIT_1P5A),7 (INLIMIT_1P0A)"
    tree.end
    tree "SMBBP_BOOST_IPZ_EN"
      sgroup "SMBBP_BOOST_IPZ_EN (at 0x1579)"
        set &access:&cmd_addr %l (0x8015790|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15790|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_IPZ_COMP                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "SMBBP_BOOST_SEC_ACCESS"
      sgroup "SMBBP_BOOST_SEC_ACCESS (at 0x15d0)"
        set &access:&cmd_addr %l (0x8015d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBBP_BOOST_PERPH_RESET_CTL2"
      sgroup "SMBBP_BOOST_PERPH_RESET_CTL2 (at 0x15d9)"
        set &access:&cmd_addr %l (0x8015d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_BOOST_PERPH_RESET_CTL3"
      sgroup "SMBBP_BOOST_PERPH_RESET_CTL3 (at 0x15da)"
        set &access:&cmd_addr %l (0x8015da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBBP_BOOST_PERPH_RESET_CTL4"
      sgroup "SMBBP_BOOST_PERPH_RESET_CTL4 (at 0x15db)"
        set &access:&cmd_addr %l (0x8015db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_BOOST_BOOST_SPARE"
      sgroup "SMBBP_BOOST_BOOST_SPARE (at 0x15df)"
        set &access:&cmd_addr %l (0x8015df0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15df0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBBP_BOOST_INT_TEST1"
      sgroup "SMBBP_BOOST_INT_TEST1 (at 0x15e0)"
        set &access:&cmd_addr %l (0x8015e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SMBBP_BOOST_INT_TEST_VAL"
      sgroup "SMBBP_BOOST_INT_TEST_VAL (at 0x15e1)"
        set &access:&cmd_addr %l (0x8015e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOOST_PWR_TEST_VAL                       = " "0, 1"
    tree.end
    tree "SMBBP_BOOST_DTEST"
      sgroup "SMBBP_BOOST_DTEST (at 0x15e2)"
        set &access:&cmd_addr %l (0x8015e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST1_OUT_SEL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST2_OUT_SEL                           = " "0, 1"
    tree.end
    tree "SMBBP_BOOST_ATEST"
      sgroup "SMBBP_BOOST_ATEST (at 0x15e3)"
        set &access:&cmd_addr %l (0x8015e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBBP_BOOST_BOOST_COMP_OVR_GLOBAL"
      sgroup "SMBBP_BOOST_BOOST_COMP_OVR_GLOBAL (at 0x15e4)"
        set &access:&cmd_addr %l (0x8015e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
    tree "SMBBP_BOOST_COMPARATOR_OVRIDE_1"
      sgroup "SMBBP_BOOST_COMPARATOR_OVRIDE_1 (at 0x15e5)"
        set &access:&cmd_addr %l (0x8015e50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x15e50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BST_PWR_OK_COMP                          = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BST_OVP_COMP                             = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
  tree.end
tree.end
tree "SMBBP_BUCK"
  tree "SMBBP_BUCK"
    tree "SMBBP_BUCK_PERPH_TYPE"
      sgroup "SMBBP_BUCK_PERPH_TYPE (at 0x1104)"
        set &access:&cmd_addr %l (0x8011040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBBP_BUCK_PERPH_SUBTYPE"
      sgroup "SMBBP_BUCK_PERPH_SUBTYPE (at 0x1105)"
        set &access:&cmd_addr %l (0x8011050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBBP_BUCK_BUCK_OK"
      sgroup "SMBBP_BUCK_BUCK_OK (at 0x1108)"
        set &access:&cmd_addr %l (0x8011080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STS                                      = " "0 (BUCK_VREG_NOK),1 (BUCK_VREG_OK)"
    tree.end
    tree "SMBBP_BUCK_INT_RT_STS"
      sgroup "SMBBP_BUCK_INT_RT_STS (at 0x1110)"
        set &access:&cmd_addr %l (0x8011100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_RT_STS                         = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_RT_STS                         = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_RT_STS                         = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_RT_STS                           = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_RT_STS                           = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "SMBBP_BUCK_INT_SET_TYPE"
      sgroup "SMBBP_BUCK_INT_SET_TYPE (at 0x1111)"
        set &access:&cmd_addr %l (0x8011110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_POLARITY_SET_TYPE               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_POLARITY_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_POLARITY_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_POLARITY_SET_TYPE              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_POLARITY_SET_TYPE               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_POLARITY_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_POLARITY_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SMBBP_BUCK_INT_POLARITY_HIGH"
      sgroup "SMBBP_BUCK_INT_POLARITY_HIGH (at 0x1112)"
        set &access:&cmd_addr %l (0x8011120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_POLARITY_HIGH                   = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_POLARITY_HIGH                  = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_POLARITY_HIGH                  = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_POLARITY_HIGH                  = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_POLARITY_HIGH                   = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_POLARITY_HIGH                    = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_POLARITY_HIGH                    = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_BUCK_INT_POLARITY_LOW"
      sgroup "SMBBP_BUCK_INT_POLARITY_LOW (at 0x1113)"
        set &access:&cmd_addr %l (0x8011130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_POLARITY_LOW                    = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_POLARITY_LOW                   = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_POLARITY_LOW                   = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_POLARITY_LOW                   = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_POLARITY_LOW                    = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_POLARITY_LOW                     = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_POLARITY_LOW                     = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_BUCK_INT_LATCHED_CLR"
      sgroup "SMBBP_BUCK_INT_LATCHED_CLR (at 0x1114)"
        set &access:&cmd_addr %l (0x8011140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "SMBBP_BUCK_INT_EN_SET"
      sgroup "SMBBP_BUCK_INT_EN_SET (at 0x1115)"
        set &access:&cmd_addr %l (0x8011150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_BUCK_INT_EN_CLR"
      sgroup "SMBBP_BUCK_INT_EN_CLR (at 0x1116)"
        set &access:&cmd_addr %l (0x8011160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_BUCK_INT_LATCHED_STS"
      sgroup "SMBBP_BUCK_INT_LATCHED_STS (at 0x1118)"
        set &access:&cmd_addr %l (0x8011180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "SMBBP_BUCK_INT_PENDING_STS"
      sgroup "SMBBP_BUCK_INT_PENDING_STS (at 0x1119)"
        set &access:&cmd_addr %l (0x8011190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_STS                             = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_STS                            = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_STS                            = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_STS                            = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_STS                             = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_STS                              = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_STS                              = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "SMBBP_BUCK_INT_MID_SEL"
      sgroup "SMBBP_BUCK_INT_MID_SEL (at 0x111a)"
        set &access:&cmd_addr %l (0x80111a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x111a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SMBBP_BUCK_INT_PRIORITY"
      sgroup "SMBBP_BUCK_INT_PRIORITY (at 0x111b)"
        set &access:&cmd_addr %l (0x80111b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x111b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SMBBP_BUCK_ENABLE_CONTROL"
      sgroup "SMBBP_BUCK_ENABLE_CONTROL (at 0x1146)"
        set &access:&cmd_addr %l (0x8011460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUCK_EN                                  = " "0 (BUCK_NOT_FORCED_ON),1 (BUCK_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (IGNORE_HW_EN),1 (FOLLOW_HW_EN)"
    tree.end
    tree "SMBBP_BUCK_VDD_LOOP_GM_CTRL"
      sgroup "SMBBP_BUCK_VDD_LOOP_GM_CTRL (at 0x1160)"
        set &access:&cmd_addr %l (0x8011600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDD_LOOP_GM_CTRL                         = "
    tree.end
    tree "SMBBP_BUCK_VCHG_LOOP_GM_CTRL"
      sgroup "SMBBP_BUCK_VCHG_LOOP_GM_CTRL (at 0x1161)"
        set &access:&cmd_addr %l (0x8011610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VCHG_LOOP_GM_CTRL                        = "
    tree.end
    tree "SMBBP_BUCK_IBAT_LOOP_GM_CTRL"
      sgroup "SMBBP_BUCK_IBAT_LOOP_GM_CTRL (at 0x1162)"
        set &access:&cmd_addr %l (0x8011620|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11620|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IBAT_LOOP_GM_CTRL                        = "
    tree.end
    tree "SMBBP_BUCK_ICHG_LOOP_GM_CTRL"
      sgroup "SMBBP_BUCK_ICHG_LOOP_GM_CTRL (at 0x1163)"
        set &access:&cmd_addr %l (0x8011630|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11630|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ICHG_LOOP_GM_CTRL                        = "
    tree.end
    tree "SMBBP_BUCK_VDD_LOOP_COMP_RES"
      sgroup "SMBBP_BUCK_VDD_LOOP_COMP_RES (at 0x1164)"
        set &access:&cmd_addr %l (0x8011640|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11640|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDD_LOOP_COMP_RES                        = "
    tree.end
    tree "SMBBP_BUCK_VCHG_LOOP_COMP_RES"
      sgroup "SMBBP_BUCK_VCHG_LOOP_COMP_RES (at 0x1165)"
        set &access:&cmd_addr %l (0x8011650|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11650|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VCHG_LOOP_COMP_RES                       = "
    tree.end
    tree "SMBBP_BUCK_SAWTOOH_SLOPE_GAIN"
      sgroup "SMBBP_BUCK_SAWTOOH_SLOPE_GAIN (at 0x1168)"
        set &access:&cmd_addr %l (0x8011680|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11680|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SAWTOOH_SLOPE_GAIN                       = " "0 (SLOPE_GAIN_320KV_S),1 (SLOPE_GAIN_640KV_S),2 (SLOPE_GAIN_960KV_S),3 (SLOPE_GAIN_1300KV_S)"
    tree.end
    tree "SMBBP_BUCK_PULSE_SKIPPING_COMP_EN"
      sgroup "SMBBP_BUCK_PULSE_SKIPPING_COMP_EN (at 0x116a)"
        set &access:&cmd_addr %l (0x80116a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x116a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULSE_SKIPPING_COMP_EN                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "SMBBP_BUCK_ZERO_COMPCAP_CTRL"
      sgroup "SMBBP_BUCK_ZERO_COMPCAP_CTRL (at 0x116b)"
        set &access:&cmd_addr %l (0x80116b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x116b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ZERO_COMP_CAP_VCHG                       = " "0 (C1_50PF),1 (C1_60PF),2 (C1_70PF),3 (C1_80PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZERO_COMP_CAP_VDD                        = " "0 (C1_50PF),1 (C1_60PF),2 (C1_70PF),3 (C1_80PF)"
    tree.end
    tree "SMBBP_BUCK_HIGH_POLE_COMPCAP_CTRL"
      sgroup "SMBBP_BUCK_HIGH_POLE_COMPCAP_CTRL (at 0x116c)"
        set &access:&cmd_addr %l (0x80116c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x116c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HIGH_POLE_COMPCAP_VCHG                   = " "0 (C1_0PF),1 (C1_1PF),2 (C1_2PF),3 (C1_3PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   HIGH_POLE_COMPCAP_VDD                    = " "0 (C1_0PF),1 (C1_1PF),2 (C1_2PF),3 (C1_3PF)"
    tree.end
    tree "SMBBP_BUCK_ILIMIT_CTRL"
      sgroup "SMBBP_BUCK_ILIMIT_CTRL (at 0x116e)"
        set &access:&cmd_addr %l (0x80116e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x116e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIMIT_EN                               = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   IPLIMIT_SEL                              = " "0 (IPLIMIT_4P5A),1 (IPLIMIT_4P0A),2 (IPLIMIT_3P5A),3 (IPLIMIT_3P0A),4 (IPLIMIT_2P5A),5 (IPLIMIT_2P0A),6 (IPLIMIT_1P5A),7 (IPLIMIT_1P0A)"
    tree.end
    tree "SMBBP_BUCK_MIN_PON"
      sgroup "SMBBP_BUCK_MIN_PON (at 0x1171)"
        set &access:&cmd_addr %l (0x8011710|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11710|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL                                      = " "0 (MIN_PON_25NS),1 (MIN_PON_37P5NS),2 (MIN_PON_50NS),3 (MIN_PON_100NS)"
    tree.end
    tree "SMBBP_BUCK_SLEW_RATE_CONTROL"
      sgroup "SMBBP_BUCK_SLEW_RATE_CONTROL (at 0x1172)"
        set &access:&cmd_addr %l (0x8011720|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11720|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PDRV                                     = " "0 (SLEW_RATE_20NS),1 (SLEW_RATE_15NS),2 (SLEW_RATE_10NS),3 (SLEW_RATE_5NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   NDRV                                     = " "0 (SLEW_RATE_20NS),1 (SLEW_RATE_15NS),2 (SLEW_RATE_10NS),3 (SLEW_RATE_5NS)"
    tree.end
    tree "SMBBP_BUCK_PSTG_CONTROL"
      sgroup "SMBBP_BUCK_PSTG_CONTROL (at 0x1173)"
        set &access:&cmd_addr %l (0x8011730|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11730|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_BUCK_BCK_VBAT_REG_MODE"
      sgroup "SMBBP_BUCK_BCK_VBAT_REG_MODE (at 0x1174)"
        set &access:&cmd_addr %l (0x8011740|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11740|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL                                      = " "0 (BUCK_REGULATE_VPH_PWR_SNS),1 (BUCK_REGULATE_VBAT_SNS)"
    tree.end
    tree "SMBBP_BUCK_VCHG_DISCHG"
      sgroup "SMBBP_BUCK_VCHG_DISCHG (at 0x1176)"
        set &access:&cmd_addr %l (0x8011760|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11760|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "SMBBP_BUCK_VCHG_OV"
      sgroup "SMBBP_BUCK_VCHG_OV (at 0x1177)"
        set &access:&cmd_addr %l (0x8011770|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11770|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_BUCK_SWITCHOVER"
      sgroup "SMBBP_BUCK_SWITCHOVER (at 0x1178)"
        set &access:&cmd_addr %l (0x8011780|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11780|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TD1_SEL                                  = " "0 (PM8026_ONLY_T_0US),1 (PM8026_ONLY_T_30US),2 (PM8026_ONLY_T_60US),3 (PM8026_ONLY_T_120US)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TD2_SEL                                  = " "0 (PM8026_ONLY_T_0US),1 (PM8026_ONLY_T_30US),2 (PM8026_ONLY_T_60US),3 (PM8026_ONLY_T_120US)"
    tree.end
    tree "SMBBP_BUCK_SEC_ACCESS"
      sgroup "SMBBP_BUCK_SEC_ACCESS (at 0x11d0)"
        set &access:&cmd_addr %l (0x8011d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBBP_BUCK_PERPH_RESET_CTL2"
      sgroup "SMBBP_BUCK_PERPH_RESET_CTL2 (at 0x11d9)"
        set &access:&cmd_addr %l (0x8011d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_BUCK_PERPH_RESET_CTL3"
      sgroup "SMBBP_BUCK_PERPH_RESET_CTL3 (at 0x11da)"
        set &access:&cmd_addr %l (0x8011da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBBP_BUCK_PERPH_RESET_CTL4"
      sgroup "SMBBP_BUCK_PERPH_RESET_CTL4 (at 0x11db)"
        set &access:&cmd_addr %l (0x8011db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_BUCK_BUCK_SPARE"
      sgroup "SMBBP_BUCK_BUCK_SPARE (at 0x11df)"
        set &access:&cmd_addr %l (0x8011df0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11df0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBBP_BUCK_INT_TEST1"
      sgroup "SMBBP_BUCK_INT_TEST1 (at 0x11e0)"
        set &access:&cmd_addr %l (0x8011e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SMBBP_BUCK_INT_TEST_VAL"
      sgroup "SMBBP_BUCK_INT_TEST_VAL (at 0x11e1)"
        set &access:&cmd_addr %l (0x8011e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VDD_LOOP_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_LOOP_INT_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICHG_LOOP_INT_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCHG_LOOP_INT_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERTEMP_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_OV_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_OV_INT_VAL                          = " "0, 1"
    tree.end
    tree "SMBBP_BUCK_TRIM_CAL_TEST"
      sgroup "SMBBP_BUCK_TRIM_CAL_TEST (at 0x11e2)"
        set &access:&cmd_addr %l (0x8011e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICHG_EA_TRIM_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ICHG_EA_TRIM_CAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCHG_EA_TRIM_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCHG_EA_TRIM_CAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBAT_EA_TRIM_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IBAT_EA_TRIM_CAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VDD_EA_TRIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VDD_EA_TRIM_CAL                          = " "0, 1"
    tree.end
    tree "SMBBP_BUCK_TRIM_CAL_TEST2"
      sgroup "SMBBP_BUCK_TRIM_CAL_TEST2 (at 0x11e3)"
        set &access:&cmd_addr %l (0x8011e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IBAT_DAC_TRIM_CAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IBAT_SNS_TRIM_CAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REFBUF_OPAMP_TRIM_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   REFBUF_OPAMP_TRIM_CAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VDD_DETECTOR_TRIM_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VDD_DETECTOR_TRIM_CAL                    = " "0, 1"
    tree.end
    tree "SMBBP_BUCK_TEST_ATEST"
      sgroup "SMBBP_BUCK_TEST_ATEST (at 0x11e4)"
        set &access:&cmd_addr %l (0x8011e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST_SEL                                = "
    tree.end
    tree "SMBBP_BUCK_TEST_EN_SMBC_LOOP"
      sgroup "SMBBP_BUCK_TEST_EN_SMBC_LOOP (at 0x11e5)"
        set &access:&cmd_addr %l (0x8011e50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SMBC_BUCK_ENABLE                         = " "0 (SMBC_BUCK_CTRL_NOT_FORCED_ON),1 (SMBC_BUCK_CTRL_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IBAT_LOOP_DISABLE                        = " "0 (IBAT_LOOP_ENABLED),1 (IBAT_LOOP_DISABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ICHG_LOOP_DISABLE                        = " "0 (ICHG_LOOP_ENABLED),1 (ICHG_LOOP_DISABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VCHG_LOOP_DISABLE                        = " "0 (VCHG_LOOP_ENABLED),1 (VCHG_LOOP_DISABLED)"
    tree.end
    tree "SMBBP_BUCK_TEST_SMBC_MODES"
      sgroup "SMBBP_BUCK_TEST_SMBC_MODES (at 0x11e6)"
        set &access:&cmd_addr %l (0x8011e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BUCK_MAX_DUTY                            = " "0 (DMAX_100P_3P2MHZ_0NS),1 (DMAX_92P_3P2MHZ_25NS),2 (DMAX_84P_3P2MHZ_50NS),3 (DMAX_68P_3P2MHZ_100NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLOPE_COMP_DIS                           = " "0 (SLOPE_COMP_ENABLED),1 (SLOPE_COMP_DISABLED)"
    tree.end
    tree "SMBBP_BUCK_TEMP_TEST"
      sgroup "SMBBP_BUCK_TEMP_TEST (at 0x11e7)"
        set &access:&cmd_addr %l (0x8011e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TL_DIS_MODE                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEMP_TEST                                = "
    tree.end
    tree "SMBBP_BUCK_DTEST_CTRL"
      sgroup "SMBBP_BUCK_DTEST_CTRL (at 0x11e8)"
        set &access:&cmd_addr %l (0x8011e80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_BUCK_VPH_OK_THR_TST"
      sgroup "SMBBP_BUCK_VPH_OK_THR_TST (at 0x11e9)"
        set &access:&cmd_addr %l (0x8011e90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11e90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VPH_OK_THR                               = " "0 (INVERT_COMP_OUTPUT),1 (OVERRIDE_TO_0),2 (OVERRIDE_TO_1),3 (reserved)"
    tree.end
    tree "SMBBP_BUCK_BUCK_COMP_OVR_GLOBAL"
      sgroup "SMBBP_BUCK_BUCK_COMP_OVR_GLOBAL (at 0x11ea)"
        set &access:&cmd_addr %l (0x8011ea0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11ea0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
    tree "SMBBP_BUCK_COMPARATOR_OVRIDE_1"
      sgroup "SMBBP_BUCK_COMPARATOR_OVRIDE_1 (at 0x11eb)"
        set &access:&cmd_addr %l (0x8011eb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11eb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ICHG_END_CMP_OVRD                        = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BUCK_TEMP2HI_CMP_OVRD                    = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BUCK_IUSB_LOOP_CMP_OVRD                  = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUCK_IBAT_LOOP_CMP_OVRD                  = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_BUCK_COMPARATOR_OVRIDE_2"
      sgroup "SMBBP_BUCK_COMPARATOR_OVRIDE_2 (at 0x11ec)"
        set &access:&cmd_addr %l (0x8011ec0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11ec0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   VREG_OV_CMP_OVRD                         = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BUCK_VIN_LOOP_CMP_OVRD                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BUCK_VDD_LOOP_CMP_OVRD                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUCK_VREG_OK_CMP_OVRD                    = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_BUCK_COMPARATOR_OVRIDE_3"
      sgroup "SMBBP_BUCK_COMPARATOR_OVRIDE_3 (at 0x11ed)"
        set &access:&cmd_addr %l (0x8011ed0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11ed0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IOVP_LO_CMP_OVRD                         = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ICHG_END_VCP_CMP_OVRD                    = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VPH_OK_CMP_OVRD                          = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_BUCK_TEST_DRIVER_OVERLAP"
      sgroup "SMBBP_BUCK_TEST_DRIVER_OVERLAP (at 0x11ee)"
        set &access:&cmd_addr %l (0x8011ee0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11ee0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_INZERO_COMP2                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_INZERO_COMP                           = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "SMBBP_BUCK_ASYNC_FSM_TST"
      sgroup "SMBBP_BUCK_ASYNC_FSM_TST (at 0x11ef)"
        set &access:&cmd_addr %l (0x8011ef0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11ef0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST                                    = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TEST_SM_TM                               = "
    tree.end
    tree "SMBBP_BUCK_BUCK_TRIM_NUM"
      sgroup "SMBBP_BUCK_BUCK_TRIM_NUM (at 0x11f0)"
        set &access:&cmd_addr %l (0x8011f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBBP_BUCK_BUCK_CTRL_TRIM1"
      sgroup "SMBBP_BUCK_BUCK_CTRL_TRIM1 (at 0x11f1)"
        set &access:&cmd_addr %l (0x8011f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VDD_EA_OFFSET_TRIM                       = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VCHG_EA_OFFSET_TRIM                      = "
    tree.end
    tree "SMBBP_BUCK_BUCK_CTRL_TRIM2"
      sgroup "SMBBP_BUCK_BUCK_CTRL_TRIM2 (at 0x11f2)"
        set &access:&cmd_addr %l (0x8011f20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   IBAT_EA_OFFSET_TRIM                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ICHG_EA_OFFSET_TRIM                      = "
    tree.end
    tree "SMBBP_BUCK_BUCK_CTRL_TRIM3"
      sgroup "SMBBP_BUCK_BUCK_CTRL_TRIM3 (at 0x11f3)"
        set &access:&cmd_addr %l (0x8011f30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IBAT_SNS_OFFSET_TRIM                     = "
    tree.end
    tree "SMBBP_BUCK_BUCK_CTRL_TRIM4"
      sgroup "SMBBP_BUCK_BUCK_CTRL_TRIM4 (at 0x11f4)"
        set &access:&cmd_addr %l (0x8011f40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   REFBUF_OFFSET_TRIM                       = "
    tree.end
    tree "SMBBP_BUCK_BUCK_CTRL_TRIM5"
      sgroup "SMBBP_BUCK_BUCK_CTRL_TRIM5 (at 0x11f5)"
        set &access:&cmd_addr %l (0x8011f50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CHG_ITRKL_TRIM                           = "
    tree.end
    tree "SMBBP_BUCK_BUCK_CTRL_TRIM6"
      sgroup "SMBBP_BUCK_BUCK_CTRL_TRIM6 (at 0x11f6)"
        set &access:&cmd_addr %l (0x8011f60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZ_VOS_ADJ_TRIM                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_BLANKING_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "SMBBP_BUCK_BUCK_CTRL_TRIM7"
      sgroup "SMBBP_BUCK_BUCK_CTRL_TRIM7 (at 0x11f7)"
        set &access:&cmd_addr %l (0x8011f70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CHG_TTRIM                                = "
    tree.end
    tree "SMBBP_BUCK_IBAT_DAC_TRIM"
      sgroup "SMBBP_BUCK_IBAT_DAC_TRIM (at 0x11f8)"
        set &access:&cmd_addr %l (0x8011f80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IBAT_DAC_TRIM                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBBP_BUCK_VDET_TRIM_SEL"
      sgroup "SMBBP_BUCK_VDET_TRIM_SEL (at 0x11f9)"
        set &access:&cmd_addr %l (0x8011f90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11f90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VDET1_TRIM_SEL                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDET0_TRIM_SEL                           = "
    tree.end
    tree "SMBBP_BUCK_IBAT_GAIN"
      sgroup "SMBBP_BUCK_IBAT_GAIN (at 0x11fa)"
        set &access:&cmd_addr %l (0x8011fa0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x11fa0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
  tree.end
tree.end
tree "SMBBP_CHGR"
  tree "SMBBP_CHGR"
    tree "SMBBP_CHGR_PERPH_TYPE"
      sgroup "SMBBP_CHGR_PERPH_TYPE (at 0x1004)"
        set &access:&cmd_addr %l (0x8010040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBBP_CHGR_PERPH_SUBTYPE"
      sgroup "SMBBP_CHGR_PERPH_SUBTYPE (at 0x1005)"
        set &access:&cmd_addr %l (0x8010050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBBP_CHGR_CHG_OPTION"
      sgroup "SMBBP_CHGR_CHG_OPTION (at 0x1008)"
        set &access:&cmd_addr %l (0x8010080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN                                      = " "0 (EXT_CHARGER),1 (PMIC_CHARGER)"
    tree.end
    tree "SMBBP_CHGR_ATC_STATUS"
      sgroup "SMBBP_CHGR_ATC_STATUS (at 0x100a)"
        set &access:&cmd_addr %l (0x80100a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x100a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATC_DONE                                 = " "0 (ATC_NOT_DONE),1 (ATC_DONE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATC_FAILED                               = " "0 (ATC_NOT_FAILED),1 (ATC_FAILED)"
    tree.end
    tree "SMBBP_CHGR_VBAT_STATUS"
      sgroup "SMBBP_CHGR_VBAT_STATUS (at 0x100b)"
        set &access:&cmd_addr %l (0x80100b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x100b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ABOVE_VBATDET_HI                         = " "0 (BELOW_VBATDET_HI),1 (ABOVE_VBATDET_HI)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ABOVE_VBATDET_LO                         = " "0 (BELOW_VBATDET_LO),1 (ABOVE_VBATDET_LO)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ABOVE_VFAULT                             = " "0 (BELOW_VTRKL_FAULT),1 (ABOVE_VTRKL_FAULT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ABOVE_VBAT_WEAK                          = " "0 (BELOW_VBAT_WEAK),1 (ABOVE_VBAT_WEAK)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABOVE_VBAT_TRKL                          = " "0 (BELOW_VBAT_TRKL),1 (ABOVE_VBAT_TRKL)"
    tree.end
    tree "SMBBP_CHGR_IBAT_BMS"
      sgroup "SMBBP_CHGR_IBAT_BMS (at 0x100c)"
        set &access:&cmd_addr %l (0x80100c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x100c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "SMBBP_CHGR_IBAT_STS"
      sgroup "SMBBP_CHGR_IBAT_STS (at 0x100d)"
        set &access:&cmd_addr %l (0x80100d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x100d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BMS_SIGN                                 = " "0 (POSITIVE_BATTERY_DISCHARGING),1 (NEGATIVE_BATTERY_CHARGING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   IBAT_TERM_COMP                           = " "0 (IBAT_ABOVE_THRESHOLD_NOK_TO_TERM),1 (IBAT_BELOW_THRESHOLD_OK_TO_TERM)"
    tree.end
    tree "SMBBP_CHGR_INT_RT_STS"
      sgroup "SMBBP_CHGR_INT_RT_STS (at 0x1010)"
        set &access:&cmd_addr %l (0x8010100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_RT_STS                        = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_RT_STS                      = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_RT_STS                           = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "SMBBP_CHGR_INT_SET_TYPE"
      sgroup "SMBBP_CHGR_INT_SET_TYPE (at 0x1011)"
        set &access:&cmd_addr %l (0x8010110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_SET_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_SET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_SET_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_SET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SMBBP_CHGR_INT_POLARITY_HIGH"
      sgroup "SMBBP_CHGR_INT_POLARITY_HIGH (at 0x1012)"
        set &access:&cmd_addr %l (0x8010120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_POLARITY_HIGH                   = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_POLARITY_HIGH                 = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_POLARITY_HIGH               = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_POLARITY_HIGH                    = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_POLARITY_HIGH                = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_INT_POLARITY_LOW"
      sgroup "SMBBP_CHGR_INT_POLARITY_LOW (at 0x1013)"
        set &access:&cmd_addr %l (0x8010130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_POLARITY_LOW                    = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_POLARITY_LOW                  = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_POLARITY_LOW                = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_POLARITY_LOW                     = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_POLARITY_LOW                 = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_INT_LATCHED_CLR"
      sgroup "SMBBP_CHGR_INT_LATCHED_CLR (at 0x1014)"
        set &access:&cmd_addr %l (0x8010140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_INT_EN_SET"
      sgroup "SMBBP_CHGR_INT_EN_SET (at 0x1015)"
        set &access:&cmd_addr %l (0x8010150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_INT_EN_CLR"
      sgroup "SMBBP_CHGR_INT_EN_CLR (at 0x1016)"
        set &access:&cmd_addr %l (0x8010160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_INT_LATCHED_STS"
      sgroup "SMBBP_CHGR_INT_LATCHED_STS (at 0x1018)"
        set &access:&cmd_addr %l (0x8010180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "SMBBP_CHGR_INT_PENDING_STS"
      sgroup "SMBBP_CHGR_INT_PENDING_STS (at 0x1019)"
        set &access:&cmd_addr %l (0x8010190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "SMBBP_CHGR_INT_MID_SEL"
      sgroup "SMBBP_CHGR_INT_MID_SEL (at 0x101a)"
        set &access:&cmd_addr %l (0x80101a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x101a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SMBBP_CHGR_INT_PRIORITY"
      sgroup "SMBBP_CHGR_INT_PRIORITY (at 0x101b)"
        set &access:&cmd_addr %l (0x80101b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x101b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SMBBP_CHGR_VDD_MAX"
      sgroup "SMBBP_CHGR_VDD_MAX (at 0x1040)"
        set &access:&cmd_addr %l (0x8010400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_VDD_SAFE"
      sgroup "SMBBP_CHGR_VDD_SAFE (at 0x1041)"
        set &access:&cmd_addr %l (0x8010410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_VDD_MAX_STEP"
      sgroup "SMBBP_CHGR_VDD_MAX_STEP (at 0x1042)"
        set &access:&cmd_addr %l (0x8010420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BYP                                      = " "0 (STEPPER_IN_USE),1 (STEPPER_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   STEP_SEL                                 = " "0 (PER_STEP_1_LSB),1 (PER_STEP_2_LSB),2 (PER_STEP_3_LSB),3 (PER_STEP_4_LSB)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DLY_SEL                                  = " "0 (PER_STEP_4_CLOCKS),1 (PER_STEP_8_CLOCKS),2 (PER_STEP_12_CLOCKS),3 (PER_STEP_16_CLOCKS),4 (PER_STEP_20_CLOCKS),5 (PER_STEP_24_CLOCKS),6 (PER_STEP_32_CLOCKS),7 (PER_STEP_64_CLOCKS)"
    tree.end
    tree "SMBBP_CHGR_VDDMAX_GSM_ADJ"
      sgroup "SMBBP_CHGR_VDDMAX_GSM_ADJ (at 0x1043)"
        set &access:&cmd_addr %l (0x8010430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (FEATURE_DISABLED),1 (FEATURE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MUX_SEL                                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_IBAT_MAX"
      sgroup "SMBBP_CHGR_IBAT_MAX (at 0x1044)"
        set &access:&cmd_addr %l (0x8010440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_IBAT_SAFE"
      sgroup "SMBBP_CHGR_IBAT_SAFE (at 0x1045)"
        set &access:&cmd_addr %l (0x8010450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_IBAT_MAX_STEP"
      sgroup "SMBBP_CHGR_IBAT_MAX_STEP (at 0x1046)"
        set &access:&cmd_addr %l (0x8010460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BYP                                      = " "0 (STEPPER_IN_USE),1 (STEPPER_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   STEP_SEL                                 = " "0 (PER_STEP_1_LSB),1 (PER_STEP_2_LSB),2 (PER_STEP_3_LSB),3 (PER_STEP_4_LSB)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DLY_SEL                                  = " "0 (PER_STEP_4_CLOCKS),1 (PER_STEP_8_CLOCKS),2 (PER_STEP_12_CLOCKS),3 (PER_STEP_16_CLOCKS),4 (PER_STEP_20_CLOCKS),5 (PER_STEP_24_CLOCKS),6 (PER_STEP_32_CLOCKS),7 (PER_STEP_64_CLOCKS)"
    tree.end
    tree "SMBBP_CHGR_VIN_MIN"
      sgroup "SMBBP_CHGR_VIN_MIN (at 0x1047)"
        set &access:&cmd_addr %l (0x8010470|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10470|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_VIN_MIN_STEP"
      sgroup "SMBBP_CHGR_VIN_MIN_STEP (at 0x1048)"
        set &access:&cmd_addr %l (0x8010480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BYP                                      = " "0 (STEPPER_IN_USE),1 (STEPPER_BYPASSED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   STEP_SEL                                 = " "0 (PER_STEP_1_LSB),1 (PER_STEP_2_LSB),2 (PER_STEP_3_LSB),3 (PER_STEP_4_LSB)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DLY_SEL                                  = " "0 (PER_STEP_4_CLOCKS),1 (PER_STEP_8_CLOCKS),2 (PER_STEP_12_CLOCKS),3 (PER_STEP_16_CLOCKS),4 (PER_STEP_20_CLOCKS),5 (PER_STEP_24_CLOCKS),6 (PER_STEP_32_CLOCKS),7 (PER_STEP_64_CLOCKS)"
    tree.end
    tree "SMBBP_CHGR_CHG_CTRL"
      sgroup "SMBBP_CHGR_CHG_CTRL (at 0x1049)"
        set &access:&cmd_addr %l (0x8010490|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10490|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_EN                                   = " "0 (CHG_DISABLED),1 (CHG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_PAUSE                                = " "0 (CHG_NOT_PAUSED),1 (CHG_PAUSED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ON_BAT_FORCE                             = " "0 (NOT_FORCED_ON_BAT),1 (FORCED_ON_BAT)"
    tree.end
    tree "SMBBP_CHGR_CHG_FAILED"
      sgroup "SMBBP_CHGR_CHG_FAILED (at 0x104a)"
        set &access:&cmd_addr %l (0x80104a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x104a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_ATC_CTRL"
      sgroup "SMBBP_CHGR_ATC_CTRL (at 0x104b)"
        set &access:&cmd_addr %l (0x80104b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x104b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATC_FORCE                                = " "0 (ATC_NOT_FORCED),1 (ATC_FORCED)"
    tree.end
    tree "SMBBP_CHGR_ATC_FAILED"
      sgroup "SMBBP_CHGR_ATC_FAILED (at 0x104c)"
        set &access:&cmd_addr %l (0x80104c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x104c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_LED"
      sgroup "SMBBP_CHGR_LED (at 0x104d)"
        set &access:&cmd_addr %l (0x80104d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x104d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CTRL                                     = " "0, 1, 2, 3"
    tree.end
    tree "SMBBP_CHGR_VBAT_TRKL"
      sgroup "SMBBP_CHGR_VBAT_TRKL (at 0x1050)"
        set &access:&cmd_addr %l (0x8010500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_VBAT_WEAK"
      sgroup "SMBBP_CHGR_VBAT_WEAK (at 0x1052)"
        set &access:&cmd_addr %l (0x8010520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_IBAT_ATC_A"
      sgroup "SMBBP_CHGR_IBAT_ATC_A (at 0x1054)"
        set &access:&cmd_addr %l (0x8010540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_IBAT_ATC_B"
      sgroup "SMBBP_CHGR_IBAT_ATC_B (at 0x1055)"
        set &access:&cmd_addr %l (0x8010550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_IBAT_TERM_CHGR"
      sgroup "SMBBP_CHGR_IBAT_TERM_CHGR (at 0x105b)"
        set &access:&cmd_addr %l (0x80105b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x105b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IEOC_SEL                                 = " "0 (ANALOG_EOC),1 (DIGITAL_EOC)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COMP_EN                                  = " "0 (IBAT_TERM_COMP_DISABLED),1 (IBAT_TERM_COMP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   THR_SEL                                  = " "0 (IBAT_TERM_AEOC_80MA),1 (IBAT_TERM_AEOC_120MA),2 (IBAT_TERM_AEOC_160MA),3 (IBAT_TERM_AEOC_200MA)"
    tree.end
    tree "SMBBP_CHGR_IBAT_TERM_BMS"
      sgroup "SMBBP_CHGR_IBAT_TERM_BMS (at 0x105c)"
        set &access:&cmd_addr %l (0x80105c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x105c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "SMBBP_CHGR_VBAT_DET"
      sgroup "SMBBP_CHGR_VBAT_DET (at 0x105d)"
        set &access:&cmd_addr %l (0x80105d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x105d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LO_THR                                   = "
    tree.end
    tree "SMBBP_CHGR_TTRKL_MAX_EN"
      sgroup "SMBBP_CHGR_TTRKL_MAX_EN (at 0x105e)"
        set &access:&cmd_addr %l (0x80105e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x105e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (TTRKL_MAX_DISABLED),1 (TTRKL_MAX_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_TTRKL_MAX"
      sgroup "SMBBP_CHGR_TTRKL_MAX (at 0x105f)"
        set &access:&cmd_addr %l (0x80105f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x105f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_TCHG_MAX_EN"
      sgroup "SMBBP_CHGR_TCHG_MAX_EN (at 0x1060)"
        set &access:&cmd_addr %l (0x8010600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (TCHG_MAX_DISABLED),1 (TCHG_MAX_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_TCHG_MAX"
      sgroup "SMBBP_CHGR_TCHG_MAX (at 0x1061)"
        set &access:&cmd_addr %l (0x8010610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_CHG_WDOG_TIME"
      sgroup "SMBBP_CHGR_CHG_WDOG_TIME (at 0x1062)"
        set &access:&cmd_addr %l (0x8010620|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10620|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SEL                                      = "
    tree.end
    tree "SMBBP_CHGR_CHG_WDOG_DLY"
      sgroup "SMBBP_CHGR_CHG_WDOG_DLY (at 0x1063)"
        set &access:&cmd_addr %l (0x8010630|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10630|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   SEL                                      = " "0 (CHG_WDOG_DLY_0SEC),1 (CHG_WDOG_DLY_1SEC),2 (CHG_WDOG_DLY_2SEC),3 (CHG_WDOG_DLY_3SEC),4 (CHG_WDOG_DLY_4SEC),5 (CHG_WDOG_DLY_5SEC),6 (CHG_WDOG_DLY_6SEC),7 (CHG_WDOG_DLY_7SEC)"
    tree.end
    tree "SMBBP_CHGR_CHG_WDOG_PET"
      sgroup "SMBBP_CHGR_CHG_WDOG_PET (at 0x1064)"
        set &access:&cmd_addr %l (0x8010640|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10640|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PET                                      = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_CHG_WDOG_EN"
      sgroup "SMBBP_CHGR_CHG_WDOG_EN (at 0x1065)"
        set &access:&cmd_addr %l (0x8010650|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10650|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (CHG_WDOG_DISABLED),1 (CHG_WDOG_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_CHG_TEMP_THRESH"
      sgroup "SMBBP_CHGR_CHG_TEMP_THRESH (at 0x1066)"
        set &access:&cmd_addr %l (0x8010660|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10660|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CHG_TEMP_STOP                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CHG_TEMP_RESUME                          = "
    tree.end
    tree "SMBBP_CHGR_IR_DROP_COMPEN"
      sgroup "SMBBP_CHGR_IR_DROP_COMPEN (at 0x1067)"
        set &access:&cmd_addr %l (0x8010670|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10670|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (IR_DROP_COMP_DISABLED),1 (IR_DROP_COMP_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES                                      = "
    tree.end
    tree "SMBBP_CHGR_VDD_MAX_COMPEN"
      sgroup "SMBBP_CHGR_VDD_MAX_COMPEN (at 0x1068)"
        set &access:&cmd_addr %l (0x8010680|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10680|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "SMBBP_CHGR_VBAT_DET_EN"
      sgroup "SMBBP_CHGR_VBAT_DET_EN (at 0x1069)"
        set &access:&cmd_addr %l (0x8010690|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10690|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_DET_HI_LO_CTRL                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBBP_CHGR_SEC_ACCESS"
      sgroup "SMBBP_CHGR_SEC_ACCESS (at 0x10d0)"
        set &access:&cmd_addr %l (0x8010d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBBP_CHGR_PERPH_RESET_CTL2"
      sgroup "SMBBP_CHGR_PERPH_RESET_CTL2 (at 0x10d9)"
        set &access:&cmd_addr %l (0x8010d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_PERPH_RESET_CTL3"
      sgroup "SMBBP_CHGR_PERPH_RESET_CTL3 (at 0x10da)"
        set &access:&cmd_addr %l (0x8010da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_PERPH_RESET_CTL4"
      sgroup "SMBBP_CHGR_PERPH_RESET_CTL4 (at 0x10db)"
        set &access:&cmd_addr %l (0x8010db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_CHGR_PERPH_RESET_CTL5"
      sgroup "SMBBP_CHGR_PERPH_RESET_CTL5 (at 0x10dc)"
        set &access:&cmd_addr %l (0x8010dc0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10dc0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_PERPH_RESET_CTL6"
      sgroup "SMBBP_CHGR_PERPH_RESET_CTL6 (at 0x10dd)"
        set &access:&cmd_addr %l (0x8010dd0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10dd0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_CHGR_CHGR_SPARE"
      sgroup "SMBBP_CHGR_CHGR_SPARE (at 0x10df)"
        set &access:&cmd_addr %l (0x8010df0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10df0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBBP_CHGR_INT_TEST1"
      sgroup "SMBBP_CHGR_INT_TEST1 (at 0x10e0)"
        set &access:&cmd_addr %l (0x8010e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_INT_TEST_VAL"
      sgroup "SMBBP_CHGR_INT_TEST_VAL (at 0x10e1)"
        set &access:&cmd_addr %l (0x8010e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_DONE_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_FAILED_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FAST_CHG_ON_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRKL_CHG_ON_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STATE_CHANGE_INT_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGWDOG_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_DET_HI_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBAT_DET_LO_INT_VAL                      = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_TRKL_CHG_TEST"
      sgroup "SMBBP_CHGR_TRKL_CHG_TEST (at 0x10e2)"
        set &access:&cmd_addr %l (0x8010e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHG_TRICKLE_FORCE                        = " "0 (NO_CHG_TRICKLE_FORCE),1 (CHG_TRICKLE_FORCED_ON)"
    tree.end
    tree "SMBBP_CHGR_TRICKLE_CLAMP"
      sgroup "SMBBP_CHGR_TRICKLE_CLAMP (at 0x10e3)"
        set &access:&cmd_addr %l (0x8010e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0 (TRICKLE_CLAMP_DISABLED),1 (TRICKLE_CLAMP_ENABLED)"
    tree.end
    tree "SMBBP_CHGR_FSM_STATE_CAPTURE"
      sgroup "SMBBP_CHGR_FSM_STATE_CAPTURE (at 0x10e6)"
        set &access:&cmd_addr %l (0x8010e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_STATE_CAPTURE                        = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_FSM_STATE_STS"
      sgroup "SMBBP_CHGR_FSM_STATE_STS (at 0x10e7)"
        set &access:&cmd_addr %l (0x8010e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FSM_STATE_STS                            = "
    tree.end
    tree "SMBBP_CHGR_FSM_STATE_TEST"
      sgroup "SMBBP_CHGR_FSM_STATE_TEST (at 0x10e8)"
        set &access:&cmd_addr %l (0x8010e80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FSM_WRITE_STATE_DWELL                    = " "0 (FSM_FUNCTION_NORMALLY),1 (FSM_STAY_IN_WRITE_STATE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FSM_WRITE_STATE                          = "
    tree.end
    tree "SMBBP_CHGR_FSM_STATE_WRITE"
      sgroup "SMBBP_CHGR_FSM_STATE_WRITE (at 0x10e9)"
        set &access:&cmd_addr %l (0x8010e90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10e90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_DTEST_CTRL1"
      sgroup "SMBBP_CHGR_DTEST_CTRL1 (at 0x10ea)"
        set &access:&cmd_addr %l (0x8010ea0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10ea0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_CTRL1                              = "
    tree.end
    tree "SMBBP_CHGR_TIMER_SPEEDUP"
      sgroup "SMBBP_CHGR_TIMER_SPEEDUP (at 0x10ec)"
        set &access:&cmd_addr %l (0x8010ec0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10ec0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TIMER_SPEED_UP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TIMER_RESET                              = " "0, 1"
    tree.end
    tree "SMBBP_CHGR_COMP_OVR0"
      sgroup "SMBBP_CHGR_COMP_OVR0 (at 0x10ed)"
        set &access:&cmd_addr %l (0x8010ed0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10ed0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VBAT_VERY_LOW                            = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VTRKL_FAULT                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHG_OPTION                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_CHGR_COMP_OVR1"
      sgroup "SMBBP_CHGR_COMP_OVR1 (at 0x10ee)"
        set &access:&cmd_addr %l (0x8010ee0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10ee0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VBAT_WEAK                                = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VBAT_DET_HI                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_DET_LO                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_CHGR_CHGR_COMP_OVR_GLOBAL"
      sgroup "SMBBP_CHGR_CHGR_COMP_OVR_GLOBAL (at 0x10ef)"
        set &access:&cmd_addr %l (0x8010ef0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x10ef0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
  tree.end
tree.end
tree "SMBBP_FREQ"
  tree "SMBBP_FREQ"
    tree "SMBBP_FREQ_REVISION1"
      sgroup "SMBBP_FREQ_REVISION1 (at 0x1700)"
        set &access:&cmd_addr %l (0x8017000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SMBBP_FREQ_REVISION2"
      sgroup "SMBBP_FREQ_REVISION2 (at 0x1701)"
        set &access:&cmd_addr %l (0x8017010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SMBBP_FREQ_PERPH_TYPE"
      sgroup "SMBBP_FREQ_PERPH_TYPE (at 0x1704)"
        set &access:&cmd_addr %l (0x8017040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBBP_FREQ_PERPH_SUBTYPE"
      sgroup "SMBBP_FREQ_PERPH_SUBTYPE (at 0x1705)"
        set &access:&cmd_addr %l (0x8017050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBBP_FREQ_CLK_ENABLE"
      sgroup "SMBBP_FREQ_CLK_ENABLE (at 0x1746)"
        set &access:&cmd_addr %l (0x8017460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "SMBBP_FREQ_CLK_DIV"
      sgroup "SMBBP_FREQ_CLK_DIV (at 0x1750)"
        set &access:&cmd_addr %l (0x8017500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "SMBBP_FREQ_CLK_PHASE"
      sgroup "SMBBP_FREQ_CLK_PHASE (at 0x1751)"
        set &access:&cmd_addr %l (0x8017510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "SMBBP_FREQ_GANG_CTL1"
      sgroup "SMBBP_FREQ_GANG_CTL1 (at 0x17c0)"
        set &access:&cmd_addr %l (0x8017c00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17c00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "SMBBP_FREQ_GANG_CTL2"
      sgroup "SMBBP_FREQ_GANG_CTL2 (at 0x17c1)"
        set &access:&cmd_addr %l (0x8017c10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17c10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "SMBBP_FREQ_SEC_ACCESS"
      sgroup "SMBBP_FREQ_SEC_ACCESS (at 0x17d0)"
        set &access:&cmd_addr %l (0x8017d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBBP_FREQ_PERPH_RESET_CTL2"
      sgroup "SMBBP_FREQ_PERPH_RESET_CTL2 (at 0x17d9)"
        set &access:&cmd_addr %l (0x8017d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SMBBP_FREQ_PERPH_RESET_CTL3"
      sgroup "SMBBP_FREQ_PERPH_RESET_CTL3 (at 0x17da)"
        set &access:&cmd_addr %l (0x8017da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SMBBP_FREQ_PERPH_RESET_CTL4"
      sgroup "SMBBP_FREQ_PERPH_RESET_CTL4 (at 0x17db)"
        set &access:&cmd_addr %l (0x8017db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_FREQ_TEST1"
      sgroup "SMBBP_FREQ_TEST1 (at 0x17e2)"
        set &access:&cmd_addr %l (0x8017e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x17e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "SMBBP_MISC"
  tree "SMBBP_MISC"
    tree "SMBBP_MISC_REVISION1"
      sgroup "SMBBP_MISC_REVISION1 (at 0x1600)"
        set &access:&cmd_addr %l (0x8016000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SMBBP_MISC_REVISION2"
      sgroup "SMBBP_MISC_REVISION2 (at 0x1601)"
        set &access:&cmd_addr %l (0x8016010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SMBBP_MISC_REVISION3"
      sgroup "SMBBP_MISC_REVISION3 (at 0x1602)"
        set &access:&cmd_addr %l (0x8016020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SMBBP_MISC_REVISION4"
      sgroup "SMBBP_MISC_REVISION4 (at 0x1603)"
        set &access:&cmd_addr %l (0x8016030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SMBBP_MISC_PERPH_TYPE"
      sgroup "SMBBP_MISC_PERPH_TYPE (at 0x1604)"
        set &access:&cmd_addr %l (0x8016040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBBP_MISC_PERPH_SUBTYPE"
      sgroup "SMBBP_MISC_PERPH_SUBTYPE (at 0x1605)"
        set &access:&cmd_addr %l (0x8016050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBBP_MISC_INT_RT_STS"
      sgroup "SMBBP_MISC_INT_RT_STS (at 0x1610)"
        set &access:&cmd_addr %l (0x8016100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_STS                          = " "0 (PM8026_ONLY_INT_RT_STS_LOW),1 (PM8026_ONLY_INT_RT_STS_HIGH)"
    tree.end
    tree "SMBBP_MISC_INT_SET_TYPE"
      sgroup "SMBBP_MISC_INT_SET_TYPE (at 0x1611)"
        set &access:&cmd_addr %l (0x8016110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_TYPE                         = " "0 (PM8026_ONLY_LEVEL),1 (PM8026_ONLY_EDGE)"
    tree.end
    tree "SMBBP_MISC_INT_POLARITY_HIGH"
      sgroup "SMBBP_MISC_INT_POLARITY_HIGH (at 0x1612)"
        set &access:&cmd_addr %l (0x8016120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_POLARITY_HIGH                = " "0 (PM8026_ONLY_HIGH_RISING_TRIGGER_DISABLED),1 (PM8026_ONLY_HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_MISC_INT_POLARITY_LOW"
      sgroup "SMBBP_MISC_INT_POLARITY_LOW (at 0x1613)"
        set &access:&cmd_addr %l (0x8016130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_POLARITY_LOW                 = " "0 (PM8026_ONLY_LOW_FALLING_TRIGGER_DISABLED),1 (PM8026_ONLY_LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_MISC_INT_LATCHED_CLR"
      sgroup "SMBBP_MISC_INT_LATCHED_CLR (at 0x1614)"
        set &access:&cmd_addr %l (0x8016140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_CLR                          = " "0, 1"
    tree.end
    tree "SMBBP_MISC_INT_EN_SET"
      sgroup "SMBBP_MISC_INT_EN_SET (at 0x1615)"
        set &access:&cmd_addr %l (0x8016150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_EN_SET                       = " "0 (PM8026_ONLY_INT_DISABLED),1 (PM8026_ONLY_INT_ENABLED)"
    tree.end
    tree "SMBBP_MISC_INT_EN_CLR"
      sgroup "SMBBP_MISC_INT_EN_CLR (at 0x1616)"
        set &access:&cmd_addr %l (0x8016160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_EN_CLR                       = " "0 (PM8026_ONLY_INT_DISABLED),1 (PM8026_ONLY_INT_ENABLED)"
    tree.end
    tree "SMBBP_MISC_INT_LATCHED_STS"
      sgroup "SMBBP_MISC_INT_LATCHED_STS (at 0x1618)"
        set &access:&cmd_addr %l (0x8016180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_LATCHED_STS                  = " "0 (PM8026_ONLY_NO_INT_LATCHED),1 (PM8026_ONLY_INT_LATCHED)"
    tree.end
    tree "SMBBP_MISC_INT_PENDING_STS"
      sgroup "SMBBP_MISC_INT_PENDING_STS (at 0x1619)"
        set &access:&cmd_addr %l (0x8016190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_PENDING_STS                  = " "0 (PM8026_ONLY_NO_INT_PENDING),1 (PM8026_ONLY_INT_PENDING)"
    tree.end
    tree "SMBBP_MISC_INT_MID_SEL"
      sgroup "SMBBP_MISC_INT_MID_SEL (at 0x161a)"
        set &access:&cmd_addr %l (0x80161a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x161a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SMBBP_MISC_INT_PRIORITY"
      sgroup "SMBBP_MISC_INT_PRIORITY (at 0x161b)"
        set &access:&cmd_addr %l (0x80161b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x161b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_PRIORITY                     = " "0 (PM8026_ONLY_SR),1 (PM8026_ONLY_A)"
    tree.end
    tree "SMBBP_MISC_LOW_POWER_MODE"
      sgroup "SMBBP_MISC_LOW_POWER_MODE (at 0x1640)"
        set &access:&cmd_addr %l (0x8016400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0 (DIG_LPM_DISABLED),1 (DIG_LPM_ENABLED)"
    tree.end
    tree "SMBBP_MISC_BOOT"
      sgroup "SMBBP_MISC_BOOT (at 0x1641)"
        set &access:&cmd_addr %l (0x8016410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BOOT_TIMER_EN                            = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADAPTIVE_BOOT_DIS                        = " "0 (ENABLED),1 (DISABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ADAPTIVE_BOOT_TYPE                       = " "0 (INCREASE_VBAT_WEAK_100MV),1 (INCREASE_VBAT_WEAK_TO_3V4)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOT_TIMER                               = " "0 (T_30S),1 (T_60S),2 (T_90S),3 (T_120S)"
    tree.end
    tree "SMBBP_MISC_BOOT_DONE"
      sgroup "SMBBP_MISC_BOOT_DONE (at 0x1642)"
        set &access:&cmd_addr %l (0x8016420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DONE                                     = " "0 (BOOT_NOT_DONE),1 (BOOT_DONE)"
    tree.end
    tree "SMBBP_MISC_VBAT_BOOT_THRES"
      sgroup "SMBBP_MISC_VBAT_BOOT_THRES (at 0x1643)"
        set &access:&cmd_addr %l (0x8016430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   STS                                      = "
    tree.end
    tree "SMBBP_MISC_TFT_WDOG"
      sgroup "SMBBP_MISC_TFT_WDOG (at 0x1644)"
        set &access:&cmd_addr %l (0x8016440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PET                                      = " "0, 1"
    tree.end
    tree "SMBBP_MISC_TFT"
      sgroup "SMBBP_MISC_TFT (at 0x1645)"
        set &access:&cmd_addr %l (0x8016450|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16450|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WDOG_EN                                  = " "0 (PM8026_ONLY_TFT_WDOG_DISABLED),1 (PM8026_ONLY_TFT_WDOG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   WDOG_DLY                                 = " "0 (PM8026_ONLY_TFT_WDOG_DLY_RSVD),1 (PM8026_ONLY_TFT_WDOG_DLY_2S),2 (PM8026_ONLY_TFT_WDOG_DLY_4S),3 (PM8026_ONLY_TFT_WDOG_DLY_6S)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WDOG_TIME                                = " "0 (PM8026_ONLY_TFT_WDOG_TIME_30S),1 (PM8026_ONLY_TFT_WDOG_TIME_60S),2 (PM8026_ONLY_TFT_WDOG_TIME_90S),3 (PM8026_ONLY_TFT_WDOG_TIME_120S)"
    tree.end
    tree "SMBBP_MISC_TFT_MODE_TYPE"
      sgroup "SMBBP_MISC_TFT_MODE_TYPE (at 0x1646)"
        set &access:&cmd_addr %l (0x8016460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SEL                                      = " "0 (PM8026_ONLY_POFF_AFTER_TFT),1 (PM8026_ONLY_WR_AFTER_TFT)"
    tree.end
    tree "SMBBP_MISC_TFT_MODE"
      sgroup "SMBBP_MISC_TFT_MODE (at 0x1647)"
        set &access:&cmd_addr %l (0x8016470|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16470|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CMD                                      = " "0 (PM8026_ONLY_NORMAL_OPERATION),1 (PM8026_ONLY_FORCE_ENTER_TFT)"
    tree.end
    tree "SMBBP_MISC_VPH_DISCHG_LD"
      sgroup "SMBBP_MISC_VPH_DISCHG_LD (at 0x1648)"
        set &access:&cmd_addr %l (0x8016480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_TFT_MODE                              = " "0 (PM8026_ONLY_VPH_DISCHG_LD_DISABLED_TFT),1 (PM8026_ONLY_VPH_DISCHG_LD_ENABLED_TFT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_NORMAL_PWROFF                         = " "0 (VPH_DISCHG_LD_DISABLED_NORMAL_POFF_WR),1 (VPH_DISCHG_LD_ENABLED_NORMAL_POFF_WR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TIME_SEL                                 = " "0 (T_25MS),1 (T_50MS),2 (T_75MS),3 (T_100MS),4 (T_250MS),5 (T_500MS),6 (T_750MS),7 (T_1000MS)"
    tree.end
    tree "SMBBP_MISC_RAW_XVDD_RB_SCRATCH"
      sgroup "SMBBP_MISC_RAW_XVDD_RB_SCRATCH (at 0x16cd)"
        set &access:&cmd_addr %l (0x8016cd0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16cd0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   REG                                      = "
    tree.end
    tree "SMBBP_MISC_RAW_DVDD_RB_SCRATCH"
      sgroup "SMBBP_MISC_RAW_DVDD_RB_SCRATCH (at 0x16ce)"
        set &access:&cmd_addr %l (0x8016ce0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16ce0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   REG                                      = "
    tree.end
    tree "SMBBP_MISC_SEC_ACCESS"
      sgroup "SMBBP_MISC_SEC_ACCESS (at 0x16d0)"
        set &access:&cmd_addr %l (0x8016d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBBP_MISC_SMBB_MISC_SPARE"
      sgroup "SMBBP_MISC_SMBB_MISC_SPARE (at 0x16d7)"
        set &access:&cmd_addr %l (0x8016d70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16d70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBBP_MISC_PERPH_RESET_CTL2"
      sgroup "SMBBP_MISC_PERPH_RESET_CTL2 (at 0x16d9)"
        set &access:&cmd_addr %l (0x8016d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_MISC_PERPH_RESET_CTL3"
      sgroup "SMBBP_MISC_PERPH_RESET_CTL3 (at 0x16da)"
        set &access:&cmd_addr %l (0x8016da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBBP_MISC_PERPH_RESET_CTL4"
      sgroup "SMBBP_MISC_PERPH_RESET_CTL4 (at 0x16db)"
        set &access:&cmd_addr %l (0x8016db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_MISC_PERPH_RESET_CTL5"
      sgroup "SMBBP_MISC_PERPH_RESET_CTL5 (at 0x16dc)"
        set &access:&cmd_addr %l (0x8016dc0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16dc0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_MISC_PERPH_RESET_CTL6"
      sgroup "SMBBP_MISC_PERPH_RESET_CTL6 (at 0x16dd)"
        set &access:&cmd_addr %l (0x8016dd0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16dd0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_MISC_PERPH_RESET_CTL7"
      sgroup "SMBBP_MISC_PERPH_RESET_CTL7 (at 0x16de)"
        set &access:&cmd_addr %l (0x8016de0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16de0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_MISC_PERPH_RESET_CTL8"
      sgroup "SMBBP_MISC_PERPH_RESET_CTL8 (at 0x16df)"
        set &access:&cmd_addr %l (0x8016df0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16df0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_MISC_INT_TEST1"
      sgroup "SMBBP_MISC_INT_TEST1 (at 0x16e0)"
        set &access:&cmd_addr %l (0x8016e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SMBBP_MISC_INT_TEST_VAL"
      sgroup "SMBBP_MISC_INT_TEST_VAL (at 0x16e1)"
        set &access:&cmd_addr %l (0x8016e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TFTWDOG_INT_VAL                          = " "0, 1"
    tree.end
    tree "SMBBP_MISC_CLOCK_TEST_SLEEP"
      sgroup "SMBBP_MISC_CLOCK_TEST_SLEEP (at 0x16e2)"
        set &access:&cmd_addr %l (0x8016e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LPM_GLOBAL_TIMESCALE_EN                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_MODE                                 = " "0 (SLP_CLK_SWITCH_HW_CNTRLED),1 (SLP_CLK_SWITCH_SW_CNTRLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_19P2M                                = " "0 (CLK_19P2M_NOT_REQED),1 (CLK_19P2M_REQED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   REQ_32K                                  = " "0 (CLK_32K_NOT_REQED),1 (CLK_32K_REQED)"
    tree.end
    tree "SMBBP_MISC_TFT_TEST"
      sgroup "SMBBP_MISC_TFT_TEST (at 0x16e3)"
        set &access:&cmd_addr %l (0x8016e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SPEEDUP                             = " "0 (PM8026_ONLY_TFT_WDOG_SPEEDUP_DISABLED),1 (PM8026_ONLY_TFT_WDOG_SPEEDUP_ENABLED)"
    tree.end
    tree "SMBBP_MISC_VPH_DISCHG_LD_TST"
      sgroup "SMBBP_MISC_VPH_DISCHG_LD_TST (at 0x16e4)"
        set &access:&cmd_addr %l (0x8016e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x16e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_ON                                 = " "0 (NOT_FORCED_ON),1 (FORCED_ON)"
    tree.end
  tree.end
tree.end
tree "SMBBP_USB_CHGPTH"
  tree "SMBBP_USB_CHGPTH"
    tree "SMBBP_USB_CHGPTH_PERPH_TYPE"
      sgroup "SMBBP_USB_CHGPTH_PERPH_TYPE (at 0x1304)"
        set &access:&cmd_addr %l (0x8013040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBBP_USB_CHGPTH_PERPH_SUBTYPE"
      sgroup "SMBBP_USB_CHGPTH_PERPH_SUBTYPE (at 0x1305)"
        set &access:&cmd_addr %l (0x8013050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBBP_USB_CHGPTH_PWR_PTH_STS"
      sgroup "SMBBP_USB_CHGPTH_PWR_PTH_STS (at 0x1308)"
        set &access:&cmd_addr %l (0x8013080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   POWER_PATH                               = " "0 (NOT_USED),1 (POWERED_FROM_BATTERY),2 (POWERED_FROM_USB_CHARGER),3 (reserved)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_CHG_PTH_STS"
      sgroup "SMBBP_USB_CHGPTH_USB_CHG_PTH_STS (at 0x1309)"
        set &access:&cmd_addr %l (0x8013090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   USB_VALID                                = " "0 (UNDER_VOLTAGE),1 (OVER_VOLTAGE),2 (IN_VALID_RANGE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_COARSE_DET                           = " "0 (BELOW_COARSE_DET_THR),1 (ABOVE_COARSE_DET_THR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TOP_OVP_FET_ON                           = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOTTOM_B2B_FETS_ON                       = " "0 (OFF),1 (ON)"
    tree.end
    tree "SMBBP_USB_CHGPTH_CHG_GONE_INT"
      sgroup "SMBBP_USB_CHGPTH_CHG_GONE_INT (at 0x130a)"
        set &access:&cmd_addr %l (0x80130a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x130a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STS                                      = " "0 (VCHG_LESS_THAN_VBAT),1 (REV_BST_DETECTED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_AICL_STS"
      sgroup "SMBBP_USB_CHGPTH_AICL_STS (at 0x130c)"
        set &access:&cmd_addr %l (0x80130c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x130c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   AICL_FSM                                 = " "0 (INITIAL),1 (WAIT),2 (STEP_UP),3 (IDLE),4 (STEP_DOWN),5 (reserved),6 (reserved),7 (DONE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   I_AUTO_EQ_I_TGT                          = " "0 (I_AUTO_NEQ_I_TGT),1 (I_AUTO_EQ_I_TGT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   I_TGT_EQ_I_MAX                           = " "0 (I_TGT_NEQ_I_MAX),1 (I_TGT_EQ_I_MAX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   T_DLY_IDLE_EXP                           = " "0 (T_N_EXP),1 (T_EXP)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VCHG_UV                                  = " "0 (VCHG_N_UV),1 (VCHG_UV)"
    tree.end
    tree "SMBBP_USB_CHGPTH_AICL_I_AUTO"
      sgroup "SMBBP_USB_CHGPTH_AICL_I_AUTO (at 0x130d)"
        set &access:&cmd_addr %l (0x80130d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x130d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STS                                      = "
    tree.end
    tree "SMBBP_USB_CHGPTH_AICL_I_TGT"
      sgroup "SMBBP_USB_CHGPTH_AICL_I_TGT (at 0x130e)"
        set &access:&cmd_addr %l (0x80130e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x130e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STS                                      = "
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_RT_STS"
      sgroup "SMBBP_USB_CHGPTH_INT_RT_STS (at 0x1310)"
        set &access:&cmd_addr %l (0x8013100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_RT_STS                           = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_RT_STS                          = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_RT_STS                       = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_RT_STS                    = " "0 (INT_RT_STS_LOW),1 (INT_RT_STS_HIGH)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_SET_TYPE"
      sgroup "SMBBP_USB_CHGPTH_INT_SET_TYPE (at 0x1311)"
        set &access:&cmd_addr %l (0x8013110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_TYPE                             = " "0 (PM8026_ONLY_LEVEL),1 (PM8026_ONLY_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_TYPE                         = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_TYPE                      = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_POLARITY_HIGH"
      sgroup "SMBBP_USB_CHGPTH_INT_POLARITY_HIGH (at 0x1312)"
        set &access:&cmd_addr %l (0x8013120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_HIGH                             = " "0 (PM8026_ONLY_HIGH_RISING_TRIGGER_DISABLED),1 (PM8026_ONLY_HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_HIGH                            = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_HIGH                         = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_HIGH                      = " "0 (HIGH_RISING_TRIGGER_DISABLED),1 (HIGH_RISING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_POLARITY_LOW"
      sgroup "SMBBP_USB_CHGPTH_INT_POLARITY_LOW (at 0x1313)"
        set &access:&cmd_addr %l (0x8013130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_LOW                              = " "0 (PM8026_ONLY_LOW_FALLING_TRIGGER_DISABLED),1 (PM8026_ONLY_LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_LOW                             = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_LOW                          = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_LOW                       = " "0 (LOW_FALLING_TRIGGER_DISABLED),1 (LOW_FALLING_TRIGGER_ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_LATCHED_CLR"
      sgroup "SMBBP_USB_CHGPTH_INT_LATCHED_CLR (at 0x1314)"
        set &access:&cmd_addr %l (0x8013140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_CLR                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_EN_SET"
      sgroup "SMBBP_USB_CHGPTH_INT_EN_SET (at 0x1315)"
        set &access:&cmd_addr %l (0x8013150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_EN_SET                           = " "0 (PM8026_ONLY_INT_DISABLED),1 (PM8026_ONLY_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_EN_CLR"
      sgroup "SMBBP_USB_CHGPTH_INT_EN_CLR (at 0x1316)"
        set &access:&cmd_addr %l (0x8013160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_EN_CLR                           = " "0 (PM8026_ONLY_INT_DISABLED),1 (PM8026_ONLY_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_LATCHED_STS"
      sgroup "SMBBP_USB_CHGPTH_INT_LATCHED_STS (at 0x1318)"
        set &access:&cmd_addr %l (0x8013180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_LATCHED_STS                      = " "0 (PM8026_ONLY_NO_INT_LATCHED),1 (PM8026_ONLY_INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_PENDING_STS"
      sgroup "SMBBP_USB_CHGPTH_INT_PENDING_STS (at 0x1319)"
        set &access:&cmd_addr %l (0x8013190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_STS                              = " "0 (PM8026_ONLY_NO_INT_PENDING),1 (PM8026_ONLY_INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_STS                             = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_STS                          = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_STS                       = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_MID_SEL"
      sgroup "SMBBP_USB_CHGPTH_INT_MID_SEL (at 0x131a)"
        set &access:&cmd_addr %l (0x80131a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x131a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_PRIORITY"
      sgroup "SMBBP_USB_CHGPTH_INT_PRIORITY (at 0x131b)"
        set &access:&cmd_addr %l (0x80131b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x131b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "SMBBP_USB_CHGPTH_CHG_PTH_CTL"
      sgroup "SMBBP_USB_CHGPTH_CHG_PTH_CTL (at 0x1340)"
        set &access:&cmd_addr %l (0x8013400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_PTH_PRIORITY_SEL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHG_PTH_SWITCH_TIME                      = " "0 (T_60US),1 (T_80US),2 (T_100US),3 (T_120US)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_CTL"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_CTL (at 0x1342)"
        set &access:&cmd_addr %l (0x8013420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   USB_OVP_THR                              = " "0 (PM8026_OVP_5P5V_ALSO_PM8110_OVP_5P5V),1 (PM8026_OVP_6V_ALSO_PM8110_OVP_6V),2 (PM8026_OVP_6P5V_ALSO_PM8110_OVP_6P5V),3 (PM8026_OVP_7V_ALSO_PM8110_OVP_7V),4 (PM8026_OVP_9P5V_ALSO_PM8110_OVP_5P5V),5 (PM8026_OVP_10V_ALSO_PM8110_OVP_6V),6 (PM8026_OVP_10P5V_ALSO_PM8110_OVP_6P5V),7 (PM8026_OVP_11V_ALSO_PM8110_OVP_7V)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   USB_UVD_THR                              = " "0 (RISING_4P25V_FALLING_4P05V),1 (RISING_4P35V_FALLING_4P15V),2 (RISING_4P45V_FALLING_4P25V),3 (RISING_4P55V_FALLING_4P35V)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USB_VALID_DEB                            = " "0 (DEB_0MS),1 (DEB_5MS),2 (DEB_10MS),3 (DEB_20MS)"
    tree.end
    tree "SMBBP_USB_CHGPTH_IUSB_MAX_EN"
      sgroup "SMBBP_USB_CHGPTH_IUSB_MAX_EN (at 0x1343)"
        set &access:&cmd_addr %l (0x8013430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_IUSB_MAX"
      sgroup "SMBBP_USB_CHGPTH_IUSB_MAX (at 0x1344)"
        set &access:&cmd_addr %l (0x8013440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IUSB_MAX                                 = "
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_SUSP"
      sgroup "SMBBP_USB_CHGPTH_USB_SUSP (at 0x1347)"
        set &access:&cmd_addr %l (0x8013470|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13470|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_SUSPEND                              = " "0 (USB_NOT_SUSPENDED),1 (USB_SUSPENDED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OTG_CTL"
      sgroup "SMBBP_USB_CHGPTH_USB_OTG_CTL (at 0x1348)"
        set &access:&cmd_addr %l (0x8013480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_OTG_EN                               = " "0 (PM8026_ONLY_USB_OTG_DISABLED),1 (PM8026_ONLY_USB_OTG_ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_ENUM_TIMER_STOP"
      sgroup "SMBBP_USB_CHGPTH_ENUM_TIMER_STOP (at 0x134e)"
        set &access:&cmd_addr %l (0x80134e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x134e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STOP                                     = " "0 (ENUM_TIMER_STOP),1 (reserved)"
    tree.end
    tree "SMBBP_USB_CHGPTH_ENUM_TIMER"
      sgroup "SMBBP_USB_CHGPTH_ENUM_TIMER (at 0x134f)"
        set &access:&cmd_addr %l (0x80134f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x134f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL                                      = " "0 (ENUM_TIMER_10S),1 (ENUM_TIMER_20S),2 (ENUM_TIMER_30S),3 (ENUM_TIMER_60S)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_FORCE"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_FORCE (at 0x1350)"
        set &access:&cmd_addr %l (0x8013500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USB_OVP_FORCE                            = " "0 (NO_FORCE),1 (reserved),2 (FORCE_OFF),3 (FORCE_ON)"
    tree.end
    tree "SMBBP_USB_CHGPTH_FLCB_IUSB_MAX_LIM"
      sgroup "SMBBP_USB_CHGPTH_FLCB_IUSB_MAX_LIM (at 0x1351)"
        set &access:&cmd_addr %l (0x8013510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (FLCB_IUSB_MAX_LIM_IGNORED),1 (FLCB_IUSB_MAX_LIM_RESPECTED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_OCP_THR"
      sgroup "SMBBP_USB_CHGPTH_OCP_THR (at 0x1352)"
        set &access:&cmd_addr %l (0x8013520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL                                      = " "0 (OCP_THR_200MA),1 (OCP_THR_500MA),2 (OCP_THR_900MA),3 (OCP_THR_RSVD)"
    tree.end
    tree "SMBBP_USB_CHGPTH_OCP_CLR"
      sgroup "SMBBP_USB_CHGPTH_OCP_CLR (at 0x1353)"
        set &access:&cmd_addr %l (0x8013530|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13530|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULSE                                    = " "0 (OCP_LATCH_NOT_CLEARED),1 (OCP_LATCH_CLEARED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_OCP_SW"
      sgroup "SMBBP_USB_CHGPTH_OCP_SW (at 0x1354)"
        set &access:&cmd_addr %l (0x8013540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTRL                                     = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_AICL_CTL"
      sgroup "SMBBP_USB_CHGPTH_AICL_CTL (at 0x1360)"
        set &access:&cmd_addr %l (0x8013600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AICL_EN                                  = " "0 (AICL_DISABLED),1 (AICL_ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_AICL_DLY"
      sgroup "SMBBP_USB_CHGPTH_AICL_DLY (at 0x1361)"
        set &access:&cmd_addr %l (0x8013610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   T_DLY_IDLE                               = " "0 (T_10MS),1 (T_20MS),2 (T_50MS),3 (T_100MS)"
    tree.end
    tree "SMBBP_USB_CHGPTH_AICL_DEB"
      sgroup "SMBBP_USB_CHGPTH_AICL_DEB (at 0x1362)"
        set &access:&cmd_addr %l (0x8013620|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13620|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VCHG_UV_RISING_DEB                       = " "0 (T_1MS),1 (T_5MS),2 (T_10MS),3 (T_20MS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VCHG_UV_FALLING_DEB                      = " "0 (T_1MS),1 (T_5MS),2 (T_10MS),3 (T_20MS)"
    tree.end
    tree "SMBBP_USB_CHGPTH_AICL_VCHG_UV_CTL"
      sgroup "SMBBP_USB_CHGPTH_AICL_VCHG_UV_CTL (at 0x1363)"
        set &access:&cmd_addr %l (0x8013630|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13630|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_VCHG_UV_SRC                         = " "0 (AICL_VCHG_UV),1 (BUCK_VIN_LOOP)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_VCHG_UV_HYST                        = " "0 (UV_HYST_25MV),1 (UV_HYST_50MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AICL_VCHG_UV_PROG                        = " "0 (VCHG_UV_4P2V),1 (VCHG_UV_4P3V),2 (VCHG_UV_4P4V),3 (VCHG_UV_4P5V)"
    tree.end
    tree "SMBBP_USB_CHGPTH_SEC_ACCESS"
      sgroup "SMBBP_USB_CHGPTH_SEC_ACCESS (at 0x13d0)"
        set &access:&cmd_addr %l (0x8013d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBBP_USB_CHGPTH_PERPH_RESET_CTL2"
      sgroup "SMBBP_USB_CHGPTH_PERPH_RESET_CTL2 (at 0x13d9)"
        set &access:&cmd_addr %l (0x8013d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_USB_CHGPTH_PERPH_RESET_CTL3"
      sgroup "SMBBP_USB_CHGPTH_PERPH_RESET_CTL3 (at 0x13da)"
        set &access:&cmd_addr %l (0x8013da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBBP_USB_CHGPTH_PERPH_RESET_CTL4"
      sgroup "SMBBP_USB_CHGPTH_PERPH_RESET_CTL4 (at 0x13db)"
        set &access:&cmd_addr %l (0x8013db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_PERPH_RESET_CTL5"
      sgroup "SMBBP_USB_CHGPTH_PERPH_RESET_CTL5 (at 0x13dc)"
        set &access:&cmd_addr %l (0x8013dc0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13dc0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBBP_USB_CHGPTH_PERPH_RESET_CTL6"
      sgroup "SMBBP_USB_CHGPTH_PERPH_RESET_CTL6 (at 0x13dd)"
        set &access:&cmd_addr %l (0x8013dd0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13dd0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_SPARE"
      sgroup "SMBBP_USB_CHGPTH_USB_SPARE (at 0x13df)"
        set &access:&cmd_addr %l (0x8013df0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13df0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_TEST1"
      sgroup "SMBBP_USB_CHGPTH_INT_TEST1 (at 0x13e0)"
        set &access:&cmd_addr %l (0x8013e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_INT_TEST_VAL"
      sgroup "SMBBP_USB_CHGPTH_INT_TEST_VAL (at 0x13e1)"
        set &access:&cmd_addr %l (0x8013e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USB_OCP_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VALID_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COARSE_DET_USB_INT_VAL                   = " "0, 1"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TST0"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TST0 (at 0x13e2)"
        set &access:&cmd_addr %l (0x8013e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_VREG2P4V                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OVP_DTEST1_OUT_SEL_USB                   = " "0, 1, 2, 3"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TST1"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TST1 (at 0x13e3)"
        set &access:&cmd_addr %l (0x8013e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OVP_DTEST2_OUT_SEL_USB                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OVP_DTEST3_OUT_SEL_USB                   = " "0, 1, 2, 3"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TST2"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TST2 (at 0x13e4)"
        set &access:&cmd_addr %l (0x8013e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   USBIN_LLIMIT_FALLHYS                     = " "0 (T_HYS_0US),1 (T_HYS_1US),2 (T_HYS_2US),3 (T_HYS_3US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OVP_DTEST4_OUT_SEL_USB                   = " "0, 1, 2, 3"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TST3"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TST3 (at 0x13e5)"
        set &access:&cmd_addr %l (0x8013e50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_USBISNS_ATEST                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB_OVP_ISNS_TRIM_EN                     = " "0, 1"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TST4"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TST4 (at 0x13e6)"
        set &access:&cmd_addr %l (0x8013e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_DTEST_IN_SEL_USB                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OVP_DTEST_IN_SEL_USB                     = " "0, 1"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TST5"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TST5 (at 0x13e7)"
        set &access:&cmd_addr %l (0x8013e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_GONE_CHG_OK_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USBIN_ULIMIT_FALLHYS                     = " "0 (T_HYS_400NS),1 (T_HYS_600NS),2 (T_HYS_800NS),3 (T_HYS_1US)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TST6"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TST6 (at 0x13e8)"
        set &access:&cmd_addr %l (0x8013e80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   USB_BBM_RISEHYS                          = " "0 (T_HYS_0US),1 (T_HYS_2US),2 (T_HYS_4US),3 (T_HYS_8US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USB_BBM_FALLHYS                          = " "0 (T_HYS_0US),1 (T_HYS_0P5US),2 (T_HYS_1US),3 (T_HYS_2US)"
    tree.end
    tree "SMBBP_USB_CHGPTH_COMP_OVR0"
      sgroup "SMBBP_USB_CHGPTH_COMP_OVR0 (at 0x13e9)"
        set &access:&cmd_addr %l (0x8013e90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13e90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   USB_OCP                                  = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   COARSE_DET_USBIN                         = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USB_BBM                                  = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_USB_CHGPTH_COMP_OVR1"
      sgroup "SMBBP_USB_CHGPTH_COMP_OVR1 (at 0x13ea)"
        set &access:&cmd_addr %l (0x8013ea0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13ea0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   AICL_VCHG_UV                             = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHG_GONE                                 = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   USBIN_ULIMIT_OK                          = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USBIN_LLIMIT_OK                          = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_COMP_OVR_GLOBAL"
      sgroup "SMBBP_USB_CHGPTH_USB_COMP_OVR_GLOBAL (at 0x13eb)"
        set &access:&cmd_addr %l (0x8013eb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13eb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BYP_EN                                   = " "0 (GLOBAL_BYPASS_DISABLED),1 (ALL_COMPARATORS_BYPASSED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_ENUM_TIMER_EN"
      sgroup "SMBBP_USB_CHGPTH_ENUM_TIMER_EN (at 0x13ec)"
        set &access:&cmd_addr %l (0x8013ec0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13ec0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "SMBBP_USB_CHGPTH_CHG_GONE_REV_BST"
      sgroup "SMBBP_USB_CHGPTH_CHG_GONE_REV_BST (at 0x13ed)"
        set &access:&cmd_addr %l (0x8013ed0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13ed0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DET_EN                                   = " "0 (REV_BST_DET_DOES_NOT_TRIGGER_CHG_GONE),1 (REV_BST_DET_TRIGGERS_CHG_GONE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCK_EN_MASK                              = " "0 (REV_BST_DET_DOES_NOT_DISABLE_BUCK),1 (REV_BST_DET_DOES_DISABLE_BUCK)"
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_TRIM_NUM"
      sgroup "SMBBP_USB_CHGPTH_USB_TRIM_NUM (at 0x13f0)"
        set &access:&cmd_addr %l (0x8013f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_OVP_TRIM"
      sgroup "SMBBP_USB_CHGPTH_USB_OVP_TRIM (at 0x13f1)"
        set &access:&cmd_addr %l (0x8013f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRIM_POL                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_VOFFSET_ADJ                         = "
    tree.end
    tree "SMBBP_USB_CHGPTH_USB_ICHG_GAIN"
      sgroup "SMBBP_USB_CHGPTH_USB_ICHG_GAIN (at 0x13f2)"
        set &access:&cmd_addr %l (0x8013f20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x13f20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM                                     = "
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&cmd_addr %l (0x8006000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&cmd_addr %l (0x8006010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&cmd_addr %l (0x8006020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&cmd_addr %l (0x8006030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&cmd_addr %l (0x8006040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&cmd_addr %l (0x8006050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&cmd_addr %l (0x8006080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&cmd_addr %l (0x80060b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&cmd_addr %l (0x80060c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&cmd_addr %l (0x80060d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&cmd_addr %l (0x80060e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x60e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&cmd_addr %l (0x8006100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&cmd_addr %l (0x8006110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&cmd_addr %l (0x8006120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&cmd_addr %l (0x8006130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&cmd_addr %l (0x8006140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&cmd_addr %l (0x8006150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&cmd_addr %l (0x8006160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&cmd_addr %l (0x8006180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&cmd_addr %l (0x8006190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&cmd_addr %l (0x80061a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&cmd_addr %l (0x80061b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x61b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&cmd_addr %l (0x8006400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&cmd_addr %l (0x8006d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&cmd_addr %l (0x8006d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&cmd_addr %l (0x8006da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&cmd_addr %l (0x8006db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&cmd_addr %l (0x8006e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&cmd_addr %l (0x8006e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&cmd_addr %l (0x8006e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      sgroup "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
        set &access:&cmd_addr %l (0x8006430|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6430|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&cmd_addr %l (0x8006440|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6440|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&cmd_addr %l (0x8006450|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6450|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&cmd_addr %l (0x8006460|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6460|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&cmd_addr %l (0x8006470|((&sid+0x2)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x6470|((&sid+0x2)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      sgroup "TEMP_ALARM_REVISION1 (at 0x2400)"
        set &access:&cmd_addr %l (0x8024000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      sgroup "TEMP_ALARM_REVISION2 (at 0x2401)"
        set &access:&cmd_addr %l (0x8024010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      sgroup "TEMP_ALARM_REVISION3 (at 0x2402)"
        set &access:&cmd_addr %l (0x8024020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      sgroup "TEMP_ALARM_REVISION4 (at 0x2403)"
        set &access:&cmd_addr %l (0x8024030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      sgroup "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
        set &access:&cmd_addr %l (0x8024040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      sgroup "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
        set &access:&cmd_addr %l (0x8024050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      sgroup "TEMP_ALARM_STATUS1 (at 0x2408)"
        set &access:&cmd_addr %l (0x8024080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0 (STAGE_0),1 (STAGE_1),2 (STAGE_2),3 (STAGE_3)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      sgroup "TEMP_ALARM_INT_RT_STS (at 0x2410)"
        set &access:&cmd_addr %l (0x8024100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      sgroup "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
        set &access:&cmd_addr %l (0x8024110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      sgroup "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
        set &access:&cmd_addr %l (0x8024120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      sgroup "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
        set &access:&cmd_addr %l (0x8024130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      sgroup "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
        set &access:&cmd_addr %l (0x8024140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      sgroup "TEMP_ALARM_INT_EN_SET (at 0x2415)"
        set &access:&cmd_addr %l (0x8024150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      sgroup "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
        set &access:&cmd_addr %l (0x8024160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      sgroup "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
        set &access:&cmd_addr %l (0x8024180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      sgroup "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
        set &access:&cmd_addr %l (0x8024190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      sgroup "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
        set &access:&cmd_addr %l (0x80241a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x241a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      sgroup "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
        set &access:&cmd_addr %l (0x80241b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x241b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
        set &access:&cmd_addr %l (0x8024400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_OVERRIDE),1 (OVERTEMP_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
        set &access:&cmd_addr %l (0x8024420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      sgroup "TEMP_ALARM_EN_CTL1 (at 0x2446)"
        set &access:&cmd_addr %l (0x8024460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      sgroup "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
        set &access:&cmd_addr %l (0x8024d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
        set &access:&cmd_addr %l (0x8024d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
        set &access:&cmd_addr %l (0x8024d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
        set &access:&cmd_addr %l (0x8024da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
        set &access:&cmd_addr %l (0x8024db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      sgroup "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
        set &access:&cmd_addr %l (0x8024e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      sgroup "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
        set &access:&cmd_addr %l (0x8024e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TEST1"
      sgroup "TEMP_ALARM_TEST1 (at 0x24e2)"
        set &access:&cmd_addr %l (0x8024e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST1_UPR_STAT_I_DTEST2_LWR_STAT_I)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0 (USE_INTERNAL_VTEMP),1 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0 (OFF),1 (ATEST_VTEMP_BUF),2 (ATEST_UPR_DAC),3 (ATEST_LWR_DAC)"
    tree.end
    tree "TEMP_ALARM_TEST2"
      sgroup "TEMP_ALARM_TEST2 (at 0x24e3)"
        set &access:&cmd_addr %l (0x8024e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0 (BUFFERED),1 (UNBUFFERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0 (TRISTATE),1 (DTEST2_DTEST1_TEMP_STATUS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0 (NORMAL_OPERATION),1 (USE_ATEST_FOR_THRESHOLDS)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      sgroup "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
        set &access:&cmd_addr %l (0x8024f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      sgroup "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
        set &access:&cmd_addr %l (0x8024f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x24f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&cmd_addr %l (0x80fe000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&cmd_addr %l (0x80fe010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&cmd_addr %l (0x80fe020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&cmd_addr %l (0x80fe030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&cmd_addr %l (0x80fe040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&cmd_addr %l (0x80fe050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&cmd_addr %l (0x80fe080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&cmd_addr %l (0x80fe090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&cmd_addr %l (0x80fe0a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe0a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&cmd_addr %l (0x80fe0b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfe0b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&cmd_addr %l (0x80fed00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfed00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&cmd_addr %l (0x80fed90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfed90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&cmd_addr %l (0x80feda0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfeda0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&cmd_addr %l (0x80fedb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfedb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&cmd_addr %l (0x80fee00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&cmd_addr %l (0x80fee10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&cmd_addr %l (0x80fee20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&cmd_addr %l (0x80fee30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&cmd_addr %l (0x80fee40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&cmd_addr %l (0x80fee50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&cmd_addr %l (0x80fee60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xfee60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end
tree "VADC1_USR"
  tree "VADC1_USR"
    tree "VADC1_USR_REVISION1"
      sgroup "VADC1_USR_REVISION1 (at 0x3100)"
        set &access:&cmd_addr %l (0x8031000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION2"
      sgroup "VADC1_USR_REVISION2 (at 0x3101)"
        set &access:&cmd_addr %l (0x8031010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC1_USR_REVISION3"
      sgroup "VADC1_USR_REVISION3 (at 0x3102)"
        set &access:&cmd_addr %l (0x8031020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC1_USR_REVISION4"
      sgroup "VADC1_USR_REVISION4 (at 0x3103)"
        set &access:&cmd_addr %l (0x8031030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC1_USR_PERPH_TYPE"
      sgroup "VADC1_USR_PERPH_TYPE (at 0x3104)"
        set &access:&cmd_addr %l (0x8031040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC1_USR_PERPH_SUBTYPE"
      sgroup "VADC1_USR_PERPH_SUBTYPE (at 0x3105)"
        set &access:&cmd_addr %l (0x8031050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC1_USR_STATUS1"
      sgroup "VADC1_USR_STATUS1 (at 0x3108)"
        set &access:&cmd_addr %l (0x8031080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC1_USR_STATUS2"
      sgroup "VADC1_USR_STATUS2 (at 0x3109)"
        set &access:&cmd_addr %l (0x8031090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_RT_STS"
      sgroup "VADC1_USR_INT_RT_STS (at 0x3110)"
        set &access:&cmd_addr %l (0x8031100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC1_USR_INT_SET_TYPE"
      sgroup "VADC1_USR_INT_SET_TYPE (at 0x3111)"
        set &access:&cmd_addr %l (0x8031110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_HIGH"
      sgroup "VADC1_USR_INT_POLARITY_HIGH (at 0x3112)"
        set &access:&cmd_addr %l (0x8031120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_POLARITY_LOW"
      sgroup "VADC1_USR_INT_POLARITY_LOW (at 0x3113)"
        set &access:&cmd_addr %l (0x8031130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_CLR"
      sgroup "VADC1_USR_INT_LATCHED_CLR (at 0x3114)"
        set &access:&cmd_addr %l (0x8031140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC1_USR_INT_EN_SET"
      sgroup "VADC1_USR_INT_EN_SET (at 0x3115)"
        set &access:&cmd_addr %l (0x8031150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_EN_CLR"
      sgroup "VADC1_USR_INT_EN_CLR (at 0x3116)"
        set &access:&cmd_addr %l (0x8031160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC1_USR_INT_LATCHED_STS"
      sgroup "VADC1_USR_INT_LATCHED_STS (at 0x3118)"
        set &access:&cmd_addr %l (0x8031180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC1_USR_INT_PENDING_STS"
      sgroup "VADC1_USR_INT_PENDING_STS (at 0x3119)"
        set &access:&cmd_addr %l (0x8031190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC1_USR_INT_MID_SEL"
      sgroup "VADC1_USR_INT_MID_SEL (at 0x311a)"
        set &access:&cmd_addr %l (0x80311a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x311a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC1_USR_INT_PRIORITY"
      sgroup "VADC1_USR_INT_PRIORITY (at 0x311b)"
        set &access:&cmd_addr %l (0x80311b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x311b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC1_USR_MODE_CTL"
      sgroup "VADC1_USR_MODE_CTL (at 0x3140)"
        set &access:&cmd_addr %l (0x8031400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC1_USR_EN_CTL1"
      sgroup "VADC1_USR_EN_CTL1 (at 0x3146)"
        set &access:&cmd_addr %l (0x8031460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC1_USR_ADC_CH_SEL_CTL"
      sgroup "VADC1_USR_ADC_CH_SEL_CTL (at 0x3148)"
        set &access:&cmd_addr %l (0x8031480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC1_USR_ADC_DIG_PARAM"
      sgroup "VADC1_USR_ADC_DIG_PARAM (at 0x3150)"
        set &access:&cmd_addr %l (0x8031500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC1_USR_HW_SETTLE_DELAY"
      sgroup "VADC1_USR_HW_SETTLE_DELAY (at 0x3151)"
        set &access:&cmd_addr %l (0x8031510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC1_USR_CONV_REQ"
      sgroup "VADC1_USR_CONV_REQ (at 0x3152)"
        set &access:&cmd_addr %l (0x8031520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC1_USR_CONV_SEQ_CTL"
      sgroup "VADC1_USR_CONV_SEQ_CTL (at 0x3154)"
        set &access:&cmd_addr %l (0x8031540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC1_USR_CONV_SEQ_TRIG_CTL"
      sgroup "VADC1_USR_CONV_SEQ_TRIG_CTL (at 0x3155)"
        set &access:&cmd_addr %l (0x8031550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_CTL"
      sgroup "VADC1_USR_MEAS_INTERVAL_CTL (at 0x3157)"
        set &access:&cmd_addr %l (0x8031570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC1_USR_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC1_USR_MEAS_INTERVAL_OP_CTL (at 0x3159)"
        set &access:&cmd_addr %l (0x8031590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC1_USR_FAST_AVG_CTL"
      sgroup "VADC1_USR_FAST_AVG_CTL (at 0x315a)"
        set &access:&cmd_addr %l (0x80315a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x315a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC1_USR_FAST_AVG_EN"
      sgroup "VADC1_USR_FAST_AVG_EN (at 0x315b)"
        set &access:&cmd_addr %l (0x80315b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x315b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC1_USR_LOW_THR0"
      sgroup "VADC1_USR_LOW_THR0 (at 0x315c)"
        set &access:&cmd_addr %l (0x80315c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x315c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC1_USR_LOW_THR1"
      sgroup "VADC1_USR_LOW_THR1 (at 0x315d)"
        set &access:&cmd_addr %l (0x80315d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x315d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR0"
      sgroup "VADC1_USR_HIGH_THR0 (at 0x315e)"
        set &access:&cmd_addr %l (0x80315e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x315e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC1_USR_HIGH_THR1"
      sgroup "VADC1_USR_HIGH_THR1 (at 0x315f)"
        set &access:&cmd_addr %l (0x80315f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x315f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC1_USR_DATA0"
      sgroup "VADC1_USR_DATA0 (at 0x3160)"
        set &access:&cmd_addr %l (0x8031600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC1_USR_DATA1"
      sgroup "VADC1_USR_DATA1 (at 0x3161)"
        set &access:&cmd_addr %l (0x8031610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC1_USR_SEC_ACCESS"
      sgroup "VADC1_USR_SEC_ACCESS (at 0x31d0)"
        set &access:&cmd_addr %l (0x8031d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL1"
      sgroup "VADC1_USR_PERPH_RESET_CTL1 (at 0x31d8)"
        set &access:&cmd_addr %l (0x8031d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL2"
      sgroup "VADC1_USR_PERPH_RESET_CTL2 (at 0x31d9)"
        set &access:&cmd_addr %l (0x8031d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL3"
      sgroup "VADC1_USR_PERPH_RESET_CTL3 (at 0x31da)"
        set &access:&cmd_addr %l (0x8031da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC1_USR_PERPH_RESET_CTL4"
      sgroup "VADC1_USR_PERPH_RESET_CTL4 (at 0x31db)"
        set &access:&cmd_addr %l (0x8031db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST1"
      sgroup "VADC1_USR_INT_TEST1 (at 0x31e0)"
        set &access:&cmd_addr %l (0x8031e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC1_USR_INT_TEST_VAL"
      sgroup "VADC1_USR_INT_TEST_VAL (at 0x31e1)"
        set &access:&cmd_addr %l (0x8031e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC1_USR_TEST1_ADC_ANA_PARAM"
      sgroup "VADC1_USR_TEST1_ADC_ANA_PARAM (at 0x31e2)"
        set &access:&cmd_addr %l (0x8031e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC1_USR_TEST2_ADC_DIG_PARAM"
      sgroup "VADC1_USR_TEST2_ADC_DIG_PARAM (at 0x31e3)"
        set &access:&cmd_addr %l (0x8031e30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0 (DEM_DISABLED),1 (DEM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0 (DECI_SEL),1 (FILTOUT_15_0),2 (FILTOUT_25_16),3 (DECI_SEL1)"
    tree.end
    tree "VADC1_USR_TEST3_ADC_RSV"
      sgroup "VADC1_USR_TEST3_ADC_RSV (at 0x31e4)"
        set &access:&cmd_addr %l (0x8031e40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0 (SINC2_OUTPUT),1 (SINC1_OUTPUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0 (RESET_DIG_FILT_FALSE),1 (RESET_DIG_FILT_TRUE)"
    tree.end
    tree "VADC1_USR_TEST4_ADC_ATEST"
      sgroup "VADC1_USR_TEST4_ADC_ATEST (at 0x31e5)"
        set &access:&cmd_addr %l (0x8031e50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VOCM_0P60),1 (VOCM_0P65),2 (VOCM_0P70),3 (VOCM_0P75)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0 (ATEST3_DISABLED),1 (VTH_N),2 (VTH_P),3 (VICM),4 (VOCM),5 (VREFN),6 (VREFMID),7 (VREFP)"
    tree.end
    tree "VADC1_USR_TEST5_AMUX_ATEST"
      sgroup "VADC1_USR_TEST5_AMUX_ATEST (at 0x31e6)"
        set &access:&cmd_addr %l (0x8031e60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_EN                                   = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
    tree.end
    tree "VADC1_USR_TEST6_DTEST"
      sgroup "VADC1_USR_TEST6_DTEST (at 0x31e7)"
        set &access:&cmd_addr %l (0x8031e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VADC1_USR_TRIM_NUM"
      sgroup "VADC1_USR_TRIM_NUM (at 0x31f0)"
        set &access:&cmd_addr %l (0x8031f00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31f00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC1_USR_TRIM1_ADC"
      sgroup "VADC1_USR_TRIM1_ADC (at 0x31f1)"
        set &access:&cmd_addr %l (0x8031f10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31f10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DAC_REF                                  = "
    tree.end
    tree "VADC1_USR_TRIM1_AMUX"
      sgroup "VADC1_USR_TRIM1_AMUX (at 0x31f2)"
        set &access:&cmd_addr %l (0x8031f20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31f20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRESCALE_167_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM2_AMUX"
      sgroup "VADC1_USR_TRIM2_AMUX (at 0x31f3)"
        set &access:&cmd_addr %l (0x8031f30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31f30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
    tree "VADC1_USR_TRIM4_AMUX"
      sgroup "VADC1_USR_TRIM4_AMUX (at 0x31f4)"
        set &access:&cmd_addr %l (0x8031f40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31f40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_LOW_OFFSET                           = "
    tree.end
    tree "VADC1_USR_TRIM5_AMUX"
      sgroup "VADC1_USR_TRIM5_AMUX (at 0x31f5)"
        set &access:&cmd_addr %l (0x8031f50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x31f50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_HIGH_OFFSET                          = "
    tree.end
  tree.end
tree.end
tree "VADC2_BTM"
  tree "VADC2_BTM"
    tree "VADC2_BTM_REVISION1"
      sgroup "VADC2_BTM_REVISION1 (at 0x3400)"
        set &access:&cmd_addr %l (0x8034000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION2"
      sgroup "VADC2_BTM_REVISION2 (at 0x3401)"
        set &access:&cmd_addr %l (0x8034010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION3"
      sgroup "VADC2_BTM_REVISION3 (at 0x3402)"
        set &access:&cmd_addr %l (0x8034020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC2_BTM_REVISION4"
      sgroup "VADC2_BTM_REVISION4 (at 0x3403)"
        set &access:&cmd_addr %l (0x8034030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC2_BTM_PERPH_TYPE"
      sgroup "VADC2_BTM_PERPH_TYPE (at 0x3404)"
        set &access:&cmd_addr %l (0x8034040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC2_BTM_PERPH_SUBTYPE"
      sgroup "VADC2_BTM_PERPH_SUBTYPE (at 0x3405)"
        set &access:&cmd_addr %l (0x8034050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC2_BTM_STATUS1"
      sgroup "VADC2_BTM_STATUS1 (at 0x3408)"
        set &access:&cmd_addr %l (0x8034080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC2_BTM_STATUS2"
      sgroup "VADC2_BTM_STATUS2 (at 0x3409)"
        set &access:&cmd_addr %l (0x8034090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC2_BTM_STATUS_LOW"
      sgroup "VADC2_BTM_STATUS_LOW (at 0x340a)"
        set &access:&cmd_addr %l (0x80340a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x340a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW                                   = " "0 (M7_LOW_FALSE),1 (M7_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW                                   = " "0 (M6_LOW_FALSE),1 (M6_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW                                   = " "0 (M5_LOW_FALSE),1 (M5_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW                                   = " "0 (M4_LOW_FALSE),1 (M4_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW                                   = " "0 (M3_LOW_FALSE),1 (M3_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW                                   = " "0 (M2_LOW_FALSE),1 (M2_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW                                   = " "0 (M1_LOW_FALSE),1 (M1_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW                                   = " "0 (M0_LOW_FALSE),1 (M0_LOW_TRUE)"
    tree.end
    tree "VADC2_BTM_STATUS_HIGH"
      sgroup "VADC2_BTM_STATUS_HIGH (at 0x340b)"
        set &access:&cmd_addr %l (0x80340b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x340b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH                                  = " "0 (M7_HIGH_FALSE),1 (M7_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH                                  = " "0 (M6_HIGH_FALSE),1 (M6_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH                                  = " "0 (M5_HIGH_FALSE),1 (M5_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH                                  = " "0 (M4_HIGH_FALSE),1 (M4_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH                                  = " "0 (M3_HIGH_FALSE),1 (M3_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH                                  = " "0 (M2_HIGH_FALSE),1 (M2_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH                                  = " "0 (M1_HIGH_FALSE),1 (M1_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH                                  = " "0 (M0_HIGH_FALSE),1 (M0_HIGH_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_RT_STS"
      sgroup "VADC2_BTM_INT_RT_STS (at 0x3410)"
        set &access:&cmd_addr %l (0x8034100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC2_BTM_INT_SET_TYPE"
      sgroup "VADC2_BTM_INT_SET_TYPE (at 0x3411)"
        set &access:&cmd_addr %l (0x8034110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_POLARITY_HIGH"
      sgroup "VADC2_BTM_INT_POLARITY_HIGH (at 0x3412)"
        set &access:&cmd_addr %l (0x8034120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_POLARITY_LOW"
      sgroup "VADC2_BTM_INT_POLARITY_LOW (at 0x3413)"
        set &access:&cmd_addr %l (0x8034130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC2_BTM_INT_LATCHED_CLR"
      sgroup "VADC2_BTM_INT_LATCHED_CLR (at 0x3414)"
        set &access:&cmd_addr %l (0x8034140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC2_BTM_INT_EN_SET"
      sgroup "VADC2_BTM_INT_EN_SET (at 0x3415)"
        set &access:&cmd_addr %l (0x8034150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_BTM_INT_EN_CLR"
      sgroup "VADC2_BTM_INT_EN_CLR (at 0x3416)"
        set &access:&cmd_addr %l (0x8034160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC2_BTM_INT_LATCHED_STS"
      sgroup "VADC2_BTM_INT_LATCHED_STS (at 0x3418)"
        set &access:&cmd_addr %l (0x8034180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_PENDING_STS"
      sgroup "VADC2_BTM_INT_PENDING_STS (at 0x3419)"
        set &access:&cmd_addr %l (0x8034190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_MID_SEL"
      sgroup "VADC2_BTM_INT_MID_SEL (at 0x341a)"
        set &access:&cmd_addr %l (0x80341a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x341a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC2_BTM_INT_PRIORITY"
      sgroup "VADC2_BTM_INT_PRIORITY (at 0x341b)"
        set &access:&cmd_addr %l (0x80341b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x341b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC2_BTM_MODE_CTL"
      sgroup "VADC2_BTM_MODE_CTL (at 0x3440)"
        set &access:&cmd_addr %l (0x8034400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC2_BTM_MULTI_MEAS_EN"
      sgroup "VADC2_BTM_MULTI_MEAS_EN (at 0x3441)"
        set &access:&cmd_addr %l (0x8034410|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34410|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_MEAS_EN                               = " "0 (M7_MEAS_DISABLE),1 (M7_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_MEAS_EN                               = " "0 (M6_MEAS_DISABLE),1 (M6_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_MEAS_EN                               = " "0 (M5_MEAS_DISABLE),1 (M5_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_MEAS_EN                               = " "0 (M4_MEAS_DISABLE),1 (M4_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_MEAS_EN                               = " "0 (M3_MEAS_DISABLE),1 (M3_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_MEAS_EN                               = " "0 (M2_MEAS_DISABLE),1 (M2_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_MEAS_EN                               = " "0 (M1_MEAS_DISABLE),1 (M1_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_MEAS_EN                               = " "0 (M0_MEAS_DISABLE),1 (M0_MEAS_ENABLE)"
    tree.end
    tree "VADC2_BTM_LOW_THR_INT_EN"
      sgroup "VADC2_BTM_LOW_THR_INT_EN (at 0x3442)"
        set &access:&cmd_addr %l (0x8034420|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34420|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_LOW_THR_INT_EN                        = " "0 (M7_LOW_THR_INT_DISABLED),1 (M7_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_LOW_THR_INT_EN                        = " "0 (M6_LOW_THR_INT_DISABLED),1 (M6_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_LOW_THR_INT_EN                        = " "0 (M5_LOW_THR_INT_DISABLED),1 (M5_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_LOW_THR_INT_EN                        = " "0 (M4_LOW_THR_INT_DISABLED),1 (M4_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_LOW_THR_INT_EN                        = " "0 (M3_LOW_THR_INT_DISABLED),1 (M3_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_LOW_THR_INT_EN                        = " "0 (M2_LOW_THR_INT_DISABLED),1 (M2_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW_THR_INT_EN                        = " "0 (M1_LOW_THR_INT_DISABLED),1 (M1_LOW_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW_THR_INT_EN                        = " "0 (M0_LOW_THR_INT_DISABLED),1 (M0_LOW_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_BTM_HIGH_THR_INT_EN"
      sgroup "VADC2_BTM_HIGH_THR_INT_EN (at 0x3443)"
        set &access:&cmd_addr %l (0x8034430|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34430|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M7_HIGH_THR_INT_EN                       = " "0 (M7_HIGH_THR_INT_DISABLED),1 (M7_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M6_HIGH_THR_INT_EN                       = " "0 (M6_HIGH_THR_INT_DISABLED),1 (M6_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   M5_HIGH_THR_INT_EN                       = " "0 (M5_HIGH_THR_INT_DISABLED),1 (M5_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   M4_HIGH_THR_INT_EN                       = " "0 (M4_HIGH_THR_INT_DISABLED),1 (M4_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   M3_HIGH_THR_INT_EN                       = " "0 (M3_HIGH_THR_INT_DISABLED),1 (M3_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   M2_HIGH_THR_INT_EN                       = " "0 (M2_HIGH_THR_INT_DISABLED),1 (M2_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH_THR_INT_EN                       = " "0 (M1_HIGH_THR_INT_DISABLED),1 (M1_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH_THR_INT_EN                       = " "0 (M0_HIGH_THR_INT_DISABLED),1 (M0_HIGH_THR_INT_ENABLED)"
    tree.end
    tree "VADC2_BTM_EN_CTL1"
      sgroup "VADC2_BTM_EN_CTL1 (at 0x3446)"
        set &access:&cmd_addr %l (0x8034460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC2_BTM_M0_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M0_ADC_CH_SEL_CTL (at 0x3448)"
        set &access:&cmd_addr %l (0x8034480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_ADC_DIG_PARAM"
      sgroup "VADC2_BTM_ADC_DIG_PARAM (at 0x3450)"
        set &access:&cmd_addr %l (0x8034500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC2_BTM_HW_SETTLE_DELAY"
      sgroup "VADC2_BTM_HW_SETTLE_DELAY (at 0x3451)"
        set &access:&cmd_addr %l (0x8034510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC2_BTM_CONV_REQ"
      sgroup "VADC2_BTM_CONV_REQ (at 0x3452)"
        set &access:&cmd_addr %l (0x8034520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC2_BTM_CONV_SEQ_CTL"
      sgroup "VADC2_BTM_CONV_SEQ_CTL (at 0x3454)"
        set &access:&cmd_addr %l (0x8034540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC2_BTM_CONV_SEQ_TRIG_CTL"
      sgroup "VADC2_BTM_CONV_SEQ_TRIG_CTL (at 0x3455)"
        set &access:&cmd_addr %l (0x8034550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_MEAS_INTERVAL_CTL (at 0x3457)"
        set &access:&cmd_addr %l (0x8034570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME1                      = "
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_CTL2"
      sgroup "VADC2_BTM_MEAS_INTERVAL_CTL2 (at 0x3458)"
        set &access:&cmd_addr %l (0x8034580|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34580|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MEAS_INTERVAL_TIME2                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME3                      = "
    tree.end
    tree "VADC2_BTM_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC2_BTM_MEAS_INTERVAL_OP_CTL (at 0x3459)"
        set &access:&cmd_addr %l (0x8034590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M0_MEAS_INTERVAL_TIME                    = " "0 (M0_USING_TIMER1),1 (M0_USING_TIMER2),2 (M0_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_FAST_AVG_CTL"
      sgroup "VADC2_BTM_FAST_AVG_CTL (at 0x345a)"
        set &access:&cmd_addr %l (0x80345a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x345a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC2_BTM_FAST_AVG_EN"
      sgroup "VADC2_BTM_FAST_AVG_EN (at 0x345b)"
        set &access:&cmd_addr %l (0x80345b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x345b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC2_BTM_M0_LOW_THR0"
      sgroup "VADC2_BTM_M0_LOW_THR0 (at 0x345c)"
        set &access:&cmd_addr %l (0x80345c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x345c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M0_LOW_THR1"
      sgroup "VADC2_BTM_M0_LOW_THR1 (at 0x345d)"
        set &access:&cmd_addr %l (0x80345d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x345d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M0_HIGH_THR0"
      sgroup "VADC2_BTM_M0_HIGH_THR0 (at 0x345e)"
        set &access:&cmd_addr %l (0x80345e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x345e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M0_HIGH_THR1"
      sgroup "VADC2_BTM_M0_HIGH_THR1 (at 0x345f)"
        set &access:&cmd_addr %l (0x80345f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x345f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M0_DATA0"
      sgroup "VADC2_BTM_M0_DATA0 (at 0x3460)"
        set &access:&cmd_addr %l (0x8034600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M0_DATA1"
      sgroup "VADC2_BTM_M0_DATA1 (at 0x3461)"
        set &access:&cmd_addr %l (0x8034610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M1_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M1_ADC_CH_SEL_CTL (at 0x3468)"
        set &access:&cmd_addr %l (0x8034680|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34680|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M1_LOW_THR0"
      sgroup "VADC2_BTM_M1_LOW_THR0 (at 0x3469)"
        set &access:&cmd_addr %l (0x8034690|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34690|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M1_LOW_THR1"
      sgroup "VADC2_BTM_M1_LOW_THR1 (at 0x346a)"
        set &access:&cmd_addr %l (0x80346a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x346a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M1_HIGH_THR0"
      sgroup "VADC2_BTM_M1_HIGH_THR0 (at 0x346b)"
        set &access:&cmd_addr %l (0x80346b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x346b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M1_HIGH_THR1"
      sgroup "VADC2_BTM_M1_HIGH_THR1 (at 0x346c)"
        set &access:&cmd_addr %l (0x80346c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x346c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M1_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_M1_MEAS_INTERVAL_CTL (at 0x346d)"
        set &access:&cmd_addr %l (0x80346d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x346d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M1_MEAS_INTERVAL_TIME                    = " "0 (M1_USING_TIMER1),1 (M1_USING_TIMER2),2 (M1_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M2_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M2_ADC_CH_SEL_CTL (at 0x3470)"
        set &access:&cmd_addr %l (0x8034700|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34700|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M2_LOW_THR0"
      sgroup "VADC2_BTM_M2_LOW_THR0 (at 0x3471)"
        set &access:&cmd_addr %l (0x8034710|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34710|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M2_LOW_THR1"
      sgroup "VADC2_BTM_M2_LOW_THR1 (at 0x3472)"
        set &access:&cmd_addr %l (0x8034720|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34720|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M2_HIGH_THR0"
      sgroup "VADC2_BTM_M2_HIGH_THR0 (at 0x3473)"
        set &access:&cmd_addr %l (0x8034730|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34730|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M2_HIGH_THR1"
      sgroup "VADC2_BTM_M2_HIGH_THR1 (at 0x3474)"
        set &access:&cmd_addr %l (0x8034740|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34740|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M2_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_M2_MEAS_INTERVAL_CTL (at 0x3475)"
        set &access:&cmd_addr %l (0x8034750|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34750|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M2_MEAS_INTERVAL_TIME                    = " "0 (M2_USING_TIMER1),1 (M2_USING_TIMER2),2 (M2_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M3_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M3_ADC_CH_SEL_CTL (at 0x3478)"
        set &access:&cmd_addr %l (0x8034780|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34780|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M3_LOW_THR0"
      sgroup "VADC2_BTM_M3_LOW_THR0 (at 0x3479)"
        set &access:&cmd_addr %l (0x8034790|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34790|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M3_LOW_THR1"
      sgroup "VADC2_BTM_M3_LOW_THR1 (at 0x347a)"
        set &access:&cmd_addr %l (0x80347a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x347a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M3_HIGH_THR0"
      sgroup "VADC2_BTM_M3_HIGH_THR0 (at 0x347b)"
        set &access:&cmd_addr %l (0x80347b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x347b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M3_HIGH_THR1"
      sgroup "VADC2_BTM_M3_HIGH_THR1 (at 0x347c)"
        set &access:&cmd_addr %l (0x80347c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x347c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M3_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_M3_MEAS_INTERVAL_CTL (at 0x347d)"
        set &access:&cmd_addr %l (0x80347d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x347d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M3_MEAS_INTERVAL_TIME                    = " "0 (M3_USING_TIMER1),1 (M3_USING_TIMER2),2 (M3_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M4_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M4_ADC_CH_SEL_CTL (at 0x3480)"
        set &access:&cmd_addr %l (0x8034800|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34800|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M4_LOW_THR0"
      sgroup "VADC2_BTM_M4_LOW_THR0 (at 0x3481)"
        set &access:&cmd_addr %l (0x8034810|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34810|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M4_LOW_THR1"
      sgroup "VADC2_BTM_M4_LOW_THR1 (at 0x3482)"
        set &access:&cmd_addr %l (0x8034820|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34820|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M4_HIGH_THR0"
      sgroup "VADC2_BTM_M4_HIGH_THR0 (at 0x3483)"
        set &access:&cmd_addr %l (0x8034830|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34830|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M4_HIGH_THR1"
      sgroup "VADC2_BTM_M4_HIGH_THR1 (at 0x3484)"
        set &access:&cmd_addr %l (0x8034840|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34840|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M4_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_M4_MEAS_INTERVAL_CTL (at 0x3485)"
        set &access:&cmd_addr %l (0x8034850|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34850|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M4_MEAS_INTERVAL_TIME                    = " "0 (M4_USING_TIMER1),1 (M4_USING_TIMER2),2 (M4_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M5_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M5_ADC_CH_SEL_CTL (at 0x3488)"
        set &access:&cmd_addr %l (0x8034880|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34880|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M5_LOW_THR0"
      sgroup "VADC2_BTM_M5_LOW_THR0 (at 0x3489)"
        set &access:&cmd_addr %l (0x8034890|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34890|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M5_LOW_THR1"
      sgroup "VADC2_BTM_M5_LOW_THR1 (at 0x348a)"
        set &access:&cmd_addr %l (0x80348a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x348a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M5_HIGH_THR0"
      sgroup "VADC2_BTM_M5_HIGH_THR0 (at 0x348b)"
        set &access:&cmd_addr %l (0x80348b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x348b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M5_HIGH_THR1"
      sgroup "VADC2_BTM_M5_HIGH_THR1 (at 0x348c)"
        set &access:&cmd_addr %l (0x80348c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x348c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M5_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_M5_MEAS_INTERVAL_CTL (at 0x348d)"
        set &access:&cmd_addr %l (0x80348d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x348d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M5_MEAS_INTERVAL_TIME                    = " "0 (M5_USING_TIMER1),1 (M5_USING_TIMER2),2 (M5_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M6_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M6_ADC_CH_SEL_CTL (at 0x3490)"
        set &access:&cmd_addr %l (0x8034900|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34900|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M6_LOW_THR0"
      sgroup "VADC2_BTM_M6_LOW_THR0 (at 0x3491)"
        set &access:&cmd_addr %l (0x8034910|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34910|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M6_LOW_THR1"
      sgroup "VADC2_BTM_M6_LOW_THR1 (at 0x3492)"
        set &access:&cmd_addr %l (0x8034920|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34920|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M6_HIGH_THR0"
      sgroup "VADC2_BTM_M6_HIGH_THR0 (at 0x3493)"
        set &access:&cmd_addr %l (0x8034930|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34930|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M6_HIGH_THR1"
      sgroup "VADC2_BTM_M6_HIGH_THR1 (at 0x3494)"
        set &access:&cmd_addr %l (0x8034940|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34940|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M6_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_M6_MEAS_INTERVAL_CTL (at 0x3495)"
        set &access:&cmd_addr %l (0x8034950|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34950|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M6_MEAS_INTERVAL_TIME                    = " "0 (M6_USING_TIMER1),1 (M6_USING_TIMER2),2 (M6_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M7_ADC_CH_SEL_CTL"
      sgroup "VADC2_BTM_M7_ADC_CH_SEL_CTL (at 0x3498)"
        set &access:&cmd_addr %l (0x8034980|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34980|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC2_BTM_M7_LOW_THR0"
      sgroup "VADC2_BTM_M7_LOW_THR0 (at 0x3499)"
        set &access:&cmd_addr %l (0x8034990|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34990|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC2_BTM_M7_LOW_THR1"
      sgroup "VADC2_BTM_M7_LOW_THR1 (at 0x349a)"
        set &access:&cmd_addr %l (0x80349a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x349a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC2_BTM_M7_HIGH_THR0"
      sgroup "VADC2_BTM_M7_HIGH_THR0 (at 0x349b)"
        set &access:&cmd_addr %l (0x80349b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x349b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC2_BTM_M7_HIGH_THR1"
      sgroup "VADC2_BTM_M7_HIGH_THR1 (at 0x349c)"
        set &access:&cmd_addr %l (0x80349c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x349c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC2_BTM_M7_MEAS_INTERVAL_CTL"
      sgroup "VADC2_BTM_M7_MEAS_INTERVAL_CTL (at 0x349d)"
        set &access:&cmd_addr %l (0x80349d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x349d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M7_MEAS_INTERVAL_TIME                    = " "0 (M7_USING_TIMER1),1 (M7_USING_TIMER2),2 (M7_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC2_BTM_M1_DATA0"
      sgroup "VADC2_BTM_M1_DATA0 (at 0x34a0)"
        set &access:&cmd_addr %l (0x8034a00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M1_DATA1"
      sgroup "VADC2_BTM_M1_DATA1 (at 0x34a1)"
        set &access:&cmd_addr %l (0x8034a10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M2_DATA0"
      sgroup "VADC2_BTM_M2_DATA0 (at 0x34a2)"
        set &access:&cmd_addr %l (0x8034a20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M2_DATA1"
      sgroup "VADC2_BTM_M2_DATA1 (at 0x34a3)"
        set &access:&cmd_addr %l (0x8034a30|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a30|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M3_DATA0"
      sgroup "VADC2_BTM_M3_DATA0 (at 0x34a4)"
        set &access:&cmd_addr %l (0x8034a40|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a40|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M3_DATA1"
      sgroup "VADC2_BTM_M3_DATA1 (at 0x34a5)"
        set &access:&cmd_addr %l (0x8034a50|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a50|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M4_DATA0"
      sgroup "VADC2_BTM_M4_DATA0 (at 0x34a6)"
        set &access:&cmd_addr %l (0x8034a60|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a60|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M4_DATA1"
      sgroup "VADC2_BTM_M4_DATA1 (at 0x34a7)"
        set &access:&cmd_addr %l (0x8034a70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M5_DATA0"
      sgroup "VADC2_BTM_M5_DATA0 (at 0x34a8)"
        set &access:&cmd_addr %l (0x8034a80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M5_DATA1"
      sgroup "VADC2_BTM_M5_DATA1 (at 0x34a9)"
        set &access:&cmd_addr %l (0x8034a90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34a90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M6_DATA0"
      sgroup "VADC2_BTM_M6_DATA0 (at 0x34aa)"
        set &access:&cmd_addr %l (0x8034aa0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34aa0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M6_DATA1"
      sgroup "VADC2_BTM_M6_DATA1 (at 0x34ab)"
        set &access:&cmd_addr %l (0x8034ab0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34ab0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_M7_DATA0"
      sgroup "VADC2_BTM_M7_DATA0 (at 0x34ac)"
        set &access:&cmd_addr %l (0x8034ac0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34ac0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC2_BTM_M7_DATA1"
      sgroup "VADC2_BTM_M7_DATA1 (at 0x34ad)"
        set &access:&cmd_addr %l (0x8034ad0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34ad0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC2_BTM_SEC_ACCESS"
      sgroup "VADC2_BTM_SEC_ACCESS (at 0x34d0)"
        set &access:&cmd_addr %l (0x8034d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL1"
      sgroup "VADC2_BTM_PERPH_RESET_CTL1 (at 0x34d8)"
        set &access:&cmd_addr %l (0x8034d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL2"
      sgroup "VADC2_BTM_PERPH_RESET_CTL2 (at 0x34d9)"
        set &access:&cmd_addr %l (0x8034d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL3"
      sgroup "VADC2_BTM_PERPH_RESET_CTL3 (at 0x34da)"
        set &access:&cmd_addr %l (0x8034da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC2_BTM_PERPH_RESET_CTL4"
      sgroup "VADC2_BTM_PERPH_RESET_CTL4 (at 0x34db)"
        set &access:&cmd_addr %l (0x8034db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_TEST1"
      sgroup "VADC2_BTM_INT_TEST1 (at 0x34e0)"
        set &access:&cmd_addr %l (0x8034e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC2_BTM_INT_TEST_VAL"
      sgroup "VADC2_BTM_INT_TEST_VAL (at 0x34e1)"
        set &access:&cmd_addr %l (0x8034e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC2_BTM_TEST1"
      sgroup "VADC2_BTM_TEST1 (at 0x34e2)"
        set &access:&cmd_addr %l (0x8034e20|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x34e20|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEL_FSM                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "VADC3_BMS"
  tree "VADC3_BMS"
    tree "VADC3_BMS_REVISION1"
      sgroup "VADC3_BMS_REVISION1 (at 0x3300)"
        set &access:&cmd_addr %l (0x8033000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_BMS_REVISION2"
      sgroup "VADC3_BMS_REVISION2 (at 0x3301)"
        set &access:&cmd_addr %l (0x8033010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_BMS_REVISION3"
      sgroup "VADC3_BMS_REVISION3 (at 0x3302)"
        set &access:&cmd_addr %l (0x8033020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_BMS_REVISION4"
      sgroup "VADC3_BMS_REVISION4 (at 0x3303)"
        set &access:&cmd_addr %l (0x8033030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_BMS_PERPH_TYPE"
      sgroup "VADC3_BMS_PERPH_TYPE (at 0x3304)"
        set &access:&cmd_addr %l (0x8033040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_BMS_PERPH_SUBTYPE"
      sgroup "VADC3_BMS_PERPH_SUBTYPE (at 0x3305)"
        set &access:&cmd_addr %l (0x8033050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_BMS_STATUS1"
      sgroup "VADC3_BMS_STATUS1 (at 0x3308)"
        set &access:&cmd_addr %l (0x8033080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_BMS_STATUS2"
      sgroup "VADC3_BMS_STATUS2 (at 0x3309)"
        set &access:&cmd_addr %l (0x8033090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_BMS_INT_RT_STS"
      sgroup "VADC3_BMS_INT_RT_STS (at 0x3310)"
        set &access:&cmd_addr %l (0x8033100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_BMS_INT_SET_TYPE"
      sgroup "VADC3_BMS_INT_SET_TYPE (at 0x3311)"
        set &access:&cmd_addr %l (0x8033110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_BMS_INT_POLARITY_HIGH"
      sgroup "VADC3_BMS_INT_POLARITY_HIGH (at 0x3312)"
        set &access:&cmd_addr %l (0x8033120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_BMS_INT_POLARITY_LOW"
      sgroup "VADC3_BMS_INT_POLARITY_LOW (at 0x3313)"
        set &access:&cmd_addr %l (0x8033130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_BMS_INT_LATCHED_CLR"
      sgroup "VADC3_BMS_INT_LATCHED_CLR (at 0x3314)"
        set &access:&cmd_addr %l (0x8033140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_BMS_INT_EN_SET"
      sgroup "VADC3_BMS_INT_EN_SET (at 0x3315)"
        set &access:&cmd_addr %l (0x8033150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_BMS_INT_EN_CLR"
      sgroup "VADC3_BMS_INT_EN_CLR (at 0x3316)"
        set &access:&cmd_addr %l (0x8033160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_BMS_INT_LATCHED_STS"
      sgroup "VADC3_BMS_INT_LATCHED_STS (at 0x3318)"
        set &access:&cmd_addr %l (0x8033180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_BMS_INT_PENDING_STS"
      sgroup "VADC3_BMS_INT_PENDING_STS (at 0x3319)"
        set &access:&cmd_addr %l (0x8033190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_BMS_INT_MID_SEL"
      sgroup "VADC3_BMS_INT_MID_SEL (at 0x331a)"
        set &access:&cmd_addr %l (0x80331a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x331a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_BMS_INT_PRIORITY"
      sgroup "VADC3_BMS_INT_PRIORITY (at 0x331b)"
        set &access:&cmd_addr %l (0x80331b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x331b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_BMS_MODE_CTL"
      sgroup "VADC3_BMS_MODE_CTL (at 0x3340)"
        set &access:&cmd_addr %l (0x8033400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_BMS_EN_CTL1"
      sgroup "VADC3_BMS_EN_CTL1 (at 0x3346)"
        set &access:&cmd_addr %l (0x8033460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_BMS_ADC_CH_SEL_CTL"
      sgroup "VADC3_BMS_ADC_CH_SEL_CTL (at 0x3348)"
        set &access:&cmd_addr %l (0x8033480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_BMS_ADC_DIG_PARAM"
      sgroup "VADC3_BMS_ADC_DIG_PARAM (at 0x3350)"
        set &access:&cmd_addr %l (0x8033500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_BMS_HW_SETTLE_DELAY"
      sgroup "VADC3_BMS_HW_SETTLE_DELAY (at 0x3351)"
        set &access:&cmd_addr %l (0x8033510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_BMS_CONV_REQ"
      sgroup "VADC3_BMS_CONV_REQ (at 0x3352)"
        set &access:&cmd_addr %l (0x8033520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_BMS_CONV_SEQ_CTL"
      sgroup "VADC3_BMS_CONV_SEQ_CTL (at 0x3354)"
        set &access:&cmd_addr %l (0x8033540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_BMS_CONV_SEQ_TRIG_CTL"
      sgroup "VADC3_BMS_CONV_SEQ_TRIG_CTL (at 0x3355)"
        set &access:&cmd_addr %l (0x8033550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_BMS_MEAS_INTERVAL_CTL"
      sgroup "VADC3_BMS_MEAS_INTERVAL_CTL (at 0x3357)"
        set &access:&cmd_addr %l (0x8033570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_BMS_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC3_BMS_MEAS_INTERVAL_OP_CTL (at 0x3359)"
        set &access:&cmd_addr %l (0x8033590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_BMS_FAST_AVG_CTL"
      sgroup "VADC3_BMS_FAST_AVG_CTL (at 0x335a)"
        set &access:&cmd_addr %l (0x80335a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x335a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_BMS_FAST_AVG_EN"
      sgroup "VADC3_BMS_FAST_AVG_EN (at 0x335b)"
        set &access:&cmd_addr %l (0x80335b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x335b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_BMS_LOW_THR0"
      sgroup "VADC3_BMS_LOW_THR0 (at 0x335c)"
        set &access:&cmd_addr %l (0x80335c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x335c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_BMS_LOW_THR1"
      sgroup "VADC3_BMS_LOW_THR1 (at 0x335d)"
        set &access:&cmd_addr %l (0x80335d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x335d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_BMS_HIGH_THR0"
      sgroup "VADC3_BMS_HIGH_THR0 (at 0x335e)"
        set &access:&cmd_addr %l (0x80335e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x335e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_BMS_HIGH_THR1"
      sgroup "VADC3_BMS_HIGH_THR1 (at 0x335f)"
        set &access:&cmd_addr %l (0x80335f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x335f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_BMS_DATA0"
      sgroup "VADC3_BMS_DATA0 (at 0x3360)"
        set &access:&cmd_addr %l (0x8033600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_BMS_DATA1"
      sgroup "VADC3_BMS_DATA1 (at 0x3361)"
        set &access:&cmd_addr %l (0x8033610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_BMS_SEC_ACCESS"
      sgroup "VADC3_BMS_SEC_ACCESS (at 0x33d0)"
        set &access:&cmd_addr %l (0x8033d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_BMS_PERPH_RESET_CTL1"
      sgroup "VADC3_BMS_PERPH_RESET_CTL1 (at 0x33d8)"
        set &access:&cmd_addr %l (0x8033d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_BMS_PERPH_RESET_CTL2"
      sgroup "VADC3_BMS_PERPH_RESET_CTL2 (at 0x33d9)"
        set &access:&cmd_addr %l (0x8033d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_BMS_PERPH_RESET_CTL3"
      sgroup "VADC3_BMS_PERPH_RESET_CTL3 (at 0x33da)"
        set &access:&cmd_addr %l (0x8033da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_BMS_PERPH_RESET_CTL4"
      sgroup "VADC3_BMS_PERPH_RESET_CTL4 (at 0x33db)"
        set &access:&cmd_addr %l (0x8033db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_BMS_INT_TEST1"
      sgroup "VADC3_BMS_INT_TEST1 (at 0x33e0)"
        set &access:&cmd_addr %l (0x8033e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_BMS_INT_TEST_VAL"
      sgroup "VADC3_BMS_INT_TEST_VAL (at 0x33e1)"
        set &access:&cmd_addr %l (0x8033e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_BMS_TEST6_DTEST"
      sgroup "VADC3_BMS_TEST6_DTEST (at 0x33e7)"
        set &access:&cmd_addr %l (0x8033e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x33e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VADC3_MDM"
  tree "VADC3_MDM"
    tree "VADC3_MDM_REVISION1"
      sgroup "VADC3_MDM_REVISION1 (at 0x3200)"
        set &access:&cmd_addr %l (0x8032000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION2"
      sgroup "VADC3_MDM_REVISION2 (at 0x3201)"
        set &access:&cmd_addr %l (0x8032010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION3"
      sgroup "VADC3_MDM_REVISION3 (at 0x3202)"
        set &access:&cmd_addr %l (0x8032020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC3_MDM_REVISION4"
      sgroup "VADC3_MDM_REVISION4 (at 0x3203)"
        set &access:&cmd_addr %l (0x8032030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC3_MDM_PERPH_TYPE"
      sgroup "VADC3_MDM_PERPH_TYPE (at 0x3204)"
        set &access:&cmd_addr %l (0x8032040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC3_MDM_PERPH_SUBTYPE"
      sgroup "VADC3_MDM_PERPH_SUBTYPE (at 0x3205)"
        set &access:&cmd_addr %l (0x8032050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC3_MDM_STATUS1"
      sgroup "VADC3_MDM_STATUS1 (at 0x3208)"
        set &access:&cmd_addr %l (0x8032080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC3_MDM_STATUS2"
      sgroup "VADC3_MDM_STATUS2 (at 0x3209)"
        set &access:&cmd_addr %l (0x8032090|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32090|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_RT_STS"
      sgroup "VADC3_MDM_INT_RT_STS (at 0x3210)"
        set &access:&cmd_addr %l (0x8032100|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32100|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_SET_TYPE"
      sgroup "VADC3_MDM_INT_SET_TYPE (at 0x3211)"
        set &access:&cmd_addr %l (0x8032110|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32110|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC3_MDM_INT_POLARITY_HIGH"
      sgroup "VADC3_MDM_INT_POLARITY_HIGH (at 0x3212)"
        set &access:&cmd_addr %l (0x8032120|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32120|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC3_MDM_INT_POLARITY_LOW"
      sgroup "VADC3_MDM_INT_POLARITY_LOW (at 0x3213)"
        set &access:&cmd_addr %l (0x8032130|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32130|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC3_MDM_INT_LATCHED_CLR"
      sgroup "VADC3_MDM_INT_LATCHED_CLR (at 0x3214)"
        set &access:&cmd_addr %l (0x8032140|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32140|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC3_MDM_INT_EN_SET"
      sgroup "VADC3_MDM_INT_EN_SET (at 0x3215)"
        set &access:&cmd_addr %l (0x8032150|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32150|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_MDM_INT_EN_CLR"
      sgroup "VADC3_MDM_INT_EN_CLR (at 0x3216)"
        set &access:&cmd_addr %l (0x8032160|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32160|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC3_MDM_INT_LATCHED_STS"
      sgroup "VADC3_MDM_INT_LATCHED_STS (at 0x3218)"
        set &access:&cmd_addr %l (0x8032180|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32180|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_PENDING_STS"
      sgroup "VADC3_MDM_INT_PENDING_STS (at 0x3219)"
        set &access:&cmd_addr %l (0x8032190|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32190|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_MID_SEL"
      sgroup "VADC3_MDM_INT_MID_SEL (at 0x321a)"
        set &access:&cmd_addr %l (0x80321a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x321a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC3_MDM_INT_PRIORITY"
      sgroup "VADC3_MDM_INT_PRIORITY (at 0x321b)"
        set &access:&cmd_addr %l (0x80321b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x321b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC3_MDM_MODE_CTL"
      sgroup "VADC3_MDM_MODE_CTL (at 0x3240)"
        set &access:&cmd_addr %l (0x8032400|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32400|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC3_MDM_EN_CTL1"
      sgroup "VADC3_MDM_EN_CTL1 (at 0x3246)"
        set &access:&cmd_addr %l (0x8032460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC3_MDM_ADC_CH_SEL_CTL"
      sgroup "VADC3_MDM_ADC_CH_SEL_CTL (at 0x3248)"
        set &access:&cmd_addr %l (0x8032480|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32480|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC3_MDM_ADC_DIG_PARAM"
      sgroup "VADC3_MDM_ADC_DIG_PARAM (at 0x3250)"
        set &access:&cmd_addr %l (0x8032500|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32500|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC3_MDM_HW_SETTLE_DELAY"
      sgroup "VADC3_MDM_HW_SETTLE_DELAY (at 0x3251)"
        set &access:&cmd_addr %l (0x8032510|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32510|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC3_MDM_CONV_REQ"
      sgroup "VADC3_MDM_CONV_REQ (at 0x3252)"
        set &access:&cmd_addr %l (0x8032520|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32520|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC3_MDM_CONV_SEQ_CTL"
      sgroup "VADC3_MDM_CONV_SEQ_CTL (at 0x3254)"
        set &access:&cmd_addr %l (0x8032540|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32540|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC3_MDM_CONV_SEQ_TRIG_CTL"
      sgroup "VADC3_MDM_CONV_SEQ_TRIG_CTL (at 0x3255)"
        set &access:&cmd_addr %l (0x8032550|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32550|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_CTL"
      sgroup "VADC3_MDM_MEAS_INTERVAL_CTL (at 0x3257)"
        set &access:&cmd_addr %l (0x8032570|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32570|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC3_MDM_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC3_MDM_MEAS_INTERVAL_OP_CTL (at 0x3259)"
        set &access:&cmd_addr %l (0x8032590|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32590|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC3_MDM_FAST_AVG_CTL"
      sgroup "VADC3_MDM_FAST_AVG_CTL (at 0x325a)"
        set &access:&cmd_addr %l (0x80325a0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x325a0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC3_MDM_FAST_AVG_EN"
      sgroup "VADC3_MDM_FAST_AVG_EN (at 0x325b)"
        set &access:&cmd_addr %l (0x80325b0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x325b0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC3_MDM_LOW_THR0"
      sgroup "VADC3_MDM_LOW_THR0 (at 0x325c)"
        set &access:&cmd_addr %l (0x80325c0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x325c0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC3_MDM_LOW_THR1"
      sgroup "VADC3_MDM_LOW_THR1 (at 0x325d)"
        set &access:&cmd_addr %l (0x80325d0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x325d0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR0"
      sgroup "VADC3_MDM_HIGH_THR0 (at 0x325e)"
        set &access:&cmd_addr %l (0x80325e0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x325e0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR1"
      sgroup "VADC3_MDM_HIGH_THR1 (at 0x325f)"
        set &access:&cmd_addr %l (0x80325f0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x325f0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_MDM_DATA0"
      sgroup "VADC3_MDM_DATA0 (at 0x3260)"
        set &access:&cmd_addr %l (0x8032600|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32600|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_MDM_DATA1"
      sgroup "VADC3_MDM_DATA1 (at 0x3261)"
        set &access:&cmd_addr %l (0x8032610|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32610|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_MDM_SEC_ACCESS"
      sgroup "VADC3_MDM_SEC_ACCESS (at 0x32d0)"
        set &access:&cmd_addr %l (0x8032d00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32d00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL1"
      sgroup "VADC3_MDM_PERPH_RESET_CTL1 (at 0x32d8)"
        set &access:&cmd_addr %l (0x8032d80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32d80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL2"
      sgroup "VADC3_MDM_PERPH_RESET_CTL2 (at 0x32d9)"
        set &access:&cmd_addr %l (0x8032d90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32d90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL3"
      sgroup "VADC3_MDM_PERPH_RESET_CTL3 (at 0x32da)"
        set &access:&cmd_addr %l (0x8032da0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32da0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL4"
      sgroup "VADC3_MDM_PERPH_RESET_CTL4 (at 0x32db)"
        set &access:&cmd_addr %l (0x8032db0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32db0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST1"
      sgroup "VADC3_MDM_INT_TEST1 (at 0x32e0)"
        set &access:&cmd_addr %l (0x8032e00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32e00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC3_MDM_INT_TEST_VAL"
      sgroup "VADC3_MDM_INT_TEST_VAL (at 0x32e1)"
        set &access:&cmd_addr %l (0x8032e10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32e10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC3_MDM_TEST6_DTEST"
      sgroup "VADC3_MDM_TEST6_DTEST (at 0x32e7)"
        set &access:&cmd_addr %l (0x8032e70|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0x32e70|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
    tree.end
  tree.end
tree.end
tree "VIB1"
  tree "VIB1"
    tree "VIB1_REVISION1"
      sgroup "VIB1_REVISION1 (at 0x1c000)"
        set &access:&cmd_addr %l (0x80c0000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VIB1_REVISION2"
      sgroup "VIB1_REVISION2 (at 0x1c001)"
        set &access:&cmd_addr %l (0x80c0010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VIB1_REVISION3"
      sgroup "VIB1_REVISION3 (at 0x1c002)"
        set &access:&cmd_addr %l (0x80c0020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VIB1_REVISION4"
      sgroup "VIB1_REVISION4 (at 0x1c003)"
        set &access:&cmd_addr %l (0x80c0030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VIB1_PERPH_TYPE"
      sgroup "VIB1_PERPH_TYPE (at 0x1c004)"
        set &access:&cmd_addr %l (0x80c0040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VIB1_PERPH_SUBTYPE"
      sgroup "VIB1_PERPH_SUBTYPE (at 0x1c005)"
        set &access:&cmd_addr %l (0x80c0050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VIB1_STATUS1"
      sgroup "VIB1_STATUS1 (at 0x1c008)"
        set &access:&cmd_addr %l (0x80c0080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VIB_OK                                   = " "0 (VIB_DISABLED),1 (VIB_ENABLED)"
    tree.end
    tree "VIB1_VOLTAGE_CTL2"
      sgroup "VIB1_VOLTAGE_CTL2 (at 0x1c041)"
        set &access:&cmd_addr %l (0x80c0410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   V_SET                                    = "
    tree.end
    tree "VIB1_EN_CTL"
      sgroup "VIB1_EN_CTL (at 0x1c046)"
        set &access:&cmd_addr %l (0x80c0460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (VIB_DISABLED),1 (VIB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   INV_DTEST                                = " "0 (VIB_ENABLE_DTEST_HIGH),1 (VIB_ENABLE_DTEST_LOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_DTEST3                            = " "0 (VIB_IGNORE_DTEST3),1 (VIB_FOLLOW_DTEST3)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_DTEST2                            = " "0 (VIB_IGNORE_DTEST2),1 (VIB_FOLLOW_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_DTEST1                            = " "0 (VIB_IGNORE_DTEST1),1 (VIB_FOLLOW_DTEST1)"
    tree.end
    tree "VIB1_SEC_ACCESS"
      sgroup "VIB1_SEC_ACCESS (at 0x1c0d0)"
        set &access:&cmd_addr %l (0x80c0d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VIB1_PERPH_RESET_CTL1"
      sgroup "VIB1_PERPH_RESET_CTL1 (at 0x1c0d8)"
        set &access:&cmd_addr %l (0x80c0d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "VIB1_PERPH_RESET_CTL2"
      sgroup "VIB1_PERPH_RESET_CTL2 (at 0x1c0d9)"
        set &access:&cmd_addr %l (0x80c0d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VIB1_PERPH_RESET_CTL3"
      sgroup "VIB1_PERPH_RESET_CTL3 (at 0x1c0da)"
        set &access:&cmd_addr %l (0x80c0da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VIB1_PERPH_RESET_CTL4"
      sgroup "VIB1_PERPH_RESET_CTL4 (at 0x1c0db)"
        set &access:&cmd_addr %l (0x80c0db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "VIB1_TEST1"
      sgroup "VIB1_TEST1 (at 0x1c0e2)"
        set &access:&cmd_addr %l (0x80c0e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xc0e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ILIM_REDUCTION                           = " "0 (VIB_TEST_ILIM_NORMAL),1 (VIB_TEST_ILIM_REDUCED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST_VIB_OUT                            = " "0 (VIB_TEST_ATEST1_HI_Z),1 (VIB_TEST_ATEST1_IS_VOUT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST_ISENSE                             = " "0 (VIB_TEST_ATEST2_HI_Z),1 (VIB_TEST_ATEST2_IS_ISENSE)"
    tree.end
  tree.end
tree.end
tree "VREFLPDDR"
  tree "VREFLPDDR"
    tree "VREFLPDDR_REVISION1"
      sgroup "VREFLPDDR_REVISION1 (at 0xa00)"
        set &access:&cmd_addr %l (0x800a000|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa000|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION2"
      sgroup "VREFLPDDR_REVISION2 (at 0xa01)"
        set &access:&cmd_addr %l (0x800a010|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa010|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION3"
      sgroup "VREFLPDDR_REVISION3 (at 0xa02)"
        set &access:&cmd_addr %l (0x800a020|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa020|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION4"
      sgroup "VREFLPDDR_REVISION4 (at 0xa03)"
        set &access:&cmd_addr %l (0x800a030|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa030|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_PERPH_TYPE"
      sgroup "VREFLPDDR_PERPH_TYPE (at 0xa04)"
        set &access:&cmd_addr %l (0x800a040|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa040|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREFLPDDR_PERPH_SUBTYPE"
      sgroup "VREFLPDDR_PERPH_SUBTYPE (at 0xa05)"
        set &access:&cmd_addr %l (0x800a050|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa050|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREFLPDDR_STATUS1"
      sgroup "VREFLPDDR_STATUS1 (at 0xa08)"
        set &access:&cmd_addr %l (0x800a080|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa080|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_OK                                  = " "0 (VREF_DISABLED),1 (VREF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_LPDDR_OK                            = " "0 (VREF_LPDDR_DISABLED),1 (VREF_LPDDR_ENABLED)"
    tree.end
    tree "VREFLPDDR_VREF_LPDDR2_EN"
      sgroup "VREFLPDDR_VREF_LPDDR2_EN (at 0xa44)"
        set &access:&cmd_addr %l (0x800a440|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa440|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (VREF_LPDDR_DISABLED),1 (VREF_LPDDR_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN2                            = " "0 (VREF_LPDDR_FOLLOW_SLEEPB_DISABLED),1 (VREF_LPDDR_FOLLOW_SLEEPB_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN1                            = " "0 (VREF_LPDDR_FOLLOW_VREGOK_DISABLED),1 (VREF_LPDDR_FOLLOW_VREGOK_ENABLED)"
    tree.end
    tree "VREFLPDDR_EN_CTL1"
      sgroup "VREFLPDDR_EN_CTL1 (at 0xa46)"
        set &access:&cmd_addr %l (0x800a460|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xa460|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (VREF_DISABLED),1 (VREF_ENABLED)"
    tree.end
    tree "VREFLPDDR_SEC_ACCESS"
      sgroup "VREFLPDDR_SEC_ACCESS (at 0xad0)"
        set &access:&cmd_addr %l (0x800ad00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xad00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL1"
      sgroup "VREFLPDDR_PERPH_RESET_CTL1 (at 0xad8)"
        set &access:&cmd_addr %l (0x800ad80|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xad80|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL2"
      sgroup "VREFLPDDR_PERPH_RESET_CTL2 (at 0xad9)"
        set &access:&cmd_addr %l (0x800ad90|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xad90|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL3"
      sgroup "VREFLPDDR_PERPH_RESET_CTL3 (at 0xada)"
        set &access:&cmd_addr %l (0x800ada0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xada0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL4"
      sgroup "VREFLPDDR_PERPH_RESET_CTL4 (at 0xadb)"
        set &access:&cmd_addr %l (0x800adb0|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xadb0|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "VREFLPDDR_TRIM_NUM"
      sgroup "VREFLPDDR_TRIM_NUM (at 0xaf0)"
        set &access:&cmd_addr %l (0x800af00|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xaf00|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREFLPDDR_TRIM_VAL"
      sgroup "VREFLPDDR_TRIM_VAL (at 0xaf1)"
        set &access:&cmd_addr %l (0x800af10|((&sid+0x0)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xaf10|((&sid+0x0)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_LPDDR2_TRIM_VALUE                   = "
    tree.end
  tree.end
tree.end
tree "WLED1"
  tree "WLED1"
    tree "WLED1_REVISION1"
      sgroup "WLED1_REVISION1 (at 0x1d800)"
        set &access:&cmd_addr %l (0x80d8000|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8000|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_REVISION2"
      sgroup "WLED1_REVISION2 (at 0x1d801)"
        set &access:&cmd_addr %l (0x80d8010|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8010|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_REVISION3"
      sgroup "WLED1_REVISION3 (at 0x1d802)"
        set &access:&cmd_addr %l (0x80d8020|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8020|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_REVISION4"
      sgroup "WLED1_REVISION4 (at 0x1d803)"
        set &access:&cmd_addr %l (0x80d8030|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8030|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_PERPH_TYPE"
      sgroup "WLED1_PERPH_TYPE (at 0x1d804)"
        set &access:&cmd_addr %l (0x80d8040|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8040|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_PERPH_SUBTYPE"
      sgroup "WLED1_PERPH_SUBTYPE (at 0x1d805)"
        set &access:&cmd_addr %l (0x80d8050|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8050|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_FAULT_STATUS"
      sgroup "WLED1_FAULT_STATUS (at 0x1d808)"
        set &access:&cmd_addr %l (0x80d8080|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8080|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT                                = " "0 (NO_FAULT),1 (OVP_FAULT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT                               = " "0 (NO_FAULT),1 (ILIM_FAULT)"
    tree.end
    tree "WLED1_INT_RT_STS"
      sgroup "WLED1_INT_RT_STS (at 0x1d810)"
        set &access:&cmd_addr %l (0x80d8100|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8100|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_RT_STS                        = " "0, 1"
    tree.end
    tree "WLED1_INT_SET_TYPE"
      sgroup "WLED1_INT_SET_TYPE (at 0x1d811)"
        set &access:&cmd_addr %l (0x80d8110|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8110|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "WLED1_INT_POLARITY_HIGH"
      sgroup "WLED1_INT_POLARITY_HIGH (at 0x1d812)"
        set &access:&cmd_addr %l (0x80d8120|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8120|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "WLED1_INT_POLARITY_LOW"
      sgroup "WLED1_INT_POLARITY_LOW (at 0x1d813)"
        set &access:&cmd_addr %l (0x80d8130|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8130|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "WLED1_INT_LATCHED_CLR"
      sgroup "WLED1_INT_LATCHED_CLR (at 0x1d814)"
        set &access:&cmd_addr %l (0x80d8140|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8140|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "WLED1_INT_EN_SET"
      sgroup "WLED1_INT_EN_SET (at 0x1d815)"
        set &access:&cmd_addr %l (0x80d8150|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8150|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "WLED1_INT_EN_CLR"
      sgroup "WLED1_INT_EN_CLR (at 0x1d816)"
        set &access:&cmd_addr %l (0x80d8160|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8160|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "WLED1_INT_LATCHED_STS"
      sgroup "WLED1_INT_LATCHED_STS (at 0x1d818)"
        set &access:&cmd_addr %l (0x80d8180|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8180|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "WLED1_INT_PENDING_STS"
      sgroup "WLED1_INT_PENDING_STS (at 0x1d819)"
        set &access:&cmd_addr %l (0x80d8190|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8190|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "WLED1_INT_MID_SEL"
      sgroup "WLED1_INT_MID_SEL (at 0x1d81a)"
        set &access:&cmd_addr %l (0x80d81a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd81a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "WLED1_INT_PRIORITY"
      sgroup "WLED1_INT_PRIORITY (at 0x1d81b)"
        set &access:&cmd_addr %l (0x80d81b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd81b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "WLED1_LED1_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_LED1_BRIGHTNESS_SETTING_LSB (at 0x1d840)"
        set &access:&cmd_addr %l (0x80d8400|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8400|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_LED1_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_LED1_BRIGHTNESS_SETTING_MSB (at 0x1d841)"
        set &access:&cmd_addr %l (0x80d8410|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8410|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_LED2_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_LED2_BRIGHTNESS_SETTING_LSB (at 0x1d842)"
        set &access:&cmd_addr %l (0x80d8420|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8420|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_LED2_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_LED2_BRIGHTNESS_SETTING_MSB (at 0x1d843)"
        set &access:&cmd_addr %l (0x80d8430|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8430|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_LED3_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_LED3_BRIGHTNESS_SETTING_LSB (at 0x1d844)"
        set &access:&cmd_addr %l (0x80d8440|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8440|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED3_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_LED3_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_LED3_BRIGHTNESS_SETTING_MSB (at 0x1d845)"
        set &access:&cmd_addr %l (0x80d8450|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8450|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_MODULE_ENABLE"
      sgroup "WLED1_MODULE_ENABLE (at 0x1d846)"
        set &access:&cmd_addr %l (0x80d8460|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8460|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0 (WLED_DIS),1 (WLED_EN)"
    tree.end
    tree "WLED1_ILED_SYNC_BIT"
      sgroup "WLED1_ILED_SYNC_BIT (at 0x1d847)"
        set &access:&cmd_addr %l (0x80d8470|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8470|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC_LED3                                = " "0 (LED3_SYNC_DIS),1 (LED3_SYNC_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_LED2                                = " "0 (LED2_SYNC_DIS),1 (LED2_SYNC_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_LED1                                = " "0 (LED1_SYNC_DIS),1 (LED1_SYNC_EN)"
    tree.end
    tree "WLED1_FEEDBACK_CONTROL"
      sgroup "WLED1_FEEDBACK_CONTROL (at 0x1d848)"
        set &access:&cmd_addr %l (0x80d8480|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8480|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FEEDBACK_CONTROL                         = " "0 (FBCTRL_AUTO),1 (FBCTRL_LED1),2 (FBCTRL_LED2),3 (FBCTRL_LED1_2),4 (FBCTRL_LED3),5 (FBCTRL_LED1_3),6 (FBCTRL_LED2_3),7 (FBCTRL_LED1_2_3)"
    tree.end
    tree "WLED1_VREF_CONTROL"
      sgroup "WLED1_VREF_CONTROL (at 0x1d849)"
        set &access:&cmd_addr %l (0x80d8490|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8490|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VREF_CONTROL                             = " "0 (VREF_CTRL_0P3V),1 (VREF_CTRL_0P4V),2 (VREF_CTRL_0P5V),3 (VREF_CTRL_0P6V),4 (VREF_CTRL_0P7V),5 (VREF_CTRL_0P8V),6 (VREF_CTRL_0P9V),7 (VREF_CTRL_1V)"
    tree.end
    tree "WLED1_MODULATION_SCHEME"
      sgroup "WLED1_MODULATION_SCHEME (at 0x1d84a)"
        set &access:&cmd_addr %l (0x80d84a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd84a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   MODULATOR_CLOCK_SEL                      = " "0 (MOD_CLK_FREQ_19P2MHZ),1 (MOD_CLK_FREQ_4P8MHZ),2 (MOD_CLK_FREQ_2P4MHZ),3 (MOD_CLK_FREQ_1P2MHZ)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INTERNAL_MOD_RESOLUTION                  = " "0 (RES_12BIT),1 (RES_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIMMING_METHOD                           = " "0 (ANALOG_DIMMING),1 (DIGITAL_DIMMING)"
    tree.end
    tree "WLED1_BOOST_MAX_DUTY_CYCLE"
      sgroup "WLED1_BOOST_MAX_DUTY_CYCLE (at 0x1d84b)"
        set &access:&cmd_addr %l (0x80d84b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd84b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_MAX_DUTY_CYCLE                     = " "0 (MXDUTY_26NS),1 (MXDUTY_52NS),2 (MXDUTY_104NS),3 (MXDUTY_156NS)"
    tree.end
    tree "WLED1_SWITCHING_FREQUENCY"
      sgroup "WLED1_SWITCHING_FREQUENCY (at 0x1d84c)"
        set &access:&cmd_addr %l (0x80d84c0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd84c0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SWITCHING_FREQ                           = "
    tree.end
    tree "WLED1_WLED_OVP"
      sgroup "WLED1_WLED_OVP (at 0x1d84d)"
        set &access:&cmd_addr %l (0x80d84d0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd84d0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WLED_OVP                                 = " "0 (OVP_35V),1 (OVP_32V),2 (OVP_29V),3 (OVP_27V)"
    tree.end
    tree "WLED1_WLED_ILIM"
      sgroup "WLED1_WLED_ILIM (at 0x1d84e)"
        set &access:&cmd_addr %l (0x80d84e0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd84e0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WLED_ILIM                                = " "0 (ILIM_143MA),1 (ILIM_409MA),2 (ILIM_544MA),3 (ILIM_818MA),4 (ILIM_981MA),5 (ILIM_1250MA),6 (ILIM_1380MA),7 (ILIM_1650MA)"
    tree.end
    tree "WLED1_EN_CURRENT_SINK"
      sgroup "WLED1_EN_CURRENT_SINK (at 0x1d84f)"
        set &access:&cmd_addr %l (0x80d84f0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd84f0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_SINK3                         = " "0 (LED3_DIS),1 (LED3_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_CURRENT_SINK2                         = " "0 (LED2_DIS),1 (LED2_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_CURRENT_SINK1                         = " "0 (LED1_DIS),1 (LED1_EN)"
    tree.end
    tree "WLED1_SLOPE_COMP_CAP"
      sgroup "WLED1_SLOPE_COMP_CAP (at 0x1d850)"
        set &access:&cmd_addr %l (0x80d8500|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8500|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP                               = " "0 (SLOPE_COMP_CAP_OPT0_5PF),1 (SLOPE_COMP_CAP_4PF),2 (SLOPE_COMP_CAP_3PF),3 (SLOPE_COMP_CAP_2PF),4 (SLOPE_COMP_CAP_8PF),5 (SLOPE_COMP_CAP_7PF),6 (SLOPE_COMP_CAP_6PF),7 (SLOPE_COMP_CAP_OPT1_5PF)"
    tree.end
    tree "WLED1_SLOPE_COMP_ADJ"
      sgroup "WLED1_SLOPE_COMP_ADJ (at 0x1d851)"
        set &access:&cmd_addr %l (0x80d8510|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8510|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SLOPE_COMP_ADJ                           = " "0 (SLOPE_COMP_3UA),1 (SLOPE_COMP_4UA),2 (reserved),3 (SLOPE_COMP_5UA)"
    tree.end
    tree "WLED1_BIAS_GEN_WARMUP_DELAY"
      sgroup "WLED1_BIAS_GEN_WARMUP_DELAY (at 0x1d852)"
        set &access:&cmd_addr %l (0x80d8520|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8520|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BIAS_GEN_WARMUP_DELAY                    = " "0 (BGWD_NODELAY),1 (BGWD_6P7US),2 (BGWD_13P3US),3 (BGWD_26P7US)"
    tree.end
    tree "WLED1_SOFTSTART_RAMP_DELAY"
      sgroup "WLED1_SOFTSTART_RAMP_DELAY (at 0x1d853)"
        set &access:&cmd_addr %l (0x80d8530|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8530|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SOFTSTART_RAMP_DELAY                     = " "0 (RAMP_TIME_700US),1 (RAMP_TIME_1400US),2 (RAMP_TIME_2100US),3 (RAMP_TIME_2800US),4 (RAMP_TIME_3500US),5 (RAMP_TIME_4200US),6 (RAMP_TIME_4900US),7 (RAMP_TIME_5600US)"
    tree.end
    tree "WLED1_SW_SLEW_RATE_CONTROL"
      sgroup "WLED1_SW_SLEW_RATE_CONTROL (at 0x1d854)"
        set &access:&cmd_addr %l (0x80d8540|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8540|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SW_SLEW_RATE_CONTROL                     = " "0 (SLEW_RATE_10NS),1 (SLEW_RATE_7P5NS),2 (SLEW_RATE_5NS),3 (SLEW_RATE_2P5NS)"
    tree.end
    tree "WLED1_VLOOP_COMP_RES"
      sgroup "WLED1_VLOOP_COMP_RES (at 0x1d855)"
        set &access:&cmd_addr %l (0x80d8550|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8550|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_COMP_RES                            = "
    tree.end
    tree "WLED1_VLOOP_COMP_GM"
      sgroup "WLED1_VLOOP_COMP_GM (at 0x1d856)"
        set &access:&cmd_addr %l (0x80d8560|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8560|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_EA_GM                               = "
    tree.end
    tree "WLED1_VLOOP_COMP_CAP"
      sgroup "WLED1_VLOOP_COMP_CAP (at 0x1d857)"
        set &access:&cmd_addr %l (0x80d8570|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8570|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_CAP                           = " "0 (VLOOP_COMP_CAP_50PF),1 (VLOOP_COMP_CAP_60PF),2 (VLOOP_COMP_CAP_70PF),3 (VLOOP_COMP_CAP_80PF)"
    tree.end
    tree "WLED1_VLOOP_COMP_HCAP"
      sgroup "WLED1_VLOOP_COMP_HCAP (at 0x1d858)"
        set &access:&cmd_addr %l (0x80d8580|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8580|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_HCAP                          = " "0 (VLOOP_COMP_HCAP_0PF),1 (VLOOP_COMP_HCAP_1PF),2 (VLOOP_COMP_HCAP_2PF),3 (VLOOP_COMP_HCAP_3PF)"
    tree.end
    tree "WLED1_EN_HW_BL_REDN"
      sgroup "WLED1_EN_HW_BL_REDN (at 0x1d859)"
        set &access:&cmd_addr %l (0x80d8590|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8590|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_HW_BL_REDN                            = " "0 (HW_BL_REDN_DIS),1 (HW_BL_REDN_EN)"
    tree.end
    tree "WLED1_EN_PSM"
      sgroup "WLED1_EN_PSM (at 0x1d85a)"
        set &access:&cmd_addr %l (0x80d85a0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd85a0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PSM                                   = " "0 (PSM_DIS),1 (PSM_EN)"
    tree.end
    tree "WLED1_PSM_CTRL"
      sgroup "WLED1_PSM_CTRL (at 0x1d85b)"
        set &access:&cmd_addr %l (0x80d85b0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd85b0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PSM_HYS_CTRL                             = " "0 (PSM_HYS_25MV),1 (PSM_HYS_50MV)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VREF_PSM                                 = " "0 (PSM_VREF_300MV),1 (PSM_VREF_400MV),2 (PSM_VREF_500MV),3 (PSM_VREF_600MV),4 (PSM_VREF_700MV),5 (PSM_VREF_800MV),6 (PSM_VREF_900MV),7 (PSM_VREF_1V)"
    tree.end
    tree "WLED1_LED1_MODULATOR_EN"
      sgroup "WLED1_LED1_MODULATOR_EN (at 0x1d860)"
        set &access:&cmd_addr %l (0x80d8600|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8600|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_EN_MODULATOR                        = " "0 (LED1_MOD_DIS),1 (LED1_MOD_EN)"
    tree.end
    tree "WLED1_LED1_IDAC_SYNC_DELAY"
      sgroup "WLED1_LED1_IDAC_SYNC_DELAY (at 0x1d861)"
        set &access:&cmd_addr %l (0x80d8610|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8610|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED1_IDAC_SYNC_DELAY                     = " "0 (LED1_SYNC_DLY_0US),1 (LED1_SYNC_DLY_200US),2 (LED1_SYNC_DLY_400US),3 (LED1_SYNC_DLY_600US),4 (LED1_SYNC_DLY_800US),5 (LED1_SYNC_DLY_1MS),6 (LED1_SYNC_DLY_1P2MS),7 (LED1_SYNC_DLY_1P4MS)"
    tree.end
    tree "WLED1_LED1_FULL_SCALE_CURRENT"
      sgroup "WLED1_LED1_FULL_SCALE_CURRENT (at 0x1d862)"
        set &access:&cmd_addr %l (0x80d8620|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8620|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED1_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_LED1_MODULATOR_SRC_SEL"
      sgroup "WLED1_LED1_MODULATOR_SRC_SEL (at 0x1d863)"
        set &access:&cmd_addr %l (0x80d8630|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8630|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_MODULATOR_SRC_SEL                   = " "0 (LED1_MOD_SRC_INT),1 (LED1_MOD_SRC_EXT)"
    tree.end
    tree "WLED1_LED1_CABC_EN"
      sgroup "WLED1_LED1_CABC_EN (at 0x1d866)"
        set &access:&cmd_addr %l (0x80d8660|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8660|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_CABC_EN                             = " "0 (CABC_DIS),1 (CABC_EN)"
    tree.end
    tree "WLED1_LED2_MODULATOR_EN"
      sgroup "WLED1_LED2_MODULATOR_EN (at 0x1d870)"
        set &access:&cmd_addr %l (0x80d8700|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8700|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_EN_MODULATOR                        = " "0 (LED2_MOD_DIS),1 (LED2_MOD_EN)"
    tree.end
    tree "WLED1_LED2_IDAC_SYNC_DELAY"
      sgroup "WLED1_LED2_IDAC_SYNC_DELAY (at 0x1d871)"
        set &access:&cmd_addr %l (0x80d8710|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8710|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED2_IDAC_SYNC_DELAY                     = " "0 (LED2_SYNC_DLY_0US),1 (LED2_SYNC_DLY_200US),2 (LED2_SYNC_DLY_400US),3 (LED2_SYNC_DLY_600US),4 (LED2_SYNC_DLY_800US),5 (LED2_SYNC_DLY_1MS),6 (LED2_SYNC_DLY_1P2MS),7 (LED2_SYNC_DLY_1P4MS)"
    tree.end
    tree "WLED1_LED2_FULL_SCALE_CURRENT"
      sgroup "WLED1_LED2_FULL_SCALE_CURRENT (at 0x1d872)"
        set &access:&cmd_addr %l (0x80d8720|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8720|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED2_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_LED2_MODULATOR_SRC_SEL"
      sgroup "WLED1_LED2_MODULATOR_SRC_SEL (at 0x1d873)"
        set &access:&cmd_addr %l (0x80d8730|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8730|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_MODULATOR_SRC_SEL                   = " "0 (LED2_MOD_SRC_INT),1 (LED2_MOD_SRC_EXT)"
    tree.end
    tree "WLED1_LED2_CABC_EN"
      sgroup "WLED1_LED2_CABC_EN (at 0x1d876)"
        set &access:&cmd_addr %l (0x80d8760|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8760|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_CABC_EN                             = " "0 (CABC_DIS),1 (CABC_EN)"
    tree.end
    tree "WLED1_LED3_MODULATOR_EN"
      sgroup "WLED1_LED3_MODULATOR_EN (at 0x1d880)"
        set &access:&cmd_addr %l (0x80d8800|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8800|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_EN_MODULATOR                        = " "0 (LED3_MOD_DIS),1 (LED3_MOD_EN)"
    tree.end
    tree "WLED1_LED3_IDAC_SYNC_DELAY"
      sgroup "WLED1_LED3_IDAC_SYNC_DELAY (at 0x1d881)"
        set &access:&cmd_addr %l (0x80d8810|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8810|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED3_IDAC_SYNC_DELAY                     = " "0 (LED3_SYNC_DLY_0US),1 (LED3_SYNC_DLY_200US),2 (LED3_SYNC_DLY_400US),3 (LED3_SYNC_DLY_600US),4 (LED3_SYNC_DLY_800US),5 (LED3_SYNC_DLY_1MS),6 (LED3_SYNC_DLY_1P2MS),7 (LED3_SYNC_DLY_1P4MS)"
    tree.end
    tree "WLED1_LED3_FULL_SCALE_CURRENT"
      sgroup "WLED1_LED3_FULL_SCALE_CURRENT (at 0x1d882)"
        set &access:&cmd_addr %l (0x80d8820|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8820|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED3_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_LED3_MODULATOR_SRC_SEL"
      sgroup "WLED1_LED3_MODULATOR_SRC_SEL (at 0x1d883)"
        set &access:&cmd_addr %l (0x80d8830|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8830|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED3_MODULATOR_SRC_SEL                   = " "0 (LED3_MOD_SRC_INT),1 (LED3_MOD_SRC_EXT)"
    tree.end
    tree "WLED1_LED3_CABC_EN"
      sgroup "WLED1_LED3_CABC_EN (at 0x1d886)"
        set &access:&cmd_addr %l (0x80d8860|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8860|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_CABC_EN                             = " "0 (CABC_DIS),1 (CABC_EN)"
    tree.end
    tree "WLED1_SEC_ACCESS"
      sgroup "WLED1_SEC_ACCESS (at 0x1d8d0)"
        set &access:&cmd_addr %l (0x80d8d00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8d00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_PERPH_RESET_CTL1"
      sgroup "WLED1_PERPH_RESET_CTL1 (at 0x1d8d8)"
        set &access:&cmd_addr %l (0x80d8d80|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8d80|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "WLED1_PERPH_RESET_CTL2"
      sgroup "WLED1_PERPH_RESET_CTL2 (at 0x1d8d9)"
        set &access:&cmd_addr %l (0x80d8d90|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8d90|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "WLED1_PERPH_RESET_CTL3"
      sgroup "WLED1_PERPH_RESET_CTL3 (at 0x1d8da)"
        set &access:&cmd_addr %l (0x80d8da0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8da0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "WLED1_PERPH_RESET_CTL4"
      sgroup "WLED1_PERPH_RESET_CTL4 (at 0x1d8db)"
        set &access:&cmd_addr %l (0x80d8db0|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8db0|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "WLED1_INT_TEST1"
      sgroup "WLED1_INT_TEST1 (at 0x1d8e0)"
        set &access:&cmd_addr %l (0x80d8e00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8e00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "WLED1_INT_TEST_VAL"
      sgroup "WLED1_INT_TEST_VAL (at 0x1d8e1)"
        set &access:&cmd_addr %l (0x80d8e10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8e10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TEST_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "WLED1_TEST1"
      sgroup "WLED1_TEST1 (at 0x1d8e2)"
        set &access:&cmd_addr %l (0x80d8e20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8e20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "WLED1_TEST2"
      sgroup "WLED1_TEST2 (at 0x1d8e3)"
        set &access:&cmd_addr %l (0x80d8e30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8e30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_TEST3"
      sgroup "WLED1_TEST3 (at 0x1d8e4)"
        set &access:&cmd_addr %l (0x80d8e40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8e40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDSON_TM                                 = " "0 (NORMAL_OPERATION),1 (NFET_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERRAMP_TRIM_CL                           = " "0 (NORMAL_OPERATION),1 (ERROR_AMP_INPUT_SHORTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVP_EN_MASK                              = " "0 (NORMAL_OPERATION),1 (OVP_MOD_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SLOPE_COMP_EN_MASK                       = " "0 (DISABLE),1 (MODULE_CNTRL_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_REF_EN_MASK                           = " "0 (DISABLE),1 (MODULE_CNTRL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_EN_MASK                             = " "0 (DISABLE),1 (MODULE_CNTRL_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIM_EN_MASK                             = " "0 (DISABLE),1 (MODULE_CNTRL_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ERRAMP_EN_MASK                           = " "0 (DISABLE),1 (MODULE_CNTRL_EN)"
    tree.end
    tree "WLED1_TEST4"
      sgroup "WLED1_TEST4 (at 0x1d8e5)"
        set &access:&cmd_addr %l (0x80d8e50|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8e50|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEBOUNCE_BYPASS                          = " "0 (DBNCE_ACTIVE),1 (DBNC_REMOVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_SLEEP_CLK_REQUEST                     = " "0 (WLED_19P2MHZ_MOD_EN),1 (WLED_19P2MHZ_DIS_SLEEP_B)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SOFT_START                            = " "0 (SOFT_START_DIS),1 (SOFT_START_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_DIM_SAMPLE_HOLD                      = " "0 (DIG_DIM_S_H),1 (CONT_FB)"
    tree.end
    tree "WLED1_TRIM_NUM"
      sgroup "WLED1_TRIM_NUM (at 0x1d8f0)"
        set &access:&cmd_addr %l (0x80d8f00|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f00|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_TRIM_VREF_ILED1"
      sgroup "WLED1_TRIM_VREF_ILED1 (at 0x1d8f1)"
        set &access:&cmd_addr %l (0x80d8f10|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f10|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_VREF_ILED1                          = "
    tree.end
    tree "WLED1_TRIM_VREF_ILED2"
      sgroup "WLED1_TRIM_VREF_ILED2 (at 0x1d8f2)"
        set &access:&cmd_addr %l (0x80d8f20|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f20|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_VREF_ILED2                          = "
    tree.end
    tree "WLED1_TRIM_VREF_ILED3"
      sgroup "WLED1_TRIM_VREF_ILED3 (at 0x1d8f3)"
        set &access:&cmd_addr %l (0x80d8f30|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f30|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_VREF_ILED3                          = "
    tree.end
    tree "WLED1_TRIM_OFFSET_ILED1"
      sgroup "WLED1_TRIM_OFFSET_ILED1 (at 0x1d8f4)"
        set &access:&cmd_addr %l (0x80d8f40|((&sid+0x1)<<20.))
        getx &access:&read_addr %l 0
        writeback
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l (0xd8f40|((&sid+0x1)<<20.))
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
