    tree "VADC3_MDM_LOW_THR1"
      sgroup "VADC3_MDM_LOW_THR1 (at 0x325d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR0"
      sgroup "VADC3_MDM_HIGH_THR0 (at 0x325e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC3_MDM_HIGH_THR1"
      sgroup "VADC3_MDM_HIGH_THR1 (at 0x325f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80325f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x325f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC3_MDM_DATA0"
      sgroup "VADC3_MDM_DATA0 (at 0x3260)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC3_MDM_DATA1"
      sgroup "VADC3_MDM_DATA1 (at 0x3261)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC3_MDM_SEC_ACCESS"
      sgroup "VADC3_MDM_SEC_ACCESS (at 0x32d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL1"
      sgroup "VADC3_MDM_PERPH_RESET_CTL1 (at 0x32d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL2"
      sgroup "VADC3_MDM_PERPH_RESET_CTL2 (at 0x32d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL3"
      sgroup "VADC3_MDM_PERPH_RESET_CTL3 (at 0x32da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VADC3_MDM_PERPH_RESET_CTL4"
      sgroup "VADC3_MDM_PERPH_RESET_CTL4 (at 0x32db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VADC3_MDM_INT_TEST1"
      sgroup "VADC3_MDM_INT_TEST1 (at 0x32e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "VADC3_MDM_INT_TEST_VAL"
      sgroup "VADC3_MDM_INT_TEST_VAL (at 0x32e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0, 1"
    tree.end
    tree "VADC3_MDM_TEST6_DTEST"
      sgroup "VADC3_MDM_TEST6_DTEST (at 0x32e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "VIB1"
  tree "VIB1"
    tree "VIB1_REVISION1"
      sgroup "VIB1_REVISION1 (at 0x1c000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VIB1_REVISION2"
      sgroup "VIB1_REVISION2 (at 0x1c001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VIB1_REVISION3"
      sgroup "VIB1_REVISION3 (at 0x1c002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VIB1_REVISION4"
      sgroup "VIB1_REVISION4 (at 0x1c003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VIB1_PERPH_TYPE"
      sgroup "VIB1_PERPH_TYPE (at 0x1c004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VIB1_PERPH_SUBTYPE"
      sgroup "VIB1_PERPH_SUBTYPE (at 0x1c005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VIB1_STATUS1"
      sgroup "VIB1_STATUS1 (at 0x1c008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VIB_OK                                   = " "0, 1"
    tree.end
    tree "VIB1_VOLTAGE_CTL2"
      sgroup "VIB1_VOLTAGE_CTL2 (at 0x1c041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   V_SET                                    = "
    tree.end
    tree "VIB1_EN_CTL"
      sgroup "VIB1_EN_CTL (at 0x1c046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   INV_DTEST                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_DTEST3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_DTEST2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_DTEST1                            = " "0, 1"
    tree.end
    tree "VIB1_SEC_ACCESS"
      sgroup "VIB1_SEC_ACCESS (at 0x1c0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VIB1_PERPH_RESET_CTL1"
      sgroup "VIB1_PERPH_RESET_CTL1 (at 0x1c0d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VIB1_PERPH_RESET_CTL2"
      sgroup "VIB1_PERPH_RESET_CTL2 (at 0x1c0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VIB1_PERPH_RESET_CTL3"
      sgroup "VIB1_PERPH_RESET_CTL3 (at 0x1c0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VIB1_PERPH_RESET_CTL4"
      sgroup "VIB1_PERPH_RESET_CTL4 (at 0x1c0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VIB1_TEST1"
      sgroup "VIB1_TEST1 (at 0x1c0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ILIM_REDUCTION                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST_VIB_OUT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST_ISENSE                             = " "0, 1"
    tree.end
  tree.end
tree.end
tree "VREFLPDDR"
  tree "VREFLPDDR"
    tree "VREFLPDDR_REVISION1"
      sgroup "VREFLPDDR_REVISION1 (at 0xa00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION2"
      sgroup "VREFLPDDR_REVISION2 (at 0xa01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION3"
      sgroup "VREFLPDDR_REVISION3 (at 0xa02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREFLPDDR_REVISION4"
      sgroup "VREFLPDDR_REVISION4 (at 0xa03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREFLPDDR_PERPH_TYPE"
      sgroup "VREFLPDDR_PERPH_TYPE (at 0xa04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREFLPDDR_PERPH_SUBTYPE"
      sgroup "VREFLPDDR_PERPH_SUBTYPE (at 0xa05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREFLPDDR_STATUS1"
      sgroup "VREFLPDDR_STATUS1 (at 0xa08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_LPDDR_OK                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_VREF_LPDDR2_EN"
      sgroup "VREFLPDDR_VREF_LPDDR2_EN (at 0xa44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN1                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_EN_CTL1"
      sgroup "VREFLPDDR_EN_CTL1 (at 0xa46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "VREFLPDDR_SEC_ACCESS"
      sgroup "VREFLPDDR_SEC_ACCESS (at 0xad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL1"
      sgroup "VREFLPDDR_PERPH_RESET_CTL1 (at 0xad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL2"
      sgroup "VREFLPDDR_PERPH_RESET_CTL2 (at 0xad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL3"
      sgroup "VREFLPDDR_PERPH_RESET_CTL3 (at 0xada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREFLPDDR_PERPH_RESET_CTL4"
      sgroup "VREFLPDDR_PERPH_RESET_CTL4 (at 0xadb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VREFLPDDR_TRIM_NUM"
      sgroup "VREFLPDDR_TRIM_NUM (at 0xaf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREFLPDDR_TRIM_VAL"
      sgroup "VREFLPDDR_TRIM_VAL (at 0xaf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_LPDDR2_TRIM_VALUE                   = "
    tree.end
  tree.end
tree.end
tree "WLED1"
  tree "WLED1"
    tree "WLED1_REVISION1"
      sgroup "WLED1_REVISION1 (at 0x1d800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_REVISION2"
      sgroup "WLED1_REVISION2 (at 0x1d801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_REVISION3"
      sgroup "WLED1_REVISION3 (at 0x1d802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_REVISION4"
      sgroup "WLED1_REVISION4 (at 0x1d803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_PERPH_TYPE"
      sgroup "WLED1_PERPH_TYPE (at 0x1d804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_PERPH_SUBTYPE"
      sgroup "WLED1_PERPH_SUBTYPE (at 0x1d805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_FAULT_STATUS"
      sgroup "WLED1_FAULT_STATUS (at 0x1d808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT                               = " "0, 1"
    tree.end
    tree "WLED1_INT_RT_STS"
      sgroup "WLED1_INT_RT_STS (at 0x1d810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_RT_STS                        = " "0, 1"
    tree.end
    tree "WLED1_INT_SET_TYPE"
      sgroup "WLED1_INT_SET_TYPE (at 0x1d811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TYPE                          = " "0, 1"
    tree.end
    tree "WLED1_INT_POLARITY_HIGH"
      sgroup "WLED1_INT_POLARITY_HIGH (at 0x1d812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_HIGH                          = " "0, 1"
    tree.end
    tree "WLED1_INT_POLARITY_LOW"
      sgroup "WLED1_INT_POLARITY_LOW (at 0x1d813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LOW                           = " "0, 1"
    tree.end
    tree "WLED1_INT_LATCHED_CLR"
      sgroup "WLED1_INT_LATCHED_CLR (at 0x1d814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "WLED1_INT_EN_SET"
      sgroup "WLED1_INT_EN_SET (at 0x1d815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_SET                        = " "0, 1"
    tree.end
    tree "WLED1_INT_EN_CLR"
      sgroup "WLED1_INT_EN_CLR (at 0x1d816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "WLED1_INT_LATCHED_STS"
      sgroup "WLED1_INT_LATCHED_STS (at 0x1d818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "WLED1_INT_PENDING_STS"
      sgroup "WLED1_INT_PENDING_STS (at 0x1d819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_PENDING_STS                   = " "0, 1"
    tree.end
    tree "WLED1_INT_MID_SEL"
      sgroup "WLED1_INT_MID_SEL (at 0x1d81a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d81a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_INT_PRIORITY"
      sgroup "WLED1_INT_PRIORITY (at 0x1d81b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d81b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "WLED1_LED1_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_LED1_BRIGHTNESS_SETTING_LSB (at 0x1d840)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_LED1_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_LED1_BRIGHTNESS_SETTING_MSB (at 0x1d841)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_LED2_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_LED2_BRIGHTNESS_SETTING_LSB (at 0x1d842)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_LED2_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_LED2_BRIGHTNESS_SETTING_MSB (at 0x1d843)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_LED3_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_LED3_BRIGHTNESS_SETTING_LSB (at 0x1d844)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED3_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_LED3_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_LED3_BRIGHTNESS_SETTING_MSB (at 0x1d845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_MODULE_ENABLE"
      sgroup "WLED1_MODULE_ENABLE (at 0x1d846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0, 1"
    tree.end
    tree "WLED1_ILED_SYNC_BIT"
      sgroup "WLED1_ILED_SYNC_BIT (at 0x1d847)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC_LED3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_LED2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_LED1                                = " "0, 1"
    tree.end
    tree "WLED1_FEEDBACK_CONTROL"
      sgroup "WLED1_FEEDBACK_CONTROL (at 0x1d848)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FEEDBACK_CONTROL                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_VREF_CONTROL"
      sgroup "WLED1_VREF_CONTROL (at 0x1d849)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VREF_CONTROL                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_MODULATION_SCHEME"
      sgroup "WLED1_MODULATION_SCHEME (at 0x1d84a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   MODULATOR_CLOCK_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INTERNAL_MOD_RESOLUTION                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIMMING_METHOD                           = " "0, 1"
    tree.end
    tree "WLED1_BOOST_MAX_DUTY_CYCLE"
      sgroup "WLED1_BOOST_MAX_DUTY_CYCLE (at 0x1d84b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_MAX_DUTY_CYCLE                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_SWITCHING_FREQUENCY"
      sgroup "WLED1_SWITCHING_FREQUENCY (at 0x1d84c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SWITCHING_FREQ                           = "
    tree.end
    tree "WLED1_WLED_OVP"
      sgroup "WLED1_WLED_OVP (at 0x1d84d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WLED_OVP                                 = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_WLED_ILIM"
      sgroup "WLED1_WLED_ILIM (at 0x1d84e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WLED_ILIM                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_EN_CURRENT_SINK"
      sgroup "WLED1_EN_CURRENT_SINK (at 0x1d84f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_SINK3                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_CURRENT_SINK2                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_CURRENT_SINK1                         = " "0, 1"
    tree.end
    tree "WLED1_SLOPE_COMP_CAP"
      sgroup "WLED1_SLOPE_COMP_CAP (at 0x1d850)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SLOPE_COMP_ADJ"
      sgroup "WLED1_SLOPE_COMP_ADJ (at 0x1d851)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SLOPE_COMP_ADJ                           = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_BIAS_GEN_WARMUP_DELAY"
      sgroup "WLED1_BIAS_GEN_WARMUP_DELAY (at 0x1d852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BIAS_GEN_WARMUP_DELAY                    = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_SOFTSTART_RAMP_DELAY"
      sgroup "WLED1_SOFTSTART_RAMP_DELAY (at 0x1d853)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SOFTSTART_RAMP_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SW_SLEW_RATE_CONTROL"
      sgroup "WLED1_SW_SLEW_RATE_CONTROL (at 0x1d854)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SW_SLEW_RATE_CONTROL                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_VLOOP_COMP_RES"
      sgroup "WLED1_VLOOP_COMP_RES (at 0x1d855)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_COMP_RES                            = "
    tree.end
    tree "WLED1_VLOOP_COMP_GM"
      sgroup "WLED1_VLOOP_COMP_GM (at 0x1d856)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_EA_GM                               = "
    tree.end
    tree "WLED1_VLOOP_COMP_CAP"
      sgroup "WLED1_VLOOP_COMP_CAP (at 0x1d857)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_CAP                           = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_VLOOP_COMP_HCAP"
      sgroup "WLED1_VLOOP_COMP_HCAP (at 0x1d858)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOOP_COMP_HCAP                          = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_EN_HW_BL_REDN"
      sgroup "WLED1_EN_HW_BL_REDN (at 0x1d859)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_HW_BL_REDN                            = " "0, 1"
    tree.end
    tree "WLED1_LED1_MODULATOR_EN"
      sgroup "WLED1_LED1_MODULATOR_EN (at 0x1d860)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_EN_MODULATOR                        = " "0, 1"
    tree.end
    tree "WLED1_LED1_IDAC_SYNC_DELAY"
      sgroup "WLED1_LED1_IDAC_SYNC_DELAY (at 0x1d861)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED1_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_LED1_FULL_SCALE_CURRENT"
      sgroup "WLED1_LED1_FULL_SCALE_CURRENT (at 0x1d862)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED1_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_LED1_MODULATOR_SRC_SEL"
      sgroup "WLED1_LED1_MODULATOR_SRC_SEL (at 0x1d863)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_LED1_CABC_EN"
      sgroup "WLED1_LED1_CABC_EN (at 0x1d866)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_LED2_MODULATOR_EN"
      sgroup "WLED1_LED2_MODULATOR_EN (at 0x1d870)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_EN_MODULATOR                        = " "0, 1"
    tree.end
    tree "WLED1_LED2_IDAC_SYNC_DELAY"
      sgroup "WLED1_LED2_IDAC_SYNC_DELAY (at 0x1d871)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED2_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_LED2_FULL_SCALE_CURRENT"
      sgroup "WLED1_LED2_FULL_SCALE_CURRENT (at 0x1d872)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED2_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_LED2_MODULATOR_SRC_SEL"
      sgroup "WLED1_LED2_MODULATOR_SRC_SEL (at 0x1d873)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_LED2_CABC_EN"
      sgroup "WLED1_LED2_CABC_EN (at 0x1d876)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_LED3_MODULATOR_EN"
      sgroup "WLED1_LED3_MODULATOR_EN (at 0x1d880)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_EN_MODULATOR                        = " "0, 1"
    tree.end
    tree "WLED1_LED3_IDAC_SYNC_DELAY"
      sgroup "WLED1_LED3_IDAC_SYNC_DELAY (at 0x1d881)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED3_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_LED3_FULL_SCALE_CURRENT"
      sgroup "WLED1_LED3_FULL_SCALE_CURRENT (at 0x1d882)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED3_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_LED3_MODULATOR_SRC_SEL"
      sgroup "WLED1_LED3_MODULATOR_SRC_SEL (at 0x1d883)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED3_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_LED3_CABC_EN"
      sgroup "WLED1_LED3_CABC_EN (at 0x1d886)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SEC_ACCESS"
      sgroup "WLED1_SEC_ACCESS (at 0x1d8d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_PERPH_RESET_CTL1"
      sgroup "WLED1_PERPH_RESET_CTL1 (at 0x1d8d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "WLED1_PERPH_RESET_CTL2"
      sgroup "WLED1_PERPH_RESET_CTL2 (at 0x1d8d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "WLED1_PERPH_RESET_CTL3"
      sgroup "WLED1_PERPH_RESET_CTL3 (at 0x1d8da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "WLED1_PERPH_RESET_CTL4"
      sgroup "WLED1_PERPH_RESET_CTL4 (at 0x1d8db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "WLED1_INT_TEST1"
      sgroup "WLED1_INT_TEST1 (at 0x1d8e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "WLED1_INT_TEST_VAL"
      sgroup "WLED1_INT_TEST_VAL (at 0x1d8e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TEST_VAL                      = " "0, 1"
    tree.end
    tree "WLED1_TEST1"
      sgroup "WLED1_TEST1 (at 0x1d8e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "WLED1_TEST2"
      sgroup "WLED1_TEST2 (at 0x1d8e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_TEST3"
      sgroup "WLED1_TEST3 (at 0x1d8e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDSON_TM                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERRAMP_TRIM_CL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVP_EN_MASK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SLOPE_COMP_EN_MASK                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_REF_EN_MASK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIM_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ERRAMP_EN_MASK                           = " "0, 1"
    tree.end
    tree "WLED1_TEST4"
      sgroup "WLED1_TEST4 (at 0x1d8e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEBOUNCE_BYPASS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_SLEEP_CLK_REQUEST                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SOFT_START                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_DIM_SAMPLE_HOLD                      = " "0, 1"
    tree.end
    tree "WLED1_TRIM_NUM"
      sgroup "WLED1_TRIM_NUM (at 0x1d8f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_TRIM_VREF_ILED1"
      sgroup "WLED1_TRIM_VREF_ILED1 (at 0x1d8f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_VREF_ILED1                          = "
    tree.end
    tree "WLED1_TRIM_VREF_ILED2"
      sgroup "WLED1_TRIM_VREF_ILED2 (at 0x1d8f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_VREF_ILED2                          = "
    tree.end
    tree "WLED1_TRIM_VREF_ILED3"
      sgroup "WLED1_TRIM_VREF_ILED3 (at 0x1d8f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_VREF_ILED3                          = "
    tree.end
    tree "WLED1_TRIM_OFFSET_ILED1"
      sgroup "WLED1_TRIM_OFFSET_ILED1 (at 0x1d8f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_OFFSET_ILED1                        = "
    tree.end
    tree "WLED1_TRIM_OFFSET_ILED2"
      sgroup "WLED1_TRIM_OFFSET_ILED2 (at 0x1d8f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_OFFSET_ILED2                        = "
    tree.end
    tree "WLED1_TRIM_OFFSET_ILED3"
      sgroup "WLED1_TRIM_OFFSET_ILED3 (at 0x1d8f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_OFFSET_ILED3                        = "
    tree.end
    tree "WLED1_TRIM_ILIM"
      sgroup "WLED1_TRIM_ILIM (at 0x1d8f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_ILIM                                = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      sgroup "XO_REVISION1 (at 0x5000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      sgroup "XO_REVISION2 (at 0x5001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      sgroup "XO_REVISION3 (at 0x5002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      sgroup "XO_REVISION4 (at 0x5003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      sgroup "XO_PERPH_TYPE (at 0x5004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      sgroup "XO_PERPH_SUBTYPE (at 0x5005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      sgroup "XO_STATUS1 (at 0x5008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_OK                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SLEEP_B                                  = " "0, 1"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      sgroup "XO_VOLTAGE_CTL1 (at 0x5040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0, 1, 2, 3"
    tree.end
    tree "XO_MODE_CTL1"
      sgroup "XO_MODE_CTL1 (at 0x5044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RF_PREBUFF_MODE                          = " "0, 1, 2, 3"
    tree.end
    tree "XO_EN_CTL"
      sgroup "XO_EN_CTL (at 0x5046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0, 1"
    tree.end
    tree "XO_XO_TIMER1"
      sgroup "XO_XO_TIMER1 (at 0x504c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   XO_TIMER_LSB                             = "
    tree.end
    tree "XO_XO_TIMER2"
      sgroup "XO_XO_TIMER2 (at 0x504d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   XO_TIMER_MSB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "XO_XO_STEPPER"
      sgroup "XO_XO_STEPPER (at 0x505a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_SS_DELAY_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_SS_DELAY                              = "
    tree.end
    tree "XO_XO_ADJ_FINE"
      sgroup "XO_XO_ADJ_FINE (at 0x505c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   XO_ADJUST_CAP                            = "
    tree.end
    tree "XO_XO_ADJ_COARSE"
      sgroup "XO_XO_ADJ_COARSE (at 0x505b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_FIXED_CAP_EN1                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XO_FIXED_CAP_EN2                         = " "0, 1"
    tree.end
    tree "XO_XO_CTL"
      sgroup "XO_XO_CTL (at 0x505e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICTL3                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ICTL2                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ICTL1                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_RATE                                  = " "0, 1, 2, 3"
    tree.end
    tree "XO_SEC_ACCESS"
      sgroup "XO_SEC_ACCESS (at 0x50d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "XO_PERPH_RESET_CTL2"
      sgroup "XO_PERPH_RESET_CTL2 (at 0x50d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "XO_PERPH_RESET_CTL3"
      sgroup "XO_PERPH_RESET_CTL3 (at 0x50da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "XO_PERPH_RESET_CTL4"
      sgroup "XO_PERPH_RESET_CTL4 (at 0x50db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "XO_TEST1"
      sgroup "XO_TEST1 (at 0x50e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST1_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   XO_AGC_TEST_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADJ_CODE_TEST                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SS_RESET                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUF_FOLLOW_BB                      = " "0, 1"
    tree.end
    tree "XO_TEST2"
      sgroup "XO_TEST2 (at 0x50e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RF_OUT_DTEST                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RF_OUT_TEST                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BB_OUT_DTEST                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BB_OUT_TEST                              = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end

