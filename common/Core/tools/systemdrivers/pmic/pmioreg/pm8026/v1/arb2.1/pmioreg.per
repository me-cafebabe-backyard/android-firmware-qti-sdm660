entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BB_CLK1"
  tree "BB_CLK1"
    tree "BB_CLK1_REVISION1"
      sgroup "BB_CLK1_REVISION1 (at 0x5100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION2"
      sgroup "BB_CLK1_REVISION2 (at 0x5101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK1_REVISION3"
      sgroup "BB_CLK1_REVISION3 (at 0x5102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK1_REVISION4"
      sgroup "BB_CLK1_REVISION4 (at 0x5103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK1_PERPH_TYPE"
      sgroup "BB_CLK1_PERPH_TYPE (at 0x5104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK1_PERPH_SUBTYPE"
      sgroup "BB_CLK1_PERPH_SUBTYPE (at 0x5105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK1_STATUS1"
      sgroup "BB_CLK1_STATUS1 (at 0x5108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0, 1"
    tree.end
    tree "BB_CLK1_DRV_CTL1"
      sgroup "BB_CLK1_DRV_CTL1 (at 0x5144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0, 1, 2, 3"
    tree.end
    tree "BB_CLK1_EN_CTL"
      sgroup "BB_CLK1_EN_CTL (at 0x5146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0, 1"
    tree.end
    tree "BB_CLK1_PD_CTL"
      sgroup "BB_CLK1_PD_CTL (at 0x5148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "BB_CLK1_SEC_ACCESS"
      sgroup "BB_CLK1_SEC_ACCESS (at 0x51d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL1"
      sgroup "BB_CLK1_PERPH_RESET_CTL1 (at 0x51d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL2"
      sgroup "BB_CLK1_PERPH_RESET_CTL2 (at 0x51d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL3"
      sgroup "BB_CLK1_PERPH_RESET_CTL3 (at 0x51da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK1_PERPH_RESET_CTL4"
      sgroup "BB_CLK1_PERPH_RESET_CTL4 (at 0x51db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "BB_CLK2"
  tree "BB_CLK2"
    tree "BB_CLK2_REVISION1"
      sgroup "BB_CLK2_REVISION1 (at 0x5200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BB_CLK2_REVISION2"
      sgroup "BB_CLK2_REVISION2 (at 0x5201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BB_CLK2_REVISION3"
      sgroup "BB_CLK2_REVISION3 (at 0x5202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BB_CLK2_REVISION4"
      sgroup "BB_CLK2_REVISION4 (at 0x5203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BB_CLK2_PERPH_TYPE"
      sgroup "BB_CLK2_PERPH_TYPE (at 0x5204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BB_CLK2_PERPH_SUBTYPE"
      sgroup "BB_CLK2_PERPH_SUBTYPE (at 0x5205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BB_CLK2_STATUS1"
      sgroup "BB_CLK2_STATUS1 (at 0x5208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0, 1"
    tree.end
    tree "BB_CLK2_DRV_CTL1"
      sgroup "BB_CLK2_DRV_CTL1 (at 0x5244)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0, 1, 2, 3"
    tree.end
    tree "BB_CLK2_EN_CTL"
      sgroup "BB_CLK2_EN_CTL (at 0x5246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0, 1"
    tree.end
    tree "BB_CLK2_PD_CTL"
      sgroup "BB_CLK2_PD_CTL (at 0x5248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "BB_CLK2_SEC_ACCESS"
      sgroup "BB_CLK2_SEC_ACCESS (at 0x52d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL1"
      sgroup "BB_CLK2_PERPH_RESET_CTL1 (at 0x52d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL2"
      sgroup "BB_CLK2_PERPH_RESET_CTL2 (at 0x52d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL3"
      sgroup "BB_CLK2_PERPH_RESET_CTL3 (at 0x52da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BB_CLK2_PERPH_RESET_CTL4"
      sgroup "BB_CLK2_PERPH_RESET_CTL4 (at 0x52db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      sgroup "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      sgroup "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      sgroup "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      sgroup "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      sgroup "BCLK_GEN_MAIN_STATUS (at 0x11008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      sgroup "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      sgroup "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      sgroup "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      sgroup "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      sgroup "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      sgroup "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      sgroup "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      sgroup "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      sgroup "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0, 1, 2, 3"
    tree.end
    tree "BCLK_GEN_MAIN_QM_MODE"
      sgroup "BCLK_GEN_MAIN_QM_MODE (at 0x11051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      sgroup "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      sgroup "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      sgroup "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      sgroup "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      sgroup "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      sgroup "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      sgroup "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "BMS1"
  tree "BMS1"
    tree "BMS1_REVISION1"
      sgroup "BMS1_REVISION1 (at 0x4000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BMS1_REVISION2"
      sgroup "BMS1_REVISION2 (at 0x4001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BMS1_PERPH_TYPE"
      sgroup "BMS1_PERPH_TYPE (at 0x4004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BMS1_PERPH_SUBTYPE"
      sgroup "BMS1_PERPH_SUBTYPE (at 0x4005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BMS1_STATUS1"
      sgroup "BMS1_STATUS1 (at 0x4008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BMS_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   OCV_FSM_STATE                            = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSENSE_FSM_STATE                         = " "0 (S4),1 (S1),2 (S2),3 (S3),4 (reserved),5 (reserved),6 (S6),7 (S7)"
    tree.end
    tree "BMS1_INT_RT_STS"
      sgroup "BMS1_INT_RT_STS (at 0x4010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_RT_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_RT_STS                        = " "0, 1"
    tree.end
    tree "BMS1_INT_SET_TYPE"
      sgroup "BMS1_INT_SET_TYPE (at 0x4011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_TYPE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_TYPE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_TYPE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_TYPE                          = " "0, 1"
    tree.end
    tree "BMS1_INT_POLARITY_HIGH"
      sgroup "BMS1_INT_POLARITY_HIGH (at 0x4012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_HIGH                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_HIGH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_HIGH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_HIGH                          = " "0, 1"
    tree.end
    tree "BMS1_INT_POLARITY_LOW"
      sgroup "BMS1_INT_POLARITY_LOW (at 0x4013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_LOW                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_LOW                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_LOW                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_LOW                           = " "0, 1"
    tree.end
    tree "BMS1_INT_LATCHED_CLR"
      sgroup "BMS1_INT_LATCHED_CLR (at 0x4014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_CLR                           = " "0, 1"
    tree.end
    tree "BMS1_INT_EN_SET"
      sgroup "BMS1_INT_EN_SET (at 0x4015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_EN_SET                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_EN_SET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_EN_SET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_EN_SET                        = " "0, 1"
    tree.end
    tree "BMS1_INT_EN_CLR"
      sgroup "BMS1_INT_EN_CLR (at 0x4016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_EN_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_EN_CLR                        = " "0, 1"
    tree.end
    tree "BMS1_INT_LATCHED_STS"
      sgroup "BMS1_INT_LATCHED_STS (at 0x4018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_LATCHED_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_LATCHED_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_LATCHED_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "BMS1_INT_PENDING_STS"
      sgroup "BMS1_INT_PENDING_STS (at 0x4019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_PENDING_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_PENDING_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_PENDING_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_PENDING_STS                   = " "0, 1"
    tree.end
    tree "BMS1_INT_MID_SEL"
      sgroup "BMS1_INT_MID_SEL (at 0x401a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BMS1_INT_PRIORITY"
      sgroup "BMS1_INT_PRIORITY (at 0x401b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RFU                                      = " "0, 1"
    tree.end
    tree "BMS1_MODE_CTL"
      sgroup "BMS1_MODE_CTL (at 0x4040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BMS_OVERRIDE_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_VCP_OVERRIDE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_VBAT                                  = " "0, 1"
    tree.end
    tree "BMS1_CC_DATA_CTL"
      sgroup "BMS1_CC_DATA_CTL (at 0x4042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CC_MANUAL_RESET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_OREG_DATA                           = " "0, 1"
    tree.end
    tree "BMS1_CC_CLEAR_CTL"
      sgroup "BMS1_CC_CLEAR_CTL (at 0x4043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLEAR_CC                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLEAR_SW_CC                              = " "0, 1"
    tree.end
    tree "BMS1_TOL_CTL"
      sgroup "BMS1_TOL_CTL (at 0x4044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   OCV_TOL                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IBAT_TOL                                 = "
    tree.end
    tree "BMS1_EN_CTL1"
      sgroup "BMS1_EN_CTL1 (at 0x4046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BMS_EN                                   = " "0, 1"
    tree.end
    tree "BMS1_OCV_USE_LOW_LIMIT_THR0"
      sgroup "BMS1_OCV_USE_LOW_LIMIT_THR0 (at 0x4048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_USE_LOW_LIMIT_THR_7_0                = "
    tree.end
    tree "BMS1_OCV_USE_LOW_LIMIT_THR1"
      sgroup "BMS1_OCV_USE_LOW_LIMIT_THR1 (at 0x4049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_USE_LOW_LIMIT_THR_15_8               = "
    tree.end
    tree "BMS1_OCV_USE_HIGH_LIMIT_THR0"
      sgroup "BMS1_OCV_USE_HIGH_LIMIT_THR0 (at 0x404a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_USE_HIGH_LIMIT_THR_7_0               = "
    tree.end
    tree "BMS1_OCV_USE_HIGH_LIMIT_THR1"
      sgroup "BMS1_OCV_USE_HIGH_LIMIT_THR1 (at 0x404b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_USE_HIGH_LIMIT_THR_15_8              = "
    tree.end
    tree "BMS1_OCV_USE_LIMIT_CTL"
      sgroup "BMS1_OCV_USE_LIMIT_CTL (at 0x404c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCV_USE_LIMIT_EN                         = " "0, 1"
    tree.end
    tree "BMS1_OCV_THR0"
      sgroup "BMS1_OCV_THR0 (at 0x4050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_THR_7_0                              = "
    tree.end
    tree "BMS1_OCV_THR1"
      sgroup "BMS1_OCV_THR1 (at 0x4051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_THR_15_8                             = "
    tree.end
    tree "BMS1_OCV_THR_CTL"
      sgroup "BMS1_OCV_THR_CTL (at 0x4053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCV_THR_EN                               = " "0, 1"
    tree.end
    tree "BMS1_S1_DELAY_CTL"
      sgroup "BMS1_S1_DELAY_CTL (at 0x405a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMPLE_DELAY_LOW_LOAD                    = "
    tree.end
    tree "BMS1_S2_DELAY_CTL"
      sgroup "BMS1_S2_DELAY_CTL (at 0x405b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMPLE_DELAY_HIGH_LOAD                   = "
    tree.end
    tree "BMS1_S6_DELAY_CTL"
      sgroup "BMS1_S6_DELAY_CTL (at 0x405c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMPLE_DELAY_OVERRIDE                    = "
    tree.end
    tree "BMS1_S7_DELAY_CTL"
      sgroup "BMS1_S7_DELAY_CTL (at 0x405d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80405d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x405d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMPLE_DELAY_PON_OCV                     = "
    tree.end
    tree "BMS1_S1_SAMP_AVG_CTL"
      sgroup "BMS1_S1_SAMP_AVG_CTL (at 0x4060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SAMP_AVG_LOW_LOAD                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S2_SAMP_AVG_CTL"
      sgroup "BMS1_S2_SAMP_AVG_CTL (at 0x4061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SAMP_AVG_HIGH_LOAD                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S3_SAMP_AVG_CTL"
      sgroup "BMS1_S3_SAMP_AVG_CTL (at 0x4062)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SAMP_AVG_MEAS_OCV                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S4_SAMP_AVG_CTL"
      sgroup "BMS1_S4_SAMP_AVG_CTL (at 0x4063)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SAMP_AVG_MEAS_RBAT                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S6_SAMP_AVG_CTL"
      sgroup "BMS1_S6_SAMP_AVG_CTL (at 0x4064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMP_AVG_OVERRIDE                        = "
    tree.end
    tree "BMS1_S7_SAMP_AVG_CTL"
      sgroup "BMS1_S7_SAMP_AVG_CTL (at 0x4065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SAMP_AVG_PON_OCV                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S1_CNT_CTL"
      sgroup "BMS1_S1_CNT_CTL (at 0x406a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HIGH_CNT_THR_LOW_LOAD                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LOW_CNT_THR_LOW_LOAD                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S2_CNT_CTL1"
      sgroup "BMS1_S2_CNT_CTL1 (at 0x406c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   HIGH_CNT_THR_HIGH_LOAD                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LOW_CNT_THR_HIGH_LOAD                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S2_CNT_CTL2"
      sgroup "BMS1_S2_CNT_CTL2 (at 0x406d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   META_CNT_THR_HIGH_LOAD                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S3_CNT_CTL"
      sgroup "BMS1_S3_CNT_CTL (at 0x406f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   META_CNT_THR_MEAS_OCV                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S4_CNT_CTL"
      sgroup "BMS1_S4_CNT_CTL (at 0x4071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   META_CNT_THR_MEAS_RBAT                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BMS1_S1_VSENSE_THR_CTL"
      sgroup "BMS1_S1_VSENSE_THR_CTL (at 0x4073)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_THR_LOW_LOAD                      = "
    tree.end
    tree "BMS1_S2_VSENSE_THR_CTL"
      sgroup "BMS1_S2_VSENSE_THR_CTL (at 0x4075)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_THR_HIGH_LOAD                     = "
    tree.end
    tree "BMS1_S3_VSENSE_THR_CTL"
      sgroup "BMS1_S3_VSENSE_THR_CTL (at 0x4077)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_THR_MEAS_OCV                      = "
    tree.end
    tree "BMS1_S4_VSENSE_THR_CTL"
      sgroup "BMS1_S4_VSENSE_THR_CTL (at 0x4079)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_THR_MEAS_RBAT                     = "
    tree.end
    tree "BMS1_CC_THR0"
      sgroup "BMS1_CC_THR0 (at 0x407a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80407a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x407a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_THR_7_0                               = "
    tree.end
    tree "BMS1_CC_THR1"
      sgroup "BMS1_CC_THR1 (at 0x407b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80407b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x407b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_THR_15_8                              = "
    tree.end
    tree "BMS1_CC_THR2"
      sgroup "BMS1_CC_THR2 (at 0x407c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80407c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x407c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_THR_23_16                             = "
    tree.end
    tree "BMS1_CC_THR3"
      sgroup "BMS1_CC_THR3 (at 0x407d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80407d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x407d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_THR_31_24                             = "
    tree.end
    tree "BMS1_CC_THR4"
      sgroup "BMS1_CC_THR4 (at 0x407e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80407e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x407e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CC_THR_35_32                             = "
    tree.end
    tree "BMS1_OCV_FOR_R_DATA0"
      sgroup "BMS1_OCV_FOR_R_DATA0 (at 0x4080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_FOR_R_7_0                            = "
    tree.end
    tree "BMS1_OCV_FOR_R_DATA1"
      sgroup "BMS1_OCV_FOR_R_DATA1 (at 0x4081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_FOR_R_15_8                           = "
    tree.end
    tree "BMS1_VSENSE_FOR_R_DATA0"
      sgroup "BMS1_VSENSE_FOR_R_DATA0 (at 0x4082)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_FOR_R_7_0                         = "
    tree.end
    tree "BMS1_VSENSE_FOR_R_DATA1"
      sgroup "BMS1_VSENSE_FOR_R_DATA1 (at 0x4083)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_FOR_R_15_8                        = "
    tree.end
    tree "BMS1_VBAT_FOR_R_DATA0"
      sgroup "BMS1_VBAT_FOR_R_DATA0 (at 0x4084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_FOR_R_7_0                           = "
    tree.end
    tree "BMS1_VBAT_FOR_R_DATA1"
      sgroup "BMS1_VBAT_FOR_R_DATA1 (at 0x4085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_FOR_R_15_8                          = "
    tree.end
    tree "BMS1_CC_DATA0"
      sgroup "BMS1_CC_DATA0 (at 0x408a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80408a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x408a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_DATA_7_0                              = "
    tree.end
    tree "BMS1_CC_DATA1"
      sgroup "BMS1_CC_DATA1 (at 0x408b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80408b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x408b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_DATA_15_8                             = "
    tree.end
    tree "BMS1_CC_DATA2"
      sgroup "BMS1_CC_DATA2 (at 0x408c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80408c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x408c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_DATA_23_16                            = "
    tree.end
    tree "BMS1_CC_DATA3"
      sgroup "BMS1_CC_DATA3 (at 0x408d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80408d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x408d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CC_DATA_31_24                            = "
    tree.end
    tree "BMS1_CC_DATA4"
      sgroup "BMS1_CC_DATA4 (at 0x408e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80408e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x408e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CC_DATA_35_32                            = "
    tree.end
    tree "BMS1_OCV_FOR_SOC_DATA0"
      sgroup "BMS1_OCV_FOR_SOC_DATA0 (at 0x4090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_FOR_SOC_7_0                          = "
    tree.end
    tree "BMS1_OCV_FOR_SOC_DATA1"
      sgroup "BMS1_OCV_FOR_SOC_DATA1 (at 0x4091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OCV_FOR_SOC_15_8                         = "
    tree.end
    tree "BMS1_VSENSE_PON_DATA0"
      sgroup "BMS1_VSENSE_PON_DATA0 (at 0x4094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_PON_7_0                           = "
    tree.end
    tree "BMS1_VSENSE_PON_DATA1"
      sgroup "BMS1_VSENSE_PON_DATA1 (at 0x4095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_PON_15_8                          = "
    tree.end
    tree "BMS1_VSENSE_AVG_DATA0"
      sgroup "BMS1_VSENSE_AVG_DATA0 (at 0x4098)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_AVG_7_0                           = "
    tree.end
    tree "BMS1_VSENSE_AVG_DATA1"
      sgroup "BMS1_VSENSE_AVG_DATA1 (at 0x4099)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSENSE_AVG_15_8                          = "
    tree.end
    tree "BMS1_VBAT_AVG_DATA0"
      sgroup "BMS1_VBAT_AVG_DATA0 (at 0x409e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80409e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x409e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_AVG_7_0                             = "
    tree.end
    tree "BMS1_VBAT_AVG_DATA1"
      sgroup "BMS1_VBAT_AVG_DATA1 (at 0x409f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80409f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x409f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_AVG_15_8                            = "
    tree.end
    tree "BMS1_SW_CC_THR0"
      sgroup "BMS1_SW_CC_THR0 (at 0x40a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_THR_7_0                            = "
    tree.end
    tree "BMS1_SW_CC_THR1"
      sgroup "BMS1_SW_CC_THR1 (at 0x40a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_THR_15_8                           = "
    tree.end
    tree "BMS1_SW_CC_THR2"
      sgroup "BMS1_SW_CC_THR2 (at 0x40a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_THR_23_16                          = "
    tree.end
    tree "BMS1_SW_CC_THR3"
      sgroup "BMS1_SW_CC_THR3 (at 0x40a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_THR_31_24                          = "
    tree.end
    tree "BMS1_SW_CC_THR4"
      sgroup "BMS1_SW_CC_THR4 (at 0x40a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SW_CC_THR_35_32                          = "
    tree.end
    tree "BMS1_SW_CC_DATA0"
      sgroup "BMS1_SW_CC_DATA0 (at 0x40a8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_DATA_7_0                           = "
    tree.end
    tree "BMS1_SW_CC_DATA1"
      sgroup "BMS1_SW_CC_DATA1 (at 0x40a9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_DATA_15_8                          = "
    tree.end
    tree "BMS1_SW_CC_DATA2"
      sgroup "BMS1_SW_CC_DATA2 (at 0x40aa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_DATA_23_16                         = "
    tree.end
    tree "BMS1_SW_CC_DATA3"
      sgroup "BMS1_SW_CC_DATA3 (at 0x40ab)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_CC_DATA_31_24                         = "
    tree.end
    tree "BMS1_SW_CC_DATA4"
      sgroup "BMS1_SW_CC_DATA4 (at 0x40ac)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SW_CC_DATA_35_32                         = "
    tree.end
    tree "BMS1_BMS_DATA_REG_0"
      sgroup "BMS1_BMS_DATA_REG_0 (at 0x40b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_0                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_1"
      sgroup "BMS1_BMS_DATA_REG_1 (at 0x40b1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_1                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_2"
      sgroup "BMS1_BMS_DATA_REG_2 (at 0x40b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_2                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_3"
      sgroup "BMS1_BMS_DATA_REG_3 (at 0x40b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_3                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_4"
      sgroup "BMS1_BMS_DATA_REG_4 (at 0x40b4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_4                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_5"
      sgroup "BMS1_BMS_DATA_REG_5 (at 0x40b5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_5                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_6"
      sgroup "BMS1_BMS_DATA_REG_6 (at 0x40b6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_6                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_7"
      sgroup "BMS1_BMS_DATA_REG_7 (at 0x40b7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_7                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_8"
      sgroup "BMS1_BMS_DATA_REG_8 (at 0x40b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_8                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_9"
      sgroup "BMS1_BMS_DATA_REG_9 (at 0x40b9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_9                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_A"
      sgroup "BMS1_BMS_DATA_REG_A (at 0x40ba)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_A                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_B"
      sgroup "BMS1_BMS_DATA_REG_B (at 0x40bb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040bb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40bb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_B                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_C"
      sgroup "BMS1_BMS_DATA_REG_C (at 0x40bc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040bc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40bc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_C                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_D"
      sgroup "BMS1_BMS_DATA_REG_D (at 0x40bd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040bd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40bd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_D                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_E"
      sgroup "BMS1_BMS_DATA_REG_E (at 0x40be)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040be0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40be0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_E                           = "
    tree.end
    tree "BMS1_BMS_DATA_REG_F"
      sgroup "BMS1_BMS_DATA_REG_F (at 0x40bf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040bf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40bf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BMS_DATA_REG_F                           = "
    tree.end
    tree "BMS1_SEC_ACCESS"
      sgroup "BMS1_SEC_ACCESS (at 0x40d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BMS1_PERPH_RESET_CTL1"
      sgroup "BMS1_PERPH_RESET_CTL1 (at 0x40d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BMS1_PERPH_RESET_CTL2"
      sgroup "BMS1_PERPH_RESET_CTL2 (at 0x40d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BMS1_PERPH_RESET_CTL3"
      sgroup "BMS1_PERPH_RESET_CTL3 (at 0x40da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BMS1_PERPH_RESET_CTL4"
      sgroup "BMS1_PERPH_RESET_CTL4 (at 0x40db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BMS1_INT_TEST1"
      sgroup "BMS1_INT_TEST1 (at 0x40e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BMS1_INT_TEST_VAL"
      sgroup "BMS1_INT_TEST_VAL (at 0x40e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VSENSE_FOR_R_INT_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VSENSE_AVG_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_CC_THR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCV_THR_INT_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHARGE_BEGIN_INT_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GOOD_OCV_INT_TEST_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCV_FOR_R_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_THR_INT_TEST_VAL                      = " "0, 1"
    tree.end
    tree "BMS1_TEST1"
      sgroup "BMS1_TEST1 (at 0x40e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "BUA"
  tree "BUA"
    tree "BUA_REVISION1"
      sgroup "BUA_REVISION1 (at 0x1c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_REVISION2"
      sgroup "BUA_REVISION2 (at 0x1c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_PERPH_TYPE"
      sgroup "BUA_PERPH_TYPE (at 0x1c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_PERPH_SUBTYPE"
      sgroup "BUA_PERPH_SUBTYPE (at 0x1c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_STATUS1"
      sgroup "BUA_STATUS1 (at 0x1c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_GONE_DETECTED                       = " "0, 1"
    tree.end
    tree "BUA_STATUS2"
      sgroup "BUA_STATUS2 (at 0x1c09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC4_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC3_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC2_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UICC1_ALARM_DETECTED                     = " "0, 1"
    tree.end
    tree "BUA_INT_RT_STS"
      sgroup "BUA_INT_RT_STS (at 0x1c10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_STS                           = " "0, 1"
    tree.end
    tree "BUA_INT_SET_TYPE"
      sgroup "BUA_INT_SET_TYPE (at 0x1c11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TYPE                          = " "0, 1"
    tree.end
    tree "BUA_INT_POLARITY_HIGH"
      sgroup "BUA_INT_POLARITY_HIGH (at 0x1c12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_HIGH                          = " "0, 1"
    tree.end
    tree "BUA_INT_POLARITY_LOW"
      sgroup "BUA_INT_POLARITY_LOW (at 0x1c13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LOW                           = " "0, 1"
    tree.end
    tree "BUA_INT_LATCHED_CLR"
      sgroup "BUA_INT_LATCHED_CLR (at 0x1c14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "BUA_INT_EN_SET"
      sgroup "BUA_INT_EN_SET (at 0x1c15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_SET                        = " "0, 1"
    tree.end
    tree "BUA_INT_EN_CLR"
      sgroup "BUA_INT_EN_CLR (at 0x1c16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_CLR                        = " "0, 1"
    tree.end
    tree "BUA_INT_LATCHED_STS"
      sgroup "BUA_INT_LATCHED_STS (at 0x1c18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "BUA_INT_PENDING_STS"
      sgroup "BUA_INT_PENDING_STS (at 0x1c19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARMPENDING_STS                    = " "0, 1"
    tree.end
    tree "BUA_INT_MID_SEL"
      sgroup "BUA_INT_MID_SEL (at 0x1c1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BUA_INT_PRIORITY"
      sgroup "BUA_INT_PRIORITY (at 0x1c1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BUA_BUA_CTL1"
      sgroup "BUA_BUA_CTL1 (at 0x1c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LDO_SHUTDOWN_DELAY                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BUA_EN_CTL1"
      sgroup "BUA_EN_CTL1 (at 0x1c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0, 1"
    tree.end
    tree "BUA_SEC_ACCESS"
      sgroup "BUA_SEC_ACCESS (at 0x1cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_PERPH_RESET_CTL1"
      sgroup "BUA_PERPH_RESET_CTL1 (at 0x1cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL2"
      sgroup "BUA_PERPH_RESET_CTL2 (at 0x1cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL3"
      sgroup "BUA_PERPH_RESET_CTL3 (at 0x1cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL4"
      sgroup "BUA_PERPH_RESET_CTL4 (at 0x1cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUA_INT_TEST1"
      sgroup "BUA_INT_TEST1 (at 0x1ce0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BUA_INT_TEST_VAL"
      sgroup "BUA_INT_TEST_VAL (at 0x1ce1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TEST_VAL                      = " "0, 1"
    tree.end
    tree "BUA_TEST1"
      sgroup "BUA_TEST1 (at 0x1ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XORC19M2_CLK_SEL                         = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_32K_RC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0, 1"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      sgroup "CLK_DIST_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0, 1"
    tree.end
    tree "CLK_DIST_RC_CTL"
      sgroup "CLK_DIST_RC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0, 1"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0, 1"
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0, 1"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0, 1"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      sgroup "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      sgroup "CLK_DIST_RCLF_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "COIN"
  tree "COIN"
    tree "COIN_REVISION1"
      sgroup "COIN_REVISION1 (at 0x2800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "COIN_REVISION2"
      sgroup "COIN_REVISION2 (at 0x2801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "COIN_REVISION3"
      sgroup "COIN_REVISION3 (at 0x2802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "COIN_REVISION4"
      sgroup "COIN_REVISION4 (at 0x2803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "COIN_PERPH_TYPE"
      sgroup "COIN_PERPH_TYPE (at 0x2804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "COIN_PERPH_SUBTYPE"
      sgroup "COIN_PERPH_SUBTYPE (at 0x2805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "COIN_STATUS1"
      sgroup "COIN_STATUS1 (at 0x2808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COINCELL_OK                              = " "0, 1"
    tree.end
    tree "COIN_COIN_CHG_RSET"
      sgroup "COIN_COIN_CHG_RSET (at 0x2844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_RSET                            = " "0, 1, 2, 3"
    tree.end
    tree "COIN_COIN_CHG_VSET"
      sgroup "COIN_COIN_CHG_VSET (at 0x2845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_VSET                            = " "0, 1, 2, 3"
    tree.end
    tree "COIN_EN_CTL"
      sgroup "COIN_EN_CTL (at 0x2846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COINCELL_EN                              = " "0, 1"
    tree.end
    tree "COIN_SEC_ACCESS"
      sgroup "COIN_SEC_ACCESS (at 0x28d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "COIN_PERPH_RESET_CTL2"
      sgroup "COIN_PERPH_RESET_CTL2 (at 0x28d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "COIN_PERPH_RESET_CTL3"
      sgroup "COIN_PERPH_RESET_CTL3 (at 0x28da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
    tree.end
    tree "COIN_PERPH_RESET_CTL4"
      sgroup "COIN_PERPH_RESET_CTL4 (at 0x28db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "COIN_TEST_CTRL"
      sgroup "COIN_TEST_CTRL (at 0x28e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_VCOIN                               = " "0, 1"
    tree.end
    tree "COIN_TRIM_NUM"
      sgroup "COIN_TRIM_NUM (at 0x28f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_NUM                                 = " "0, 1"
    tree.end
    tree "COIN_TRIM_OFFSET"
      sgroup "COIN_TRIM_OFFSET (at 0x28f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   COIN_CHG_RSET_TRIM                       = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "DIFF_CLK1"
  tree "DIFF_CLK1"
    tree "DIFF_CLK1_REVISION1"
      sgroup "DIFF_CLK1_REVISION1 (at 0x5700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIFF_CLK1_REVISION2"
      sgroup "DIFF_CLK1_REVISION2 (at 0x5701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIFF_CLK1_REVISION3"
      sgroup "DIFF_CLK1_REVISION3 (at 0x5702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "DIFF_CLK1_REVISION4"
      sgroup "DIFF_CLK1_REVISION4 (at 0x5703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "DIFF_CLK1_PERPH_TYPE"
      sgroup "DIFF_CLK1_PERPH_TYPE (at 0x5704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIFF_CLK1_PERPH_SUBTYPE"
      sgroup "DIFF_CLK1_PERPH_SUBTYPE (at 0x5705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIFF_CLK1_STATUS1"
      sgroup "DIFF_CLK1_STATUS1 (at 0x5708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0, 1"
    tree.end
    tree "DIFF_CLK1_AMP_CTL"
      sgroup "DIFF_CLK1_AMP_CTL (at 0x5742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AMP_CTL                                  = "
    tree.end
    tree "DIFF_CLK1_DRV_CTL1"
      sgroup "DIFF_CLK1_DRV_CTL1 (at 0x5744)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0, 1, 2, 3"
    tree.end
    tree "DIFF_CLK1_EN_CTL"
      sgroup "DIFF_CLK1_EN_CTL (at 0x5746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0, 1"
    tree.end
    tree "DIFF_CLK1_SEC_ACCESS"
      sgroup "DIFF_CLK1_SEC_ACCESS (at 0x57d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIFF_CLK1_PERPH_RESET_CTL1"
      sgroup "DIFF_CLK1_PERPH_RESET_CTL1 (at 0x57d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIFF_CLK1_PERPH_RESET_CTL2"
      sgroup "DIFF_CLK1_PERPH_RESET_CTL2 (at 0x57d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIFF_CLK1_PERPH_RESET_CTL3"
      sgroup "DIFF_CLK1_PERPH_RESET_CTL3 (at 0x57da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIFF_CLK1_PERPH_RESET_CTL4"
      sgroup "DIFF_CLK1_PERPH_RESET_CTL4 (at 0x57db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "DIFF_CLK1_TEST1"
      sgroup "DIFF_CLK1_TEST1 (at 0x57e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIFF_OUT_DTEST2                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DIFF_OUT_TEST                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIFF_ATEST_EN                            = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK1"
  tree "DIV_CLK1"
    tree "DIV_CLK1_REVISION1"
      sgroup "DIV_CLK1_REVISION1 (at 0x5b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK1_REVISION2"
      sgroup "DIV_CLK1_REVISION2 (at 0x5b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK1_PERPH_TYPE"
      sgroup "DIV_CLK1_PERPH_TYPE (at 0x5b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK1_PERPH_SUBTYPE"
      sgroup "DIV_CLK1_PERPH_SUBTYPE (at 0x5b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK1_STATUS1"
      sgroup "DIV_CLK1_STATUS1 (at 0x5b08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0, 1"
    tree.end
    tree "DIV_CLK1_DIV_CTL1"
      sgroup "DIV_CLK1_DIV_CTL1 (at 0x5b43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "DIV_CLK1_EN_CTL"
      sgroup "DIV_CLK1_EN_CTL (at 0x5b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0, 1"
    tree.end
    tree "DIV_CLK1_SEC_ACCESS"
      sgroup "DIV_CLK1_SEC_ACCESS (at 0x5bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL1"
      sgroup "DIV_CLK1_PERPH_RESET_CTL1 (at 0x5bd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL2"
      sgroup "DIV_CLK1_PERPH_RESET_CTL2 (at 0x5bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL3"
      sgroup "DIV_CLK1_PERPH_RESET_CTL3 (at 0x5bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL4"
      sgroup "DIV_CLK1_PERPH_RESET_CTL4 (at 0x5bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK2"
  tree "DIV_CLK2"
    tree "DIV_CLK2_REVISION1"
      sgroup "DIV_CLK2_REVISION1 (at 0x5c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK2_REVISION2"
      sgroup "DIV_CLK2_REVISION2 (at 0x5c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK2_PERPH_TYPE"
      sgroup "DIV_CLK2_PERPH_TYPE (at 0x5c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK2_PERPH_SUBTYPE"
      sgroup "DIV_CLK2_PERPH_SUBTYPE (at 0x5c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK2_STATUS1"
      sgroup "DIV_CLK2_STATUS1 (at 0x5c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0, 1"
    tree.end
    tree "DIV_CLK2_DIV_CTL1"
      sgroup "DIV_CLK2_DIV_CTL1 (at 0x5c43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "DIV_CLK2_EN_CTL"
      sgroup "DIV_CLK2_EN_CTL (at 0x5c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0, 1"
    tree.end
    tree "DIV_CLK2_SEC_ACCESS"
      sgroup "DIV_CLK2_SEC_ACCESS (at 0x5cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL1"
      sgroup "DIV_CLK2_PERPH_RESET_CTL1 (at 0x5cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL2"
      sgroup "DIV_CLK2_PERPH_RESET_CTL2 (at 0x5cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL3"
      sgroup "DIV_CLK2_PERPH_RESET_CTL3 (at 0x5cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK2_PERPH_RESET_CTL4"
      sgroup "DIV_CLK2_PERPH_RESET_CTL4 (at 0x5cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        set &access:&cmd_addr %l 0x805cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "DIV_CLK3"
  tree "DIV_CLK3"
    tree "DIV_CLK3_REVISION1"
      sgroup "DIV_CLK3_REVISION1 (at 0x5d00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK3_REVISION2"
      sgroup "DIV_CLK3_REVISION2 (at 0x5d01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK3_PERPH_TYPE"
      sgroup "DIV_CLK3_PERPH_TYPE (at 0x5d04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK3_PERPH_SUBTYPE"
      sgroup "DIV_CLK3_PERPH_SUBTYPE (at 0x5d05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK3_STATUS1"
      sgroup "DIV_CLK3_STATUS1 (at 0x5d08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0, 1"
    tree.end
    tree "DIV_CLK3_DIV_CTL1"
      sgroup "DIV_CLK3_DIV_CTL1 (at 0x5d43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "DIV_CLK3_EN_CTL"
      sgroup "DIV_CLK3_EN_CTL (at 0x5d46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0, 1"
    tree.end
    tree "DIV_CLK3_SEC_ACCESS"
      sgroup "DIV_CLK3_SEC_ACCESS (at 0x5dd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL1"
      sgroup "DIV_CLK3_PERPH_RESET_CTL1 (at 0x5dd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL2"
      sgroup "DIV_CLK3_PERPH_RESET_CTL2 (at 0x5dd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL3"
      sgroup "DIV_CLK3_PERPH_RESET_CTL3 (at 0x5dda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "DIV_CLK3_PERPH_RESET_CTL4"
      sgroup "DIV_CLK3_PERPH_RESET_CTL4 (at 0x5ddb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        set &access:&cmd_addr %l 0x805ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "FLASH1"
  tree "FLASH1"
    tree "FLASH1_REVISION1"
      sgroup "FLASH1_REVISION1 (at 0x1d300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "FLASH1_REVISION2"
      sgroup "FLASH1_REVISION2 (at 0x1d301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "FLASH1_REVISION3"
      sgroup "FLASH1_REVISION3 (at 0x1d302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "FLASH1_REVISION4"
      sgroup "FLASH1_REVISION4 (at 0x1d303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "FLASH1_PERPH_TYPE"
      sgroup "FLASH1_PERPH_TYPE (at 0x1d304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FLASH1_PERPH_SUBTYPE"
      sgroup "FLASH1_PERPH_SUBTYPE (at 0x1d305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FLASH1_LED_FAULT_STATUS"
      sgroup "FLASH1_LED_FAULT_STATUS (at 0x1d308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OK_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   THERMAL_DERATE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED2_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_SHORT_FAULT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_SHORT_FAULT                         = " "0, 1"
    tree.end
    tree "FLASH1_LED1_IRAMP_STATUS"
      sgroup "FLASH1_LED1_IRAMP_STATUS (at 0x1d309)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_RAMP_CURRENT                        = "
    tree.end
    tree "FLASH1_LED2_IRAMP_STATUS"
      sgroup "FLASH1_LED2_IRAMP_STATUS (at 0x1d30a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_RAMP_CURRENT                        = "
    tree.end
    tree "FLASH1_INT_RT_STS"
      sgroup "FLASH1_INT_RT_STS (at 0x1d310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_RT_STS                  = " "0, 1"
    tree.end
    tree "FLASH1_INT_SET_TYPE"
      sgroup "FLASH1_INT_SET_TYPE (at 0x1d311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_TYPE                    = " "0, 1"
    tree.end
    tree "FLASH1_INT_POLARITY_HIGH"
      sgroup "FLASH1_INT_POLARITY_HIGH (at 0x1d312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_HIGH                    = " "0, 1"
    tree.end
    tree "FLASH1_INT_POLARITY_LOW"
      sgroup "FLASH1_INT_POLARITY_LOW (at 0x1d313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LOW                     = " "0, 1"
    tree.end
    tree "FLASH1_INT_LATCHED_CLR"
      sgroup "FLASH1_INT_LATCHED_CLR (at 0x1d314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "FLASH1_INT_EN_SET"
      sgroup "FLASH1_INT_EN_SET (at 0x1d315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_EN_SET                  = " "0, 1"
    tree.end
    tree "FLASH1_INT_EN_CLR"
      sgroup "FLASH1_INT_EN_CLR (at 0x1d316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_EN_CLR                  = " "0, 1"
    tree.end
    tree "FLASH1_INT_LATCHED_STS"
      sgroup "FLASH1_INT_LATCHED_STS (at 0x1d318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_LATCHED_STS             = " "0, 1"
    tree.end
    tree "FLASH1_INT_PENDING_STS"
      sgroup "FLASH1_INT_PENDING_STS (at 0x1d319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_PENDING_STS             = " "0, 1"
    tree.end
    tree "FLASH1_INT_MID_SEL"
      sgroup "FLASH1_INT_MID_SEL (at 0x1d31a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_INT_PRIORITY"
      sgroup "FLASH1_INT_PRIORITY (at 0x1d31b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "FLASH1_FLASH_SAFETY_TIMER"
      sgroup "FLASH1_FLASH_SAFETY_TIMER (at 0x1d340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   FLASH_TIMER_DURATION                     = "
    tree.end
    tree "FLASH1_MAX_FLSH_CURRENT"
      sgroup "FLASH1_MAX_FLSH_CURRENT (at 0x1d341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MAX_LED_CURRENT                          = "
    tree.end
    tree "FLASH1_LED1_CURRENT_PRGM"
      sgroup "FLASH1_LED1_CURRENT_PRGM (at 0x1d342)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_CURRENT_CONTROL                     = "
    tree.end
    tree "FLASH1_LED2_CURRENT_PRGM"
      sgroup "FLASH1_LED2_CURRENT_PRGM (at 0x1d343)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_CURRENT_CONTROL                     = "
    tree.end
    tree "FLASH1_MASK_CLAMP_CURRENT"
      sgroup "FLASH1_MASK_CLAMP_CURRENT (at 0x1d344)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MASK_CURRENT                             = "
    tree.end
    tree "FLASH1_ENABLE_CONTROL"
      sgroup "FLASH1_ENABLE_CONTROL (at 0x1d346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_ENABLE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED1_DRVR_SEL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED2_DRVR_SEL                            = " "0, 1"
    tree.end
    tree "FLASH1_LED_STROBE_CONTROL"
      sgroup "FLASH1_LED_STROBE_CONTROL (at 0x1d347)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LED1_OUTPUT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_LED2_OUTPUT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HW_SW_STROBE_SEL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_STROBE_TRIGGER                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_STROBE_POLARITY                       = " "0, 1"
    tree.end
    tree "FLASH1_LED_TMR_CONTROL"
      sgroup "FLASH1_LED_TMR_CONTROL (at 0x1d348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIMER1_SEL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER2_SEL                               = " "0, 1"
    tree.end
    tree "FLASH1_WATCHDOG_TIMER"
      sgroup "FLASH1_WATCHDOG_TIMER (at 0x1d349)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   WATCHDOG_TIMER_DURATION                  = "
    tree.end
    tree "FLASH1_FLASH_HEADRM_PRGM"
      sgroup "FLASH1_FLASH_HEADRM_PRGM (at 0x1d34a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FLSH_DRVR_HEADROOM                       = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_STARTUP_DELAY"
      sgroup "FLASH1_STARTUP_DELAY (at 0x1d34b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STARTUP_DELAY                            = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_MASK_ENABLE"
      sgroup "FLASH1_MASK_ENABLE (at 0x1d34c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MASK3                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_MASK2                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_MASK1                                 = " "0, 1"
    tree.end
    tree "FLASH1_LED1_FINE_CURRENT_PRGM"
      sgroup "FLASH1_LED1_FINE_CURRENT_PRGM (at 0x1d34d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_FINE_CURRENT_CONTROL                = "
    tree.end
    tree "FLASH1_LED2_FINE_CURRENT_PRGM"
      sgroup "FLASH1_LED2_FINE_CURRENT_PRGM (at 0x1d34e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_FINE_CURRENT_CONTROL                = "
    tree.end
    tree "FLASH1_VREG_OK_FORCE"
      sgroup "FLASH1_VREG_OK_FORCE (at 0x1d34f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_FORCE_VREG_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HW_VREG_OK                        = " "0, 1"
    tree.end
    tree "FLASH1_MASK_CONFIG"
      sgroup "FLASH1_MASK_CONFIG (at 0x1d350)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK3_POLARITY                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MASK2_POLARITY                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MASK1_POLARITY                           = " "0, 1"
    tree.end
    tree "FLASH1_FAULT_DETECT"
      sgroup "FLASH1_FAULT_DETECT (at 0x1d351)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SELF_CHECK                            = " "0, 1"
    tree.end
    tree "FLASH1_THERMAL_DERATE"
      sgroup "FLASH1_THERMAL_DERATE (at 0x1d352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_THERMAL_DERATE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   DERATE_RATE                              = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DERATE_THRESHOLD                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FLASH1_PWM_DIMMING"
      sgroup "FLASH1_PWM_DIMMING (at 0x1d353)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PWM_DIMMING                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FULL_SCALE_CURRENT                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FLASH1_LED_CURRENT_RAMP"
      sgroup "FLASH1_LED_CURRENT_RAMP (at 0x1d354)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_RAMP                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_UP_STEP                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_DN_STEP                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FLASH1_ALT_RAMP_DN"
      sgroup "FLASH1_ALT_RAMP_DN (at 0x1d355)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ALTERNATE_RAMP_DN                        = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_WATCHDOG_PET"
      sgroup "FLASH1_WATCHDOG_PET (at 0x1d356)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PET_WATCHDOG                             = " "0, 1"
    tree.end
    tree "FLASH1_STROBE_DEBOUNCE"
      sgroup "FLASH1_STROBE_DEBOUNCE (at 0x1d357)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_STROBE                     = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_MASK_DEBOUNCE"
      sgroup "FLASH1_MASK_DEBOUNCE (at 0x1d358)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEBOUNCE_TIME_MASK1                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_OTHER_MASKS                = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_FAULT_DEBOUNCE"
      sgroup "FLASH1_FAULT_DEBOUNCE (at 0x1d359)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEBOUNCE_TIME_LED1_OPEN                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEBOUNCE_TIME_LED2_OPEN                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEBOUNCE_TIME_LED1_SHORT                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_LED2_SHORT                 = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_VPH_PWR_DROOP"
      sgroup "FLASH1_VPH_PWR_DROOP (at 0x1d35a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_VPH_PWR_DROOP                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   VPH_PWR_DROOP_THRESHOLD                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_VPH_PWR_DROOP              = " "0, 1, 2, 3"
    tree.end
    tree "FLASH1_SEC_ACCESS"
      sgroup "FLASH1_SEC_ACCESS (at 0x1d3d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FLASH1_PERPH_RESET_CTL2"
      sgroup "FLASH1_PERPH_RESET_CTL2 (at 0x1d3d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FLASH1_PERPH_RESET_CTL3"
      sgroup "FLASH1_PERPH_RESET_CTL3 (at 0x1d3da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FLASH1_PERPH_RESET_CTL4"
      sgroup "FLASH1_PERPH_RESET_CTL4 (at 0x1d3db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "FLASH1_INT_TEST1"
      sgroup "FLASH1_INT_TEST1 (at 0x1d3e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "FLASH1_INT_TEST_VAL"
      sgroup "FLASH1_INT_TEST_VAL (at 0x1d3e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLSH_EXP_TEST_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DOG_EXP_TEST_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED_FLT_TEST_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_RMP_UP_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED1_RMP_DN_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_RMP_UP_DONE_TEST_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_RMP_DN_DONE_TEST_VAL                = " "0, 1"
    tree.end
    tree "FLASH1_TEST1"
      sgroup "FLASH1_TEST1 (at 0x1d3e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "FLASH1_TEST2"
      sgroup "FLASH1_TEST2 (at 0x1d3e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FLSH_ATEST_CTRL                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FLASH1_TEST3"
      sgroup "FLASH1_TEST3 (at 0x1d3e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_WDOG_TIMER                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_SFTY_TIMER                            = " "0, 1"
    tree.end
    tree "FLASH1_TEST4"
      sgroup "FLASH1_TEST4 (at 0x1d3e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLKRATE_TEST                             = " "0, 1"
    tree.end
    tree "FLASH1_TEST5"
      sgroup "FLASH1_TEST5 (at 0x1d3e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED1_SEGMENT_CTRL                        = "
    tree.end
    tree "FLASH1_TEST6"
      sgroup "FLASH1_TEST6 (at 0x1d3e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LED2_SEGMENT_CTRL                        = "
    tree.end
    tree "FLASH1_TRIM_NUM"
      sgroup "FLASH1_TRIM_NUM (at 0x1d3f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "FLASH1_TRIM1"
      sgroup "FLASH1_TRIM1 (at 0x1d3f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED1_CURR_TRIM_VIN                       = "
    tree.end
    tree "FLASH1_TRIM2"
      sgroup "FLASH1_TRIM2 (at 0x1d3f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED1_CURR_TRIM_VREG                      = "
    tree.end
    tree "FLASH1_TRIM3"
      sgroup "FLASH1_TRIM3 (at 0x1d3f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED2_CURR_TRIM_VIN                       = "
    tree.end
    tree "FLASH1_TRIM4"
      sgroup "FLASH1_TRIM4 (at 0x1d3f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LED2_CURR_TRIM_VREG                      = "
    tree.end
  tree.end
tree.end
tree "GPIO1"
  tree "GPIO1"
    tree "GPIO1_REVISION1"
      sgroup "GPIO1_REVISION1 (at 0xc000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION2"
      sgroup "GPIO1_REVISION2 (at 0xc001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO1_REVISION3"
      sgroup "GPIO1_REVISION3 (at 0xc002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO1_REVISION4"
      sgroup "GPIO1_REVISION4 (at 0xc003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO1_PERPH_TYPE"
      sgroup "GPIO1_PERPH_TYPE (at 0xc004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO1_PERPH_SUBTYPE"
      sgroup "GPIO1_PERPH_SUBTYPE (at 0xc005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO1_STATUS1"
      sgroup "GPIO1_STATUS1 (at 0xc008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO1_INT_RT_STS"
      sgroup "GPIO1_INT_RT_STS (at 0xc010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO1_INT_SET_TYPE"
      sgroup "GPIO1_INT_SET_TYPE (at 0xc011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO1_INT_POLARITY_HIGH"
      sgroup "GPIO1_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO1_INT_POLARITY_LOW"
      sgroup "GPIO1_INT_POLARITY_LOW (at 0xc013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO1_INT_LATCHED_CLR"
      sgroup "GPIO1_INT_LATCHED_CLR (at 0xc014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_SET"
      sgroup "GPIO1_INT_EN_SET (at 0xc015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO1_INT_EN_CLR"
      sgroup "GPIO1_INT_EN_CLR (at 0xc016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO1_INT_LATCHED_STS"
      sgroup "GPIO1_INT_LATCHED_STS (at 0xc018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_PENDING_STS"
      sgroup "GPIO1_INT_PENDING_STS (at 0xc019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO1_INT_MID_SEL"
      sgroup "GPIO1_INT_MID_SEL (at 0xc01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO1_INT_PRIORITY"
      sgroup "GPIO1_INT_PRIORITY (at 0xc01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO1_MODE_CTL"
      sgroup "GPIO1_MODE_CTL (at 0xc040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO1_DIG_VIN_CTL"
      sgroup "GPIO1_DIG_VIN_CTL (at 0xc041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO1_DIG_PULL_CTL"
      sgroup "GPIO1_DIG_PULL_CTL (at 0xc042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO1_DIG_IN_CTL"
      sgroup "GPIO1_DIG_IN_CTL (at 0xc043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO1_DIG_OUT_CTL"
      sgroup "GPIO1_DIG_OUT_CTL (at 0xc045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO1_EN_CTL"
      sgroup "GPIO1_EN_CTL (at 0xc046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO1_SEC_ACCESS"
      sgroup "GPIO1_SEC_ACCESS (at 0xc0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO1_PERPH_RESET_CTL1"
      sgroup "GPIO1_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL2"
      sgroup "GPIO1_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL3"
      sgroup "GPIO1_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO1_PERPH_RESET_CTL4"
      sgroup "GPIO1_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO2"
  tree "GPIO2"
    tree "GPIO2_REVISION1"
      sgroup "GPIO2_REVISION1 (at 0xc100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION2"
      sgroup "GPIO2_REVISION2 (at 0xc101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO2_REVISION3"
      sgroup "GPIO2_REVISION3 (at 0xc102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO2_REVISION4"
      sgroup "GPIO2_REVISION4 (at 0xc103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO2_PERPH_TYPE"
      sgroup "GPIO2_PERPH_TYPE (at 0xc104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO2_PERPH_SUBTYPE"
      sgroup "GPIO2_PERPH_SUBTYPE (at 0xc105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO2_STATUS1"
      sgroup "GPIO2_STATUS1 (at 0xc108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO2_INT_RT_STS"
      sgroup "GPIO2_INT_RT_STS (at 0xc110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO2_INT_SET_TYPE"
      sgroup "GPIO2_INT_SET_TYPE (at 0xc111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO2_INT_POLARITY_HIGH"
      sgroup "GPIO2_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO2_INT_POLARITY_LOW"
      sgroup "GPIO2_INT_POLARITY_LOW (at 0xc113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO2_INT_LATCHED_CLR"
      sgroup "GPIO2_INT_LATCHED_CLR (at 0xc114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_SET"
      sgroup "GPIO2_INT_EN_SET (at 0xc115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO2_INT_EN_CLR"
      sgroup "GPIO2_INT_EN_CLR (at 0xc116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO2_INT_LATCHED_STS"
      sgroup "GPIO2_INT_LATCHED_STS (at 0xc118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_PENDING_STS"
      sgroup "GPIO2_INT_PENDING_STS (at 0xc119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO2_INT_MID_SEL"
      sgroup "GPIO2_INT_MID_SEL (at 0xc11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO2_INT_PRIORITY"
      sgroup "GPIO2_INT_PRIORITY (at 0xc11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO2_MODE_CTL"
      sgroup "GPIO2_MODE_CTL (at 0xc140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO2_DIG_VIN_CTL"
      sgroup "GPIO2_DIG_VIN_CTL (at 0xc141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO2_DIG_PULL_CTL"
      sgroup "GPIO2_DIG_PULL_CTL (at 0xc142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO2_DIG_IN_CTL"
      sgroup "GPIO2_DIG_IN_CTL (at 0xc143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO2_DIG_OUT_CTL"
      sgroup "GPIO2_DIG_OUT_CTL (at 0xc145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO2_EN_CTL"
      sgroup "GPIO2_EN_CTL (at 0xc146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO2_SEC_ACCESS"
      sgroup "GPIO2_SEC_ACCESS (at 0xc1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO2_PERPH_RESET_CTL1"
      sgroup "GPIO2_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL2"
      sgroup "GPIO2_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL3"
      sgroup "GPIO2_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO2_PERPH_RESET_CTL4"
      sgroup "GPIO2_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO3"
  tree "GPIO3"
    tree "GPIO3_REVISION1"
      sgroup "GPIO3_REVISION1 (at 0xc200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION2"
      sgroup "GPIO3_REVISION2 (at 0xc201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO3_REVISION3"
      sgroup "GPIO3_REVISION3 (at 0xc202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO3_REVISION4"
      sgroup "GPIO3_REVISION4 (at 0xc203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO3_PERPH_TYPE"
      sgroup "GPIO3_PERPH_TYPE (at 0xc204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO3_PERPH_SUBTYPE"
      sgroup "GPIO3_PERPH_SUBTYPE (at 0xc205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO3_STATUS1"
      sgroup "GPIO3_STATUS1 (at 0xc208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO3_INT_RT_STS"
      sgroup "GPIO3_INT_RT_STS (at 0xc210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO3_INT_SET_TYPE"
      sgroup "GPIO3_INT_SET_TYPE (at 0xc211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO3_INT_POLARITY_HIGH"
      sgroup "GPIO3_INT_POLARITY_HIGH (at 0xc212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO3_INT_POLARITY_LOW"
      sgroup "GPIO3_INT_POLARITY_LOW (at 0xc213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO3_INT_LATCHED_CLR"
      sgroup "GPIO3_INT_LATCHED_CLR (at 0xc214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_SET"
      sgroup "GPIO3_INT_EN_SET (at 0xc215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO3_INT_EN_CLR"
      sgroup "GPIO3_INT_EN_CLR (at 0xc216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO3_INT_LATCHED_STS"
      sgroup "GPIO3_INT_LATCHED_STS (at 0xc218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_PENDING_STS"
      sgroup "GPIO3_INT_PENDING_STS (at 0xc219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO3_INT_MID_SEL"
      sgroup "GPIO3_INT_MID_SEL (at 0xc21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO3_INT_PRIORITY"
      sgroup "GPIO3_INT_PRIORITY (at 0xc21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO3_MODE_CTL"
      sgroup "GPIO3_MODE_CTL (at 0xc240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO3_DIG_VIN_CTL"
      sgroup "GPIO3_DIG_VIN_CTL (at 0xc241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO3_DIG_PULL_CTL"
      sgroup "GPIO3_DIG_PULL_CTL (at 0xc242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO3_DIG_IN_CTL"
      sgroup "GPIO3_DIG_IN_CTL (at 0xc243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO3_DIG_OUT_CTL"
      sgroup "GPIO3_DIG_OUT_CTL (at 0xc245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO3_EN_CTL"
      sgroup "GPIO3_EN_CTL (at 0xc246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO3_SEC_ACCESS"
      sgroup "GPIO3_SEC_ACCESS (at 0xc2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO3_PERPH_RESET_CTL1"
      sgroup "GPIO3_PERPH_RESET_CTL1 (at 0xc2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL2"
      sgroup "GPIO3_PERPH_RESET_CTL2 (at 0xc2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL3"
      sgroup "GPIO3_PERPH_RESET_CTL3 (at 0xc2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO3_PERPH_RESET_CTL4"
      sgroup "GPIO3_PERPH_RESET_CTL4 (at 0xc2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO4"
  tree "GPIO4"
    tree "GPIO4_REVISION1"
      sgroup "GPIO4_REVISION1 (at 0xc300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION2"
      sgroup "GPIO4_REVISION2 (at 0xc301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO4_REVISION3"
      sgroup "GPIO4_REVISION3 (at 0xc302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO4_REVISION4"
      sgroup "GPIO4_REVISION4 (at 0xc303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO4_PERPH_TYPE"
      sgroup "GPIO4_PERPH_TYPE (at 0xc304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO4_PERPH_SUBTYPE"
      sgroup "GPIO4_PERPH_SUBTYPE (at 0xc305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO4_STATUS1"
      sgroup "GPIO4_STATUS1 (at 0xc308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO4_INT_RT_STS"
      sgroup "GPIO4_INT_RT_STS (at 0xc310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO4_INT_SET_TYPE"
      sgroup "GPIO4_INT_SET_TYPE (at 0xc311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO4_INT_POLARITY_HIGH"
      sgroup "GPIO4_INT_POLARITY_HIGH (at 0xc312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO4_INT_POLARITY_LOW"
      sgroup "GPIO4_INT_POLARITY_LOW (at 0xc313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO4_INT_LATCHED_CLR"
      sgroup "GPIO4_INT_LATCHED_CLR (at 0xc314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_SET"
      sgroup "GPIO4_INT_EN_SET (at 0xc315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO4_INT_EN_CLR"
      sgroup "GPIO4_INT_EN_CLR (at 0xc316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO4_INT_LATCHED_STS"
      sgroup "GPIO4_INT_LATCHED_STS (at 0xc318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_PENDING_STS"
      sgroup "GPIO4_INT_PENDING_STS (at 0xc319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO4_INT_MID_SEL"
      sgroup "GPIO4_INT_MID_SEL (at 0xc31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO4_INT_PRIORITY"
      sgroup "GPIO4_INT_PRIORITY (at 0xc31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO4_MODE_CTL"
      sgroup "GPIO4_MODE_CTL (at 0xc340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO4_DIG_VIN_CTL"
      sgroup "GPIO4_DIG_VIN_CTL (at 0xc341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO4_DIG_PULL_CTL"
      sgroup "GPIO4_DIG_PULL_CTL (at 0xc342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO4_DIG_IN_CTL"
      sgroup "GPIO4_DIG_IN_CTL (at 0xc343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO4_DIG_OUT_CTL"
      sgroup "GPIO4_DIG_OUT_CTL (at 0xc345)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO4_EN_CTL"
      sgroup "GPIO4_EN_CTL (at 0xc346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO4_SEC_ACCESS"
      sgroup "GPIO4_SEC_ACCESS (at 0xc3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO4_PERPH_RESET_CTL1"
      sgroup "GPIO4_PERPH_RESET_CTL1 (at 0xc3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL2"
      sgroup "GPIO4_PERPH_RESET_CTL2 (at 0xc3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL3"
      sgroup "GPIO4_PERPH_RESET_CTL3 (at 0xc3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO4_PERPH_RESET_CTL4"
      sgroup "GPIO4_PERPH_RESET_CTL4 (at 0xc3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO5"
  tree "GPIO5"
    tree "GPIO5_REVISION1"
      sgroup "GPIO5_REVISION1 (at 0xc400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION2"
      sgroup "GPIO5_REVISION2 (at 0xc401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO5_REVISION3"
      sgroup "GPIO5_REVISION3 (at 0xc402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO5_REVISION4"
      sgroup "GPIO5_REVISION4 (at 0xc403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO5_PERPH_TYPE"
      sgroup "GPIO5_PERPH_TYPE (at 0xc404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO5_PERPH_SUBTYPE"
      sgroup "GPIO5_PERPH_SUBTYPE (at 0xc405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO5_STATUS1"
      sgroup "GPIO5_STATUS1 (at 0xc408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO5_INT_RT_STS"
      sgroup "GPIO5_INT_RT_STS (at 0xc410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO5_INT_SET_TYPE"
      sgroup "GPIO5_INT_SET_TYPE (at 0xc411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO5_INT_POLARITY_HIGH"
      sgroup "GPIO5_INT_POLARITY_HIGH (at 0xc412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO5_INT_POLARITY_LOW"
      sgroup "GPIO5_INT_POLARITY_LOW (at 0xc413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO5_INT_LATCHED_CLR"
      sgroup "GPIO5_INT_LATCHED_CLR (at 0xc414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO5_INT_EN_SET"
      sgroup "GPIO5_INT_EN_SET (at 0xc415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO5_INT_EN_CLR"
      sgroup "GPIO5_INT_EN_CLR (at 0xc416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO5_INT_LATCHED_STS"
      sgroup "GPIO5_INT_LATCHED_STS (at 0xc418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO5_INT_PENDING_STS"
      sgroup "GPIO5_INT_PENDING_STS (at 0xc419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO5_INT_MID_SEL"
      sgroup "GPIO5_INT_MID_SEL (at 0xc41a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO5_INT_PRIORITY"
      sgroup "GPIO5_INT_PRIORITY (at 0xc41b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO5_MODE_CTL"
      sgroup "GPIO5_MODE_CTL (at 0xc440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO5_DIG_VIN_CTL"
      sgroup "GPIO5_DIG_VIN_CTL (at 0xc441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO5_DIG_PULL_CTL"
      sgroup "GPIO5_DIG_PULL_CTL (at 0xc442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO5_DIG_IN_CTL"
      sgroup "GPIO5_DIG_IN_CTL (at 0xc443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO5_DIG_OUT_CTL"
      sgroup "GPIO5_DIG_OUT_CTL (at 0xc445)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO5_EN_CTL"
      sgroup "GPIO5_EN_CTL (at 0xc446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO5_SEC_ACCESS"
      sgroup "GPIO5_SEC_ACCESS (at 0xc4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO5_PERPH_RESET_CTL1"
      sgroup "GPIO5_PERPH_RESET_CTL1 (at 0xc4d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL2"
      sgroup "GPIO5_PERPH_RESET_CTL2 (at 0xc4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL3"
      sgroup "GPIO5_PERPH_RESET_CTL3 (at 0xc4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO5_PERPH_RESET_CTL4"
      sgroup "GPIO5_PERPH_RESET_CTL4 (at 0xc4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO6"
  tree "GPIO6"
    tree "GPIO6_REVISION1"
      sgroup "GPIO6_REVISION1 (at 0xc500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION2"
      sgroup "GPIO6_REVISION2 (at 0xc501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO6_REVISION3"
      sgroup "GPIO6_REVISION3 (at 0xc502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO6_REVISION4"
      sgroup "GPIO6_REVISION4 (at 0xc503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO6_PERPH_TYPE"
      sgroup "GPIO6_PERPH_TYPE (at 0xc504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO6_PERPH_SUBTYPE"
      sgroup "GPIO6_PERPH_SUBTYPE (at 0xc505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO6_STATUS1"
      sgroup "GPIO6_STATUS1 (at 0xc508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO6_INT_RT_STS"
      sgroup "GPIO6_INT_RT_STS (at 0xc510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO6_INT_SET_TYPE"
      sgroup "GPIO6_INT_SET_TYPE (at 0xc511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO6_INT_POLARITY_HIGH"
      sgroup "GPIO6_INT_POLARITY_HIGH (at 0xc512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO6_INT_POLARITY_LOW"
      sgroup "GPIO6_INT_POLARITY_LOW (at 0xc513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO6_INT_LATCHED_CLR"
      sgroup "GPIO6_INT_LATCHED_CLR (at 0xc514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO6_INT_EN_SET"
      sgroup "GPIO6_INT_EN_SET (at 0xc515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO6_INT_EN_CLR"
      sgroup "GPIO6_INT_EN_CLR (at 0xc516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO6_INT_LATCHED_STS"
      sgroup "GPIO6_INT_LATCHED_STS (at 0xc518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO6_INT_PENDING_STS"
      sgroup "GPIO6_INT_PENDING_STS (at 0xc519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO6_INT_MID_SEL"
      sgroup "GPIO6_INT_MID_SEL (at 0xc51a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO6_INT_PRIORITY"
      sgroup "GPIO6_INT_PRIORITY (at 0xc51b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO6_MODE_CTL"
      sgroup "GPIO6_MODE_CTL (at 0xc540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO6_DIG_VIN_CTL"
      sgroup "GPIO6_DIG_VIN_CTL (at 0xc541)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO6_DIG_PULL_CTL"
      sgroup "GPIO6_DIG_PULL_CTL (at 0xc542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO6_DIG_IN_CTL"
      sgroup "GPIO6_DIG_IN_CTL (at 0xc543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO6_DIG_OUT_CTL"
      sgroup "GPIO6_DIG_OUT_CTL (at 0xc545)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO6_EN_CTL"
      sgroup "GPIO6_EN_CTL (at 0xc546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO6_SEC_ACCESS"
      sgroup "GPIO6_SEC_ACCESS (at 0xc5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO6_PERPH_RESET_CTL1"
      sgroup "GPIO6_PERPH_RESET_CTL1 (at 0xc5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL2"
      sgroup "GPIO6_PERPH_RESET_CTL2 (at 0xc5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL3"
      sgroup "GPIO6_PERPH_RESET_CTL3 (at 0xc5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO6_PERPH_RESET_CTL4"
      sgroup "GPIO6_PERPH_RESET_CTL4 (at 0xc5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO7"
  tree "GPIO7"
    tree "GPIO7_REVISION1"
      sgroup "GPIO7_REVISION1 (at 0xc600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO7_REVISION2"
      sgroup "GPIO7_REVISION2 (at 0xc601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO7_REVISION3"
      sgroup "GPIO7_REVISION3 (at 0xc602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO7_REVISION4"
      sgroup "GPIO7_REVISION4 (at 0xc603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO7_PERPH_TYPE"
      sgroup "GPIO7_PERPH_TYPE (at 0xc604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO7_PERPH_SUBTYPE"
      sgroup "GPIO7_PERPH_SUBTYPE (at 0xc605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO7_STATUS1"
      sgroup "GPIO7_STATUS1 (at 0xc608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO7_INT_RT_STS"
      sgroup "GPIO7_INT_RT_STS (at 0xc610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO7_INT_SET_TYPE"
      sgroup "GPIO7_INT_SET_TYPE (at 0xc611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO7_INT_POLARITY_HIGH"
      sgroup "GPIO7_INT_POLARITY_HIGH (at 0xc612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO7_INT_POLARITY_LOW"
      sgroup "GPIO7_INT_POLARITY_LOW (at 0xc613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO7_INT_LATCHED_CLR"
      sgroup "GPIO7_INT_LATCHED_CLR (at 0xc614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO7_INT_EN_SET"
      sgroup "GPIO7_INT_EN_SET (at 0xc615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO7_INT_EN_CLR"
      sgroup "GPIO7_INT_EN_CLR (at 0xc616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO7_INT_LATCHED_STS"
      sgroup "GPIO7_INT_LATCHED_STS (at 0xc618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO7_INT_PENDING_STS"
      sgroup "GPIO7_INT_PENDING_STS (at 0xc619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO7_INT_MID_SEL"
      sgroup "GPIO7_INT_MID_SEL (at 0xc61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c61a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO7_INT_PRIORITY"
      sgroup "GPIO7_INT_PRIORITY (at 0xc61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c61b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO7_MODE_CTL"
      sgroup "GPIO7_MODE_CTL (at 0xc640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO7_DIG_VIN_CTL"
      sgroup "GPIO7_DIG_VIN_CTL (at 0xc641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO7_DIG_PULL_CTL"
      sgroup "GPIO7_DIG_PULL_CTL (at 0xc642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO7_DIG_IN_CTL"
      sgroup "GPIO7_DIG_IN_CTL (at 0xc643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO7_DIG_OUT_CTL"
      sgroup "GPIO7_DIG_OUT_CTL (at 0xc645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO7_EN_CTL"
      sgroup "GPIO7_EN_CTL (at 0xc646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO7_SEC_ACCESS"
      sgroup "GPIO7_SEC_ACCESS (at 0xc6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO7_PERPH_RESET_CTL1"
      sgroup "GPIO7_PERPH_RESET_CTL1 (at 0xc6d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL2"
      sgroup "GPIO7_PERPH_RESET_CTL2 (at 0xc6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL3"
      sgroup "GPIO7_PERPH_RESET_CTL3 (at 0xc6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO7_PERPH_RESET_CTL4"
      sgroup "GPIO7_PERPH_RESET_CTL4 (at 0xc6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "GPIO8"
  tree "GPIO8"
    tree "GPIO8_REVISION1"
      sgroup "GPIO8_REVISION1 (at 0xc700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO8_REVISION2"
      sgroup "GPIO8_REVISION2 (at 0xc701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO8_REVISION3"
      sgroup "GPIO8_REVISION3 (at 0xc702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO8_REVISION4"
      sgroup "GPIO8_REVISION4 (at 0xc703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO8_PERPH_TYPE"
      sgroup "GPIO8_PERPH_TYPE (at 0xc704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO8_PERPH_SUBTYPE"
      sgroup "GPIO8_PERPH_SUBTYPE (at 0xc705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO8_STATUS1"
      sgroup "GPIO8_STATUS1 (at 0xc708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0, 1"
    tree.end
    tree "GPIO8_INT_RT_STS"
      sgroup "GPIO8_INT_RT_STS (at 0xc710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0, 1"
    tree.end
    tree "GPIO8_INT_SET_TYPE"
      sgroup "GPIO8_INT_SET_TYPE (at 0xc711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0, 1"
    tree.end
    tree "GPIO8_INT_POLARITY_HIGH"
      sgroup "GPIO8_INT_POLARITY_HIGH (at 0xc712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0, 1"
    tree.end
    tree "GPIO8_INT_POLARITY_LOW"
      sgroup "GPIO8_INT_POLARITY_LOW (at 0xc713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0, 1"
    tree.end
    tree "GPIO8_INT_LATCHED_CLR"
      sgroup "GPIO8_INT_LATCHED_CLR (at 0xc714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO8_INT_EN_SET"
      sgroup "GPIO8_INT_EN_SET (at 0xc715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0, 1"
    tree.end
    tree "GPIO8_INT_EN_CLR"
      sgroup "GPIO8_INT_EN_CLR (at 0xc716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0, 1"
    tree.end
    tree "GPIO8_INT_LATCHED_STS"
      sgroup "GPIO8_INT_LATCHED_STS (at 0xc718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "GPIO8_INT_PENDING_STS"
      sgroup "GPIO8_INT_PENDING_STS (at 0xc719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0, 1"
    tree.end
    tree "GPIO8_INT_MID_SEL"
      sgroup "GPIO8_INT_MID_SEL (at 0xc71a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c71a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc71a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "GPIO8_INT_PRIORITY"
      sgroup "GPIO8_INT_PRIORITY (at 0xc71b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c71b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc71b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "GPIO8_MODE_CTL"
      sgroup "GPIO8_MODE_CTL (at 0xc740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "GPIO8_DIG_VIN_CTL"
      sgroup "GPIO8_DIG_VIN_CTL (at 0xc741)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO8_DIG_PULL_CTL"
      sgroup "GPIO8_DIG_PULL_CTL (at 0xc742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "GPIO8_DIG_IN_CTL"
      sgroup "GPIO8_DIG_IN_CTL (at 0xc743)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "GPIO8_DIG_OUT_CTL"
      sgroup "GPIO8_DIG_OUT_CTL (at 0xc745)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0, 1, 2, 3"
    tree.end
    tree "GPIO8_EN_CTL"
      sgroup "GPIO8_EN_CTL (at 0xc746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "GPIO8_SEC_ACCESS"
      sgroup "GPIO8_SEC_ACCESS (at 0xc7d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO8_PERPH_RESET_CTL1"
      sgroup "GPIO8_PERPH_RESET_CTL1 (at 0xc7d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL2"
      sgroup "GPIO8_PERPH_RESET_CTL2 (at 0xc7d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL3"
      sgroup "GPIO8_PERPH_RESET_CTL3 (at 0xc7da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "GPIO8_PERPH_RESET_CTL4"
      sgroup "GPIO8_PERPH_RESET_CTL4 (at 0xc7db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "IADC1_USR"
  tree "IADC1_USR"
    tree "IADC1_USR_REVISION1"
      sgroup "IADC1_USR_REVISION1 (at 0x3600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "IADC1_USR_REVISION2"
      sgroup "IADC1_USR_REVISION2 (at 0x3601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "IADC1_USR_REVISION3"
      sgroup "IADC1_USR_REVISION3 (at 0x3602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "IADC1_USR_REVISION4"
      sgroup "IADC1_USR_REVISION4 (at 0x3603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "IADC1_USR_PERPH_TYPE"
      sgroup "IADC1_USR_PERPH_TYPE (at 0x3604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "IADC1_USR_PERPH_SUBTYPE"
      sgroup "IADC1_USR_PERPH_SUBTYPE (at 0x3605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "IADC1_USR_STATUS1"
      sgroup "IADC1_USR_STATUS1 (at 0x3608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0, 1"
    tree.end
    tree "IADC1_USR_STATUS2"
      sgroup "IADC1_USR_STATUS2 (at 0x3609)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_RT_STS"
      sgroup "IADC1_USR_INT_RT_STS (at 0x3610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_SET_TYPE"
      sgroup "IADC1_USR_INT_SET_TYPE (at 0x3611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_POLARITY_HIGH"
      sgroup "IADC1_USR_INT_POLARITY_HIGH (at 0x3612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_POLARITY_LOW"
      sgroup "IADC1_USR_INT_POLARITY_LOW (at 0x3613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_LATCHED_CLR"
      sgroup "IADC1_USR_INT_LATCHED_CLR (at 0x3614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_EN_SET"
      sgroup "IADC1_USR_INT_EN_SET (at 0x3615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_EN_CLR"
      sgroup "IADC1_USR_INT_EN_CLR (at 0x3616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_LATCHED_STS"
      sgroup "IADC1_USR_INT_LATCHED_STS (at 0x3618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_PENDING_STS"
      sgroup "IADC1_USR_INT_PENDING_STS (at 0x3619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_MID_SEL"
      sgroup "IADC1_USR_INT_MID_SEL (at 0x361a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80361a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x361a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "IADC1_USR_INT_PRIORITY"
      sgroup "IADC1_USR_INT_PRIORITY (at 0x361b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80361b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x361b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "IADC1_USR_MODE_CTL"
      sgroup "IADC1_USR_MODE_CTL (at 0x3640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USE_BMS_DATA                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VADC_SYNCH_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OFFSET_RMV_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0, 1"
    tree.end
    tree "IADC1_USR_EN_CTL1"
      sgroup "IADC1_USR_EN_CTL1 (at 0x3646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0, 1"
    tree.end
    tree "IADC1_USR_ADC_CH_SEL_CTL"
      sgroup "IADC1_USR_ADC_CH_SEL_CTL (at 0x3648)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_CH_SEL                               = " "0 (INTRSNS),1 (EXTRSNS),2 (CSP2_CSN2),3 (GAIN),4 (INTRSNS_OFFSET),5 (EXTRSNS_OFFSET),6 (CSP2_CSN2_OFFSET),7 (GAIN2)"
    tree.end
    tree "IADC1_USR_ADC_DIG_PARAM"
      sgroup "IADC1_USR_ADC_DIG_PARAM (at 0x3650)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2M4),1 (CLK_SEL_4M8),2 (CLK_SEL_9M6),3 (CLK_SEL_19M2)"
    tree.end
    tree "IADC1_USR_CONV_REQ"
      sgroup "IADC1_USR_CONV_REQ (at 0x3652)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0, 1"
    tree.end
    tree "IADC1_USR_CONV_SEQ_CTL"
      sgroup "IADC1_USR_CONV_SEQ_CTL (at 0x3654)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "IADC1_USR_CONV_SEQ_TRIG_CTL"
      sgroup "IADC1_USR_CONV_SEQ_TRIG_CTL (at 0x3655)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0, 1, 2, 3"
    tree.end
    tree "IADC1_USR_MEAS_INTERVAL_CTL"
      sgroup "IADC1_USR_MEAS_INTERVAL_CTL (at 0x3657)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "IADC1_USR_MEAS_INTERVAL_OP_CTL"
      sgroup "IADC1_USR_MEAS_INTERVAL_OP_CTL (at 0x3659)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0, 1"
    tree.end
    tree "IADC1_USR_FAST_AVG_CTL"
      sgroup "IADC1_USR_FAST_AVG_CTL (at 0x365a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80365a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x365a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "IADC1_USR_FAST_AVG_EN"
      sgroup "IADC1_USR_FAST_AVG_EN (at 0x365b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80365b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x365b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0, 1"
    tree.end
    tree "IADC1_USR_LOW_THR0"
      sgroup "IADC1_USR_LOW_THR0 (at 0x365c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80365c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x365c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "IADC1_USR_LOW_THR1"
      sgroup "IADC1_USR_LOW_THR1 (at 0x365d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80365d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x365d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "IADC1_USR_HIGH_THR0"
      sgroup "IADC1_USR_HIGH_THR0 (at 0x365e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80365e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x365e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "IADC1_USR_HIGH_THR1"
      sgroup "IADC1_USR_HIGH_THR1 (at 0x365f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80365f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x365f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "IADC1_USR_DATA0"
      sgroup "IADC1_USR_DATA0 (at 0x3660)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "IADC1_USR_DATA1"
      sgroup "IADC1_USR_DATA1 (at 0x3661)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "IADC1_USR_SEC_ACCESS"
      sgroup "IADC1_USR_SEC_ACCESS (at 0x36d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "IADC1_USR_PERPH_RESET_CTL1"
      sgroup "IADC1_USR_PERPH_RESET_CTL1 (at 0x36d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "IADC1_USR_PERPH_RESET_CTL2"
      sgroup "IADC1_USR_PERPH_RESET_CTL2 (at 0x36d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "IADC1_USR_PERPH_RESET_CTL3"
      sgroup "IADC1_USR_PERPH_RESET_CTL3 (at 0x36da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "IADC1_USR_PERPH_RESET_CTL4"
      sgroup "IADC1_USR_PERPH_RESET_CTL4 (at 0x36db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_TEST1"
      sgroup "IADC1_USR_INT_TEST1 (at 0x36e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "IADC1_USR_INT_TEST_VAL"
      sgroup "IADC1_USR_INT_TEST_VAL (at 0x36e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0, 1"
    tree.end
    tree "IADC1_USR_TEST1_ADC_ANA_PARAM"
      sgroup "IADC1_USR_TEST1_ADC_ANA_PARAM (at 0x36e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FILT_RESISTOR_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   IOTA1_CTL                                = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   IOTA2_CTL                                = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CCADC_EN                                 = " "0, 1"
    tree.end
    tree "IADC1_USR_TEST2_ADC_DIG_PARAM"
      sgroup "IADC1_USR_TEST2_ADC_DIG_PARAM (at 0x36e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0, 1, 2, 3"
    tree.end
    tree "IADC1_USR_TEST3_ADC_RSV"
      sgroup "IADC1_USR_TEST3_ADC_RSV (at 0x36e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0, 1"
    tree.end
    tree "IADC1_USR_TEST4_ADC_ATEST"
      sgroup "IADC1_USR_TEST4_ADC_ATEST (at 0x36e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IP_MODE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "IADC1_USR_TEST5_DTEST"
      sgroup "IADC1_USR_TEST5_DTEST (at 0x36e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "IADC1_USR_TEST6_CADC_LDO_VOUT"
      sgroup "IADC1_USR_TEST6_CADC_LDO_VOUT (at 0x36e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CADC_LDO_VSET                            = "
    tree.end
    tree "IADC1_USR_TEST6_CADC_LDO_CTL"
      sgroup "IADC1_USR_TEST6_CADC_LDO_CTL (at 0x36e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CADC_LDO_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CADC_LDO_TRIM_CTL                        = " "0, 1, 2, 3"
    tree.end
    tree "IADC1_USR_TRIM_NUM"
      sgroup "IADC1_USR_TRIM_NUM (at 0x36f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "IADC1_USR_TRIM1_LDO"
      sgroup "IADC1_USR_TRIM1_LDO (at 0x36f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CADC_LDO_TRIM                            = "
    tree.end
    tree "IADC1_USR_TRIM2_ADC_OFFSET1"
      sgroup "IADC1_USR_TRIM2_ADC_OFFSET1 (at 0x36f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_OFFSET1                             = "
    tree.end
    tree "IADC1_USR_TRIM3_ADC_OFFSET0"
      sgroup "IADC1_USR_TRIM3_ADC_OFFSET0 (at 0x36f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_OFFSET0                             = "
    tree.end
    tree "IADC1_USR_TRIM2_ADC_FULLSCALE1"
      sgroup "IADC1_USR_TRIM2_ADC_FULLSCALE1 (at 0x36f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_FULLSCALE1                          = "
    tree.end
    tree "IADC1_USR_TRIM3_ADC_FULLSCALE0"
      sgroup "IADC1_USR_TRIM3_ADC_FULLSCALE0 (at 0x36f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_FULSCALE0                           = "
    tree.end
  tree.end
tree.end
tree "IADC2_BMS"
  tree "IADC2_BMS"
    tree "IADC2_BMS_REVISION1"
      sgroup "IADC2_BMS_REVISION1 (at 0x3800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "IADC2_BMS_REVISION2"
      sgroup "IADC2_BMS_REVISION2 (at 0x3801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "IADC2_BMS_REVISION3"
      sgroup "IADC2_BMS_REVISION3 (at 0x3802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "IADC2_BMS_REVISION4"
      sgroup "IADC2_BMS_REVISION4 (at 0x3803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "IADC2_BMS_PERPH_TYPE"
      sgroup "IADC2_BMS_PERPH_TYPE (at 0x3804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "IADC2_BMS_PERPH_SUBTYPE"
      sgroup "IADC2_BMS_PERPH_SUBTYPE (at 0x3805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "IADC2_BMS_STATUS1"
      sgroup "IADC2_BMS_STATUS1 (at 0x3808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0, 1"
    tree.end
    tree "IADC2_BMS_STATUS2"
      sgroup "IADC2_BMS_STATUS2 (at 0x3809)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_RT_STS"
      sgroup "IADC2_BMS_INT_RT_STS (at 0x3810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_SET_TYPE"
      sgroup "IADC2_BMS_INT_SET_TYPE (at 0x3811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_POLARITY_HIGH"
      sgroup "IADC2_BMS_INT_POLARITY_HIGH (at 0x3812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_POLARITY_LOW"
      sgroup "IADC2_BMS_INT_POLARITY_LOW (at 0x3813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_LATCHED_CLR"
      sgroup "IADC2_BMS_INT_LATCHED_CLR (at 0x3814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_EN_SET"
      sgroup "IADC2_BMS_INT_EN_SET (at 0x3815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_EN_CLR"
      sgroup "IADC2_BMS_INT_EN_CLR (at 0x3816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_LATCHED_STS"
      sgroup "IADC2_BMS_INT_LATCHED_STS (at 0x3818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_PENDING_STS"
      sgroup "IADC2_BMS_INT_PENDING_STS (at 0x3819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_MID_SEL"
      sgroup "IADC2_BMS_INT_MID_SEL (at 0x381a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80381a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x381a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "IADC2_BMS_INT_PRIORITY"
      sgroup "IADC2_BMS_INT_PRIORITY (at 0x381b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80381b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x381b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "IADC2_BMS_MODE_CTL"
      sgroup "IADC2_BMS_MODE_CTL (at 0x3840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USE_BMS_DATA                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VADC_SYNCH_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OFFSET_RMV_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0, 1"
    tree.end
    tree "IADC2_BMS_EN_CTL1"
      sgroup "IADC2_BMS_EN_CTL1 (at 0x3846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0, 1"
    tree.end
    tree "IADC2_BMS_ADC_CH_SEL_CTL"
      sgroup "IADC2_BMS_ADC_CH_SEL_CTL (at 0x3848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_CH_SEL                               = " "0 (INTRSNS),1 (EXTRSNS),2 (CSP2_CSN2),3 (GAIN),4 (INTRSNS_OFFSET),5 (EXTRSNS_OFFSET),6 (CSP2_CSN2_OFFSET),7 (GAIN2)"
    tree.end
    tree "IADC2_BMS_ADC_DIG_PARAM"
      sgroup "IADC2_BMS_ADC_DIG_PARAM (at 0x3850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2M4),1 (CLK_SEL_4M8),2 (CLK_SEL_9M6),3 (CLK_SEL_19M2)"
    tree.end
    tree "IADC2_BMS_CONV_REQ"
      sgroup "IADC2_BMS_CONV_REQ (at 0x3852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0, 1"
    tree.end
    tree "IADC2_BMS_CONV_SEQ_CTL"
      sgroup "IADC2_BMS_CONV_SEQ_CTL (at 0x3854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "IADC2_BMS_CONV_SEQ_TRIG_CTL"
      sgroup "IADC2_BMS_CONV_SEQ_TRIG_CTL (at 0x3855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0, 1, 2, 3"
    tree.end
    tree "IADC2_BMS_MEAS_INTERVAL_CTL"
      sgroup "IADC2_BMS_MEAS_INTERVAL_CTL (at 0x3857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "IADC2_BMS_MEAS_INTERVAL_OP_CTL"
      sgroup "IADC2_BMS_MEAS_INTERVAL_OP_CTL (at 0x3859)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0, 1"
    tree.end
    tree "IADC2_BMS_FAST_AVG_CTL"
      sgroup "IADC2_BMS_FAST_AVG_CTL (at 0x385a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80385a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x385a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "IADC2_BMS_FAST_AVG_EN"
      sgroup "IADC2_BMS_FAST_AVG_EN (at 0x385b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80385b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x385b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0, 1"
    tree.end
    tree "IADC2_BMS_LOW_THR0"
      sgroup "IADC2_BMS_LOW_THR0 (at 0x385c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80385c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x385c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "IADC2_BMS_LOW_THR1"
      sgroup "IADC2_BMS_LOW_THR1 (at 0x385d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80385d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x385d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "IADC2_BMS_HIGH_THR0"
      sgroup "IADC2_BMS_HIGH_THR0 (at 0x385e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80385e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x385e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "IADC2_BMS_HIGH_THR1"
      sgroup "IADC2_BMS_HIGH_THR1 (at 0x385f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80385f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x385f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "IADC2_BMS_DATA0"
      sgroup "IADC2_BMS_DATA0 (at 0x3860)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "IADC2_BMS_DATA1"
      sgroup "IADC2_BMS_DATA1 (at 0x3861)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "IADC2_BMS_SEC_ACCESS"
      sgroup "IADC2_BMS_SEC_ACCESS (at 0x38d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "IADC2_BMS_PERPH_RESET_CTL1"
      sgroup "IADC2_BMS_PERPH_RESET_CTL1 (at 0x38d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "IADC2_BMS_PERPH_RESET_CTL2"
      sgroup "IADC2_BMS_PERPH_RESET_CTL2 (at 0x38d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "IADC2_BMS_PERPH_RESET_CTL3"
      sgroup "IADC2_BMS_PERPH_RESET_CTL3 (at 0x38da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "IADC2_BMS_PERPH_RESET_CTL4"
      sgroup "IADC2_BMS_PERPH_RESET_CTL4 (at 0x38db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_TEST1"
      sgroup "IADC2_BMS_INT_TEST1 (at 0x38e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "IADC2_BMS_INT_TEST_VAL"
      sgroup "IADC2_BMS_INT_TEST_VAL (at 0x38e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0, 1"
    tree.end
    tree "IADC2_BMS_TEST5_DTEST"
      sgroup "IADC2_BMS_TEST5_DTEST (at 0x38e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0, 1, 2, 3"
    tree.end
    tree "IADC2_BMS_TRIM2_ADC_OFFSET1"
      sgroup "IADC2_BMS_TRIM2_ADC_OFFSET1 (at 0x38f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_OFFSET1                             = "
    tree.end
    tree "IADC2_BMS_TRIM3_ADC_OFFSET0"
      sgroup "IADC2_BMS_TRIM3_ADC_OFFSET0 (at 0x38f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_OFFSET0                             = "
    tree.end
    tree "IADC2_BMS_TRIM2_ADC_FULLSCALE1"
      sgroup "IADC2_BMS_TRIM2_ADC_FULLSCALE1 (at 0x38f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_FULLSCALE1                          = "
    tree.end
    tree "IADC2_BMS_TRIM3_ADC_FULLSCALE0"
      sgroup "IADC2_BMS_TRIM3_ADC_FULLSCALE0 (at 0x38f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_FULSCALE0                           = "
    tree.end
  tree.end
tree.end
tree "IADC2_MDM"
  tree "IADC2_MDM"
    tree "IADC2_MDM_REVISION1"
      sgroup "IADC2_MDM_REVISION1 (at 0x3700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "IADC2_MDM_REVISION2"
      sgroup "IADC2_MDM_REVISION2 (at 0x3701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "IADC2_MDM_REVISION3"
      sgroup "IADC2_MDM_REVISION3 (at 0x3702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "IADC2_MDM_REVISION4"
      sgroup "IADC2_MDM_REVISION4 (at 0x3703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "IADC2_MDM_PERPH_TYPE"
      sgroup "IADC2_MDM_PERPH_TYPE (at 0x3704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "IADC2_MDM_PERPH_SUBTYPE"
      sgroup "IADC2_MDM_PERPH_SUBTYPE (at 0x3705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "IADC2_MDM_STATUS1"
      sgroup "IADC2_MDM_STATUS1 (at 0x3708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0, 1"
    tree.end
    tree "IADC2_MDM_STATUS2"
      sgroup "IADC2_MDM_STATUS2 (at 0x3709)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_RT_STS"
      sgroup "IADC2_MDM_INT_RT_STS (at 0x3710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_SET_TYPE"
      sgroup "IADC2_MDM_INT_SET_TYPE (at 0x3711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_POLARITY_HIGH"
      sgroup "IADC2_MDM_INT_POLARITY_HIGH (at 0x3712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_POLARITY_LOW"
      sgroup "IADC2_MDM_INT_POLARITY_LOW (at 0x3713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_LATCHED_CLR"
      sgroup "IADC2_MDM_INT_LATCHED_CLR (at 0x3714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_EN_SET"
      sgroup "IADC2_MDM_INT_EN_SET (at 0x3715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_EN_CLR"
      sgroup "IADC2_MDM_INT_EN_CLR (at 0x3716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_LATCHED_STS"
      sgroup "IADC2_MDM_INT_LATCHED_STS (at 0x3718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_PENDING_STS"
      sgroup "IADC2_MDM_INT_PENDING_STS (at 0x3719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_MID_SEL"
      sgroup "IADC2_MDM_INT_MID_SEL (at 0x371a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80371a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x371a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "IADC2_MDM_INT_PRIORITY"
      sgroup "IADC2_MDM_INT_PRIORITY (at 0x371b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80371b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x371b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "IADC2_MDM_MODE_CTL"
      sgroup "IADC2_MDM_MODE_CTL (at 0x3740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USE_BMS_DATA                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VADC_SYNCH_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OFFSET_RMV_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0, 1"
    tree.end
    tree "IADC2_MDM_EN_CTL1"
      sgroup "IADC2_MDM_EN_CTL1 (at 0x3746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0, 1"
    tree.end
    tree "IADC2_MDM_ADC_CH_SEL_CTL"
      sgroup "IADC2_MDM_ADC_CH_SEL_CTL (at 0x3748)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_CH_SEL                               = " "0 (INTRSNS),1 (EXTRSNS),2 (CSP2_CSN2),3 (GAIN),4 (INTRSNS_OFFSET),5 (EXTRSNS_OFFSET),6 (CSP2_CSN2_OFFSET),7 (GAIN2)"
    tree.end
    tree "IADC2_MDM_ADC_DIG_PARAM"
      sgroup "IADC2_MDM_ADC_DIG_PARAM (at 0x3750)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2M4),1 (CLK_SEL_4M8),2 (CLK_SEL_9M6),3 (CLK_SEL_19M2)"
    tree.end
    tree "IADC2_MDM_CONV_REQ"
      sgroup "IADC2_MDM_CONV_REQ (at 0x3752)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0, 1"
    tree.end
    tree "IADC2_MDM_CONV_SEQ_CTL"
      sgroup "IADC2_MDM_CONV_SEQ_CTL (at 0x3754)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "IADC2_MDM_CONV_SEQ_TRIG_CTL"
      sgroup "IADC2_MDM_CONV_SEQ_TRIG_CTL (at 0x3755)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0, 1, 2, 3"
    tree.end
    tree "IADC2_MDM_MEAS_INTERVAL_CTL"
      sgroup "IADC2_MDM_MEAS_INTERVAL_CTL (at 0x3757)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "IADC2_MDM_MEAS_INTERVAL_OP_CTL"
      sgroup "IADC2_MDM_MEAS_INTERVAL_OP_CTL (at 0x3759)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0, 1"
    tree.end
    tree "IADC2_MDM_FAST_AVG_CTL"
      sgroup "IADC2_MDM_FAST_AVG_CTL (at 0x375a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80375a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x375a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "IADC2_MDM_FAST_AVG_EN"
      sgroup "IADC2_MDM_FAST_AVG_EN (at 0x375b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80375b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x375b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0, 1"
    tree.end
    tree "IADC2_MDM_LOW_THR0"
      sgroup "IADC2_MDM_LOW_THR0 (at 0x375c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80375c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x375c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "IADC2_MDM_LOW_THR1"
      sgroup "IADC2_MDM_LOW_THR1 (at 0x375d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80375d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x375d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "IADC2_MDM_HIGH_THR0"
      sgroup "IADC2_MDM_HIGH_THR0 (at 0x375e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80375e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x375e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "IADC2_MDM_HIGH_THR1"
      sgroup "IADC2_MDM_HIGH_THR1 (at 0x375f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80375f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x375f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "IADC2_MDM_DATA0"
      sgroup "IADC2_MDM_DATA0 (at 0x3760)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "IADC2_MDM_DATA1"
      sgroup "IADC2_MDM_DATA1 (at 0x3761)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "IADC2_MDM_SEC_ACCESS"
      sgroup "IADC2_MDM_SEC_ACCESS (at 0x37d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "IADC2_MDM_PERPH_RESET_CTL1"
      sgroup "IADC2_MDM_PERPH_RESET_CTL1 (at 0x37d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "IADC2_MDM_PERPH_RESET_CTL2"
      sgroup "IADC2_MDM_PERPH_RESET_CTL2 (at 0x37d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "IADC2_MDM_PERPH_RESET_CTL3"
      sgroup "IADC2_MDM_PERPH_RESET_CTL3 (at 0x37da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "IADC2_MDM_PERPH_RESET_CTL4"
      sgroup "IADC2_MDM_PERPH_RESET_CTL4 (at 0x37db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_TEST1"
      sgroup "IADC2_MDM_INT_TEST1 (at 0x37e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "IADC2_MDM_INT_TEST_VAL"
      sgroup "IADC2_MDM_INT_TEST_VAL (at 0x37e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0, 1"
    tree.end
    tree "IADC2_MDM_TEST5_DTEST"
      sgroup "IADC2_MDM_TEST5_DTEST (at 0x37e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0, 1, 2, 3"
    tree.end
    tree "IADC2_MDM_TRIM2_ADC_OFFSET1"
      sgroup "IADC2_MDM_TRIM2_ADC_OFFSET1 (at 0x37f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_OFFSET1                             = "
    tree.end
    tree "IADC2_MDM_TRIM3_ADC_OFFSET0"
      sgroup "IADC2_MDM_TRIM3_ADC_OFFSET0 (at 0x37f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_OFFSET0                             = "
    tree.end
    tree "IADC2_MDM_TRIM2_ADC_FULLSCALE1"
      sgroup "IADC2_MDM_TRIM2_ADC_FULLSCALE1 (at 0x37f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_FULLSCALE1                          = "
    tree.end
    tree "IADC2_MDM_TRIM3_ADC_FULLSCALE0"
      sgroup "IADC2_MDM_TRIM3_ADC_FULLSCALE0 (at 0x37f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CADC_FULSCALE0                           = "
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0, 1"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0, 1"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0, 1"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LDO1"
  tree "LDO1"
    tree "LDO1_REVISION1"
      sgroup "LDO1_REVISION1 (at 0x14000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO1_REVISION2"
      sgroup "LDO1_REVISION2 (at 0x14001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO1_REVISION3"
      sgroup "LDO1_REVISION3 (at 0x14002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO1_REVISION4"
      sgroup "LDO1_REVISION4 (at 0x14003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO1_PERPH_TYPE"
      sgroup "LDO1_PERPH_TYPE (at 0x14004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO1_PERPH_SUBTYPE"
      sgroup "LDO1_PERPH_SUBTYPE (at 0x14005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO1_STATUS1"
      sgroup "LDO1_STATUS1 (at 0x14008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "LDO1_STATUS2"
      sgroup "LDO1_STATUS2 (at 0x14009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO1_STATUS3"
      sgroup "LDO1_STATUS3 (at 0x1400a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO1_INT_RT_STS"
      sgroup "LDO1_INT_RT_STS (at 0x14010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO1_INT_SET_TYPE"
      sgroup "LDO1_INT_SET_TYPE (at 0x14011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO1_INT_POLARITY_HIGH"
      sgroup "LDO1_INT_POLARITY_HIGH (at 0x14012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO1_INT_POLARITY_LOW"
      sgroup "LDO1_INT_POLARITY_LOW (at 0x14013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO1_INT_LATCHED_CLR"
      sgroup "LDO1_INT_LATCHED_CLR (at 0x14014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO1_INT_EN_SET"
      sgroup "LDO1_INT_EN_SET (at 0x14015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO1_INT_EN_CLR"
      sgroup "LDO1_INT_EN_CLR (at 0x14016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO1_INT_LATCHED_STS"
      sgroup "LDO1_INT_LATCHED_STS (at 0x14018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO1_INT_PENDING_STS"
      sgroup "LDO1_INT_PENDING_STS (at 0x14019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO1_INT_MID_SEL"
      sgroup "LDO1_INT_MID_SEL (at 0x1401a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO1_INT_PRIORITY"
      sgroup "LDO1_INT_PRIORITY (at 0x1401b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO1_VOLTAGE_CTL1"
      sgroup "LDO1_VOLTAGE_CTL1 (at 0x14040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_VOLTAGE_CTL2"
      sgroup "LDO1_VOLTAGE_CTL2 (at 0x14041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO1_MODE_CTL2"
      sgroup "LDO1_MODE_CTL2 (at 0x14045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO1_EN_CTL"
      sgroup "LDO1_EN_CTL (at 0x14046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO1_PD_CTL"
      sgroup "LDO1_PD_CTL (at 0x14048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO1_CURRENT_LIM_CTL"
      sgroup "LDO1_CURRENT_LIM_CTL (at 0x1404a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO1_SOFT_START_CTL"
      sgroup "LDO1_SOFT_START_CTL (at 0x1404c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO1_CONFIG_CTL"
      sgroup "LDO1_CONFIG_CTL (at 0x14052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO1_VS_CTL"
      sgroup "LDO1_VS_CTL (at 0x14061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL1"
      sgroup "LDO1_LL_VOLTAGE_CTL1 (at 0x14068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_LL_VOLTAGE_CTL2"
      sgroup "LDO1_LL_VOLTAGE_CTL2 (at 0x14069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL1"
      sgroup "LDO1_UL_VOLTAGE_CTL1 (at 0x1406a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO1_UL_VOLTAGE_CTL2"
      sgroup "LDO1_UL_VOLTAGE_CTL2 (at 0x1406b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80406b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x406b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO1_SEC_ACCESS"
      sgroup "LDO1_SEC_ACCESS (at 0x140d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO1_PERPH_RESET_CTL1"
      sgroup "LDO1_PERPH_RESET_CTL1 (at 0x140d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO1_PERPH_RESET_CTL2"
      sgroup "LDO1_PERPH_RESET_CTL2 (at 0x140d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO1_PERPH_RESET_CTL3"
      sgroup "LDO1_PERPH_RESET_CTL3 (at 0x140da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO1_PERPH_RESET_CTL4"
      sgroup "LDO1_PERPH_RESET_CTL4 (at 0x140db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO1_INT_TEST1"
      sgroup "LDO1_INT_TEST1 (at 0x140e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO1_INT_TEST_VAL"
      sgroup "LDO1_INT_TEST_VAL (at 0x140e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO1_TEST1"
      sgroup "LDO1_TEST1 (at 0x140e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO1_TEST2"
      sgroup "LDO1_TEST2 (at 0x140e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO1_TRIM_NUM"
      sgroup "LDO1_TRIM_NUM (at 0x140f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO1_TRIM_CTRL"
      sgroup "LDO1_TRIM_CTRL (at 0x140f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO10"
  tree "LDO10"
    tree "LDO10_REVISION1"
      sgroup "LDO10_REVISION1 (at 0x14900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO10_REVISION2"
      sgroup "LDO10_REVISION2 (at 0x14901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO10_REVISION3"
      sgroup "LDO10_REVISION3 (at 0x14902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO10_REVISION4"
      sgroup "LDO10_REVISION4 (at 0x14903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO10_PERPH_TYPE"
      sgroup "LDO10_PERPH_TYPE (at 0x14904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO10_PERPH_SUBTYPE"
      sgroup "LDO10_PERPH_SUBTYPE (at 0x14905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO10_STATUS1"
      sgroup "LDO10_STATUS1 (at 0x14908)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO10_STATUS2"
      sgroup "LDO10_STATUS2 (at 0x14909)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO10_STATUS3"
      sgroup "LDO10_STATUS3 (at 0x1490a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80490a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x490a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO10_INT_RT_STS"
      sgroup "LDO10_INT_RT_STS (at 0x14910)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO10_INT_SET_TYPE"
      sgroup "LDO10_INT_SET_TYPE (at 0x14911)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO10_INT_POLARITY_HIGH"
      sgroup "LDO10_INT_POLARITY_HIGH (at 0x14912)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO10_INT_POLARITY_LOW"
      sgroup "LDO10_INT_POLARITY_LOW (at 0x14913)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO10_INT_LATCHED_CLR"
      sgroup "LDO10_INT_LATCHED_CLR (at 0x14914)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO10_INT_EN_SET"
      sgroup "LDO10_INT_EN_SET (at 0x14915)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO10_INT_EN_CLR"
      sgroup "LDO10_INT_EN_CLR (at 0x14916)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO10_INT_LATCHED_STS"
      sgroup "LDO10_INT_LATCHED_STS (at 0x14918)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO10_INT_PENDING_STS"
      sgroup "LDO10_INT_PENDING_STS (at 0x14919)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO10_INT_MID_SEL"
      sgroup "LDO10_INT_MID_SEL (at 0x1491a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO10_INT_PRIORITY"
      sgroup "LDO10_INT_PRIORITY (at 0x1491b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO10_VOLTAGE_CTL1"
      sgroup "LDO10_VOLTAGE_CTL1 (at 0x14940)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_VOLTAGE_CTL2"
      sgroup "LDO10_VOLTAGE_CTL2 (at 0x14941)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO10_MODE_CTL2"
      sgroup "LDO10_MODE_CTL2 (at 0x14945)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO10_EN_CTL"
      sgroup "LDO10_EN_CTL (at 0x14946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO10_PD_CTL"
      sgroup "LDO10_PD_CTL (at 0x14948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO10_CURRENT_LIM_CTL"
      sgroup "LDO10_CURRENT_LIM_CTL (at 0x1494a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80494a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x494a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO10_SOFT_START_CTL"
      sgroup "LDO10_SOFT_START_CTL (at 0x1494c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80494c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x494c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO10_CONFIG_CTL"
      sgroup "LDO10_CONFIG_CTL (at 0x14952)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL1"
      sgroup "LDO10_LL_VOLTAGE_CTL1 (at 0x14968)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_LL_VOLTAGE_CTL2"
      sgroup "LDO10_LL_VOLTAGE_CTL2 (at 0x14969)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL1"
      sgroup "LDO10_UL_VOLTAGE_CTL1 (at 0x1496a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80496a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x496a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO10_UL_VOLTAGE_CTL2"
      sgroup "LDO10_UL_VOLTAGE_CTL2 (at 0x1496b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80496b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x496b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO10_SEC_ACCESS"
      sgroup "LDO10_SEC_ACCESS (at 0x149d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO10_PERPH_RESET_CTL1"
      sgroup "LDO10_PERPH_RESET_CTL1 (at 0x149d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO10_PERPH_RESET_CTL2"
      sgroup "LDO10_PERPH_RESET_CTL2 (at 0x149d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO10_PERPH_RESET_CTL3"
      sgroup "LDO10_PERPH_RESET_CTL3 (at 0x149da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO10_PERPH_RESET_CTL4"
      sgroup "LDO10_PERPH_RESET_CTL4 (at 0x149db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO10_INT_TEST1"
      sgroup "LDO10_INT_TEST1 (at 0x149e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO10_INT_TEST_VAL"
      sgroup "LDO10_INT_TEST_VAL (at 0x149e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO10_TEST1"
      sgroup "LDO10_TEST1 (at 0x149e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO10_TEST2"
      sgroup "LDO10_TEST2 (at 0x149e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO10_TRIM_NUM"
      sgroup "LDO10_TRIM_NUM (at 0x149f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO10_TRIM_CTRL"
      sgroup "LDO10_TRIM_CTRL (at 0x149f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO11"
  tree "LDO11"
    tree "LDO11_REVISION1"
      sgroup "LDO11_REVISION1 (at 0x14a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO11_REVISION2"
      sgroup "LDO11_REVISION2 (at 0x14a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO11_REVISION3"
      sgroup "LDO11_REVISION3 (at 0x14a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO11_REVISION4"
      sgroup "LDO11_REVISION4 (at 0x14a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO11_PERPH_TYPE"
      sgroup "LDO11_PERPH_TYPE (at 0x14a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO11_PERPH_SUBTYPE"
      sgroup "LDO11_PERPH_SUBTYPE (at 0x14a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO11_STATUS1"
      sgroup "LDO11_STATUS1 (at 0x14a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
    tree.end
    tree "LDO11_VOLTAGE_CTL1"
      sgroup "LDO11_VOLTAGE_CTL1 (at 0x14a40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "LDO11_VOLTAGE_CTL2"
      sgroup "LDO11_VOLTAGE_CTL2 (at 0x14a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO11_MODE_CTL2"
      sgroup "LDO11_MODE_CTL2 (at 0x14a45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
    tree.end
    tree "LDO11_EN_CTL"
      sgroup "LDO11_EN_CTL (at 0x14a46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
    tree.end
    tree "LDO11_SEC_ACCESS"
      sgroup "LDO11_SEC_ACCESS (at 0x14ad0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO11_PERPH_RESET_CTL1"
      sgroup "LDO11_PERPH_RESET_CTL1 (at 0x14ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO11_PERPH_RESET_CTL2"
      sgroup "LDO11_PERPH_RESET_CTL2 (at 0x14ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO11_PERPH_RESET_CTL3"
      sgroup "LDO11_PERPH_RESET_CTL3 (at 0x14ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO11_PERPH_RESET_CTL4"
      sgroup "LDO11_PERPH_RESET_CTL4 (at 0x14adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO11_TEST1"
      sgroup "LDO11_TEST1 (at 0x14ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0, 1"
    tree.end
  tree.end
tree.end
tree "LDO12"
  tree "LDO12"
    tree "LDO12_REVISION1"
      sgroup "LDO12_REVISION1 (at 0x14b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO12_REVISION2"
      sgroup "LDO12_REVISION2 (at 0x14b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO12_REVISION3"
      sgroup "LDO12_REVISION3 (at 0x14b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO12_REVISION4"
      sgroup "LDO12_REVISION4 (at 0x14b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO12_PERPH_TYPE"
      sgroup "LDO12_PERPH_TYPE (at 0x14b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO12_PERPH_SUBTYPE"
      sgroup "LDO12_PERPH_SUBTYPE (at 0x14b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO12_STATUS1"
      sgroup "LDO12_STATUS1 (at 0x14b08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO12_STATUS2"
      sgroup "LDO12_STATUS2 (at 0x14b09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO12_STATUS3"
      sgroup "LDO12_STATUS3 (at 0x14b0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO12_INT_RT_STS"
      sgroup "LDO12_INT_RT_STS (at 0x14b10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO12_INT_SET_TYPE"
      sgroup "LDO12_INT_SET_TYPE (at 0x14b11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO12_INT_POLARITY_HIGH"
      sgroup "LDO12_INT_POLARITY_HIGH (at 0x14b12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO12_INT_POLARITY_LOW"
      sgroup "LDO12_INT_POLARITY_LOW (at 0x14b13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO12_INT_LATCHED_CLR"
      sgroup "LDO12_INT_LATCHED_CLR (at 0x14b14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO12_INT_EN_SET"
      sgroup "LDO12_INT_EN_SET (at 0x14b15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO12_INT_EN_CLR"
      sgroup "LDO12_INT_EN_CLR (at 0x14b16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO12_INT_LATCHED_STS"
      sgroup "LDO12_INT_LATCHED_STS (at 0x14b18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO12_INT_PENDING_STS"
      sgroup "LDO12_INT_PENDING_STS (at 0x14b19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO12_INT_MID_SEL"
      sgroup "LDO12_INT_MID_SEL (at 0x14b1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO12_INT_PRIORITY"
      sgroup "LDO12_INT_PRIORITY (at 0x14b1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO12_VOLTAGE_CTL1"
      sgroup "LDO12_VOLTAGE_CTL1 (at 0x14b40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_VOLTAGE_CTL2"
      sgroup "LDO12_VOLTAGE_CTL2 (at 0x14b41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO12_MODE_CTL2"
      sgroup "LDO12_MODE_CTL2 (at 0x14b45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO12_EN_CTL"
      sgroup "LDO12_EN_CTL (at 0x14b46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO12_PD_CTL"
      sgroup "LDO12_PD_CTL (at 0x14b48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO12_CURRENT_LIM_CTL"
      sgroup "LDO12_CURRENT_LIM_CTL (at 0x14b4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO12_SOFT_START_CTL"
      sgroup "LDO12_SOFT_START_CTL (at 0x14b4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO12_CONFIG_CTL"
      sgroup "LDO12_CONFIG_CTL (at 0x14b52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL1"
      sgroup "LDO12_LL_VOLTAGE_CTL1 (at 0x14b68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_LL_VOLTAGE_CTL2"
      sgroup "LDO12_LL_VOLTAGE_CTL2 (at 0x14b69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL1"
      sgroup "LDO12_UL_VOLTAGE_CTL1 (at 0x14b6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO12_UL_VOLTAGE_CTL2"
      sgroup "LDO12_UL_VOLTAGE_CTL2 (at 0x14b6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO12_SEC_ACCESS"
      sgroup "LDO12_SEC_ACCESS (at 0x14bd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO12_PERPH_RESET_CTL1"
      sgroup "LDO12_PERPH_RESET_CTL1 (at 0x14bd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO12_PERPH_RESET_CTL2"
      sgroup "LDO12_PERPH_RESET_CTL2 (at 0x14bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO12_PERPH_RESET_CTL3"
      sgroup "LDO12_PERPH_RESET_CTL3 (at 0x14bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO12_PERPH_RESET_CTL4"
      sgroup "LDO12_PERPH_RESET_CTL4 (at 0x14bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO12_INT_TEST1"
      sgroup "LDO12_INT_TEST1 (at 0x14be0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO12_INT_TEST_VAL"
      sgroup "LDO12_INT_TEST_VAL (at 0x14be1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO12_TEST1"
      sgroup "LDO12_TEST1 (at 0x14be2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO12_TEST2"
      sgroup "LDO12_TEST2 (at 0x14be3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO12_TRIM_NUM"
      sgroup "LDO12_TRIM_NUM (at 0x14bf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO12_TRIM_CTRL"
      sgroup "LDO12_TRIM_CTRL (at 0x14bf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO13"
  tree "LDO13"
    tree "LDO13_REVISION1"
      sgroup "LDO13_REVISION1 (at 0x14c00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO13_REVISION2"
      sgroup "LDO13_REVISION2 (at 0x14c01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO13_REVISION3"
      sgroup "LDO13_REVISION3 (at 0x14c02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO13_REVISION4"
      sgroup "LDO13_REVISION4 (at 0x14c03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO13_PERPH_TYPE"
      sgroup "LDO13_PERPH_TYPE (at 0x14c04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO13_PERPH_SUBTYPE"
      sgroup "LDO13_PERPH_SUBTYPE (at 0x14c05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO13_STATUS1"
      sgroup "LDO13_STATUS1 (at 0x14c08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
    tree.end
    tree "LDO13_VOLTAGE_CTL1"
      sgroup "LDO13_VOLTAGE_CTL1 (at 0x14c40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "LDO13_VOLTAGE_CTL2"
      sgroup "LDO13_VOLTAGE_CTL2 (at 0x14c41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VSET                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO13_MODE_CTL2"
      sgroup "LDO13_MODE_CTL2 (at 0x14c45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
    tree.end
    tree "LDO13_EN_CTL"
      sgroup "LDO13_EN_CTL (at 0x14c46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
    tree.end
    tree "LDO13_SEC_ACCESS"
      sgroup "LDO13_SEC_ACCESS (at 0x14cd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO13_PERPH_RESET_CTL1"
      sgroup "LDO13_PERPH_RESET_CTL1 (at 0x14cd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO13_PERPH_RESET_CTL2"
      sgroup "LDO13_PERPH_RESET_CTL2 (at 0x14cd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO13_PERPH_RESET_CTL3"
      sgroup "LDO13_PERPH_RESET_CTL3 (at 0x14cda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO13_PERPH_RESET_CTL4"
      sgroup "LDO13_PERPH_RESET_CTL4 (at 0x14cdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO13_TEST1"
      sgroup "LDO13_TEST1 (at 0x14ce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST1                                   = " "0, 1"
    tree.end
  tree.end
tree.end
tree "LDO14"
  tree "LDO14"
    tree "LDO14_REVISION1"
      sgroup "LDO14_REVISION1 (at 0x14d00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO14_REVISION2"
      sgroup "LDO14_REVISION2 (at 0x14d01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO14_REVISION3"
      sgroup "LDO14_REVISION3 (at 0x14d02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO14_REVISION4"
      sgroup "LDO14_REVISION4 (at 0x14d03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO14_PERPH_TYPE"
      sgroup "LDO14_PERPH_TYPE (at 0x14d04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO14_PERPH_SUBTYPE"
      sgroup "LDO14_PERPH_SUBTYPE (at 0x14d05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO14_STATUS1"
      sgroup "LDO14_STATUS1 (at 0x14d08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO14_STATUS2"
      sgroup "LDO14_STATUS2 (at 0x14d09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO14_STATUS3"
      sgroup "LDO14_STATUS3 (at 0x14d0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO14_INT_RT_STS"
      sgroup "LDO14_INT_RT_STS (at 0x14d10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO14_INT_SET_TYPE"
      sgroup "LDO14_INT_SET_TYPE (at 0x14d11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO14_INT_POLARITY_HIGH"
      sgroup "LDO14_INT_POLARITY_HIGH (at 0x14d12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO14_INT_POLARITY_LOW"
      sgroup "LDO14_INT_POLARITY_LOW (at 0x14d13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO14_INT_LATCHED_CLR"
      sgroup "LDO14_INT_LATCHED_CLR (at 0x14d14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO14_INT_EN_SET"
      sgroup "LDO14_INT_EN_SET (at 0x14d15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO14_INT_EN_CLR"
      sgroup "LDO14_INT_EN_CLR (at 0x14d16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO14_INT_LATCHED_STS"
      sgroup "LDO14_INT_LATCHED_STS (at 0x14d18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO14_INT_PENDING_STS"
      sgroup "LDO14_INT_PENDING_STS (at 0x14d19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO14_INT_MID_SEL"
      sgroup "LDO14_INT_MID_SEL (at 0x14d1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO14_INT_PRIORITY"
      sgroup "LDO14_INT_PRIORITY (at 0x14d1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO14_VOLTAGE_CTL1"
      sgroup "LDO14_VOLTAGE_CTL1 (at 0x14d40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_VOLTAGE_CTL2"
      sgroup "LDO14_VOLTAGE_CTL2 (at 0x14d41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO14_MODE_CTL2"
      sgroup "LDO14_MODE_CTL2 (at 0x14d45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO14_EN_CTL"
      sgroup "LDO14_EN_CTL (at 0x14d46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO14_PD_CTL"
      sgroup "LDO14_PD_CTL (at 0x14d48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO14_CURRENT_LIM_CTL"
      sgroup "LDO14_CURRENT_LIM_CTL (at 0x14d4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO14_SOFT_START_CTL"
      sgroup "LDO14_SOFT_START_CTL (at 0x14d4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO14_CONFIG_CTL"
      sgroup "LDO14_CONFIG_CTL (at 0x14d52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL1"
      sgroup "LDO14_LL_VOLTAGE_CTL1 (at 0x14d68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_LL_VOLTAGE_CTL2"
      sgroup "LDO14_LL_VOLTAGE_CTL2 (at 0x14d69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL1"
      sgroup "LDO14_UL_VOLTAGE_CTL1 (at 0x14d6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO14_UL_VOLTAGE_CTL2"
      sgroup "LDO14_UL_VOLTAGE_CTL2 (at 0x14d6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804d6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO14_SEC_ACCESS"
      sgroup "LDO14_SEC_ACCESS (at 0x14dd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO14_PERPH_RESET_CTL1"
      sgroup "LDO14_PERPH_RESET_CTL1 (at 0x14dd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO14_PERPH_RESET_CTL2"
      sgroup "LDO14_PERPH_RESET_CTL2 (at 0x14dd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO14_PERPH_RESET_CTL3"
      sgroup "LDO14_PERPH_RESET_CTL3 (at 0x14dda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO14_PERPH_RESET_CTL4"
      sgroup "LDO14_PERPH_RESET_CTL4 (at 0x14ddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO14_INT_TEST1"
      sgroup "LDO14_INT_TEST1 (at 0x14de0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO14_INT_TEST_VAL"
      sgroup "LDO14_INT_TEST_VAL (at 0x14de1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO14_TEST1"
      sgroup "LDO14_TEST1 (at 0x14de2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO14_TEST2"
      sgroup "LDO14_TEST2 (at 0x14de3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804de30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO14_TRIM_NUM"
      sgroup "LDO14_TRIM_NUM (at 0x14df0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804df00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO14_TRIM_CTRL"
      sgroup "LDO14_TRIM_CTRL (at 0x14df1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        set &access:&cmd_addr %l 0x804df10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO15"
  tree "LDO15"
    tree "LDO15_REVISION1"
      sgroup "LDO15_REVISION1 (at 0x14e00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO15_REVISION2"
      sgroup "LDO15_REVISION2 (at 0x14e01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO15_REVISION3"
      sgroup "LDO15_REVISION3 (at 0x14e02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO15_REVISION4"
      sgroup "LDO15_REVISION4 (at 0x14e03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO15_PERPH_TYPE"
      sgroup "LDO15_PERPH_TYPE (at 0x14e04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO15_PERPH_SUBTYPE"
      sgroup "LDO15_PERPH_SUBTYPE (at 0x14e05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO15_STATUS1"
      sgroup "LDO15_STATUS1 (at 0x14e08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO15_STATUS2"
      sgroup "LDO15_STATUS2 (at 0x14e09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO15_STATUS3"
      sgroup "LDO15_STATUS3 (at 0x14e0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO15_INT_RT_STS"
      sgroup "LDO15_INT_RT_STS (at 0x14e10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO15_INT_SET_TYPE"
      sgroup "LDO15_INT_SET_TYPE (at 0x14e11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO15_INT_POLARITY_HIGH"
      sgroup "LDO15_INT_POLARITY_HIGH (at 0x14e12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO15_INT_POLARITY_LOW"
      sgroup "LDO15_INT_POLARITY_LOW (at 0x14e13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO15_INT_LATCHED_CLR"
      sgroup "LDO15_INT_LATCHED_CLR (at 0x14e14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO15_INT_EN_SET"
      sgroup "LDO15_INT_EN_SET (at 0x14e15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO15_INT_EN_CLR"
      sgroup "LDO15_INT_EN_CLR (at 0x14e16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO15_INT_LATCHED_STS"
      sgroup "LDO15_INT_LATCHED_STS (at 0x14e18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO15_INT_PENDING_STS"
      sgroup "LDO15_INT_PENDING_STS (at 0x14e19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO15_INT_MID_SEL"
      sgroup "LDO15_INT_MID_SEL (at 0x14e1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO15_INT_PRIORITY"
      sgroup "LDO15_INT_PRIORITY (at 0x14e1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO15_VOLTAGE_CTL1"
      sgroup "LDO15_VOLTAGE_CTL1 (at 0x14e40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_VOLTAGE_CTL2"
      sgroup "LDO15_VOLTAGE_CTL2 (at 0x14e41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO15_MODE_CTL2"
      sgroup "LDO15_MODE_CTL2 (at 0x14e45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO15_EN_CTL"
      sgroup "LDO15_EN_CTL (at 0x14e46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO15_PD_CTL"
      sgroup "LDO15_PD_CTL (at 0x14e48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO15_CURRENT_LIM_CTL"
      sgroup "LDO15_CURRENT_LIM_CTL (at 0x14e4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO15_SOFT_START_CTL"
      sgroup "LDO15_SOFT_START_CTL (at 0x14e4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO15_CONFIG_CTL"
      sgroup "LDO15_CONFIG_CTL (at 0x14e52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL1"
      sgroup "LDO15_LL_VOLTAGE_CTL1 (at 0x14e68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_LL_VOLTAGE_CTL2"
      sgroup "LDO15_LL_VOLTAGE_CTL2 (at 0x14e69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL1"
      sgroup "LDO15_UL_VOLTAGE_CTL1 (at 0x14e6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO15_UL_VOLTAGE_CTL2"
      sgroup "LDO15_UL_VOLTAGE_CTL2 (at 0x14e6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804e6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO15_SEC_ACCESS"
      sgroup "LDO15_SEC_ACCESS (at 0x14ed0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO15_PERPH_RESET_CTL1"
      sgroup "LDO15_PERPH_RESET_CTL1 (at 0x14ed8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO15_PERPH_RESET_CTL2"
      sgroup "LDO15_PERPH_RESET_CTL2 (at 0x14ed9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO15_PERPH_RESET_CTL3"
      sgroup "LDO15_PERPH_RESET_CTL3 (at 0x14eda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO15_PERPH_RESET_CTL4"
      sgroup "LDO15_PERPH_RESET_CTL4 (at 0x14edb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO15_INT_TEST1"
      sgroup "LDO15_INT_TEST1 (at 0x14ee0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO15_INT_TEST_VAL"
      sgroup "LDO15_INT_TEST_VAL (at 0x14ee1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO15_TEST1"
      sgroup "LDO15_TEST1 (at 0x14ee2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO15_TEST2"
      sgroup "LDO15_TEST2 (at 0x14ee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO15_TRIM_NUM"
      sgroup "LDO15_TRIM_NUM (at 0x14ef0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ef00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO15_TRIM_CTRL"
      sgroup "LDO15_TRIM_CTRL (at 0x14ef1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        set &access:&cmd_addr %l 0x804ef10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO16"
  tree "LDO16"
    tree "LDO16_REVISION1"
      sgroup "LDO16_REVISION1 (at 0x14f00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO16_REVISION2"
      sgroup "LDO16_REVISION2 (at 0x14f01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO16_REVISION3"
      sgroup "LDO16_REVISION3 (at 0x14f02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO16_REVISION4"
      sgroup "LDO16_REVISION4 (at 0x14f03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO16_PERPH_TYPE"
      sgroup "LDO16_PERPH_TYPE (at 0x14f04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO16_PERPH_SUBTYPE"
      sgroup "LDO16_PERPH_SUBTYPE (at 0x14f05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO16_STATUS1"
      sgroup "LDO16_STATUS1 (at 0x14f08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO16_STATUS2"
      sgroup "LDO16_STATUS2 (at 0x14f09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO16_STATUS3"
      sgroup "LDO16_STATUS3 (at 0x14f0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO16_INT_RT_STS"
      sgroup "LDO16_INT_RT_STS (at 0x14f10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO16_INT_SET_TYPE"
      sgroup "LDO16_INT_SET_TYPE (at 0x14f11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO16_INT_POLARITY_HIGH"
      sgroup "LDO16_INT_POLARITY_HIGH (at 0x14f12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO16_INT_POLARITY_LOW"
      sgroup "LDO16_INT_POLARITY_LOW (at 0x14f13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO16_INT_LATCHED_CLR"
      sgroup "LDO16_INT_LATCHED_CLR (at 0x14f14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO16_INT_EN_SET"
      sgroup "LDO16_INT_EN_SET (at 0x14f15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO16_INT_EN_CLR"
      sgroup "LDO16_INT_EN_CLR (at 0x14f16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO16_INT_LATCHED_STS"
      sgroup "LDO16_INT_LATCHED_STS (at 0x14f18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO16_INT_PENDING_STS"
      sgroup "LDO16_INT_PENDING_STS (at 0x14f19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO16_INT_MID_SEL"
      sgroup "LDO16_INT_MID_SEL (at 0x14f1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO16_INT_PRIORITY"
      sgroup "LDO16_INT_PRIORITY (at 0x14f1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO16_VOLTAGE_CTL1"
      sgroup "LDO16_VOLTAGE_CTL1 (at 0x14f40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_VOLTAGE_CTL2"
      sgroup "LDO16_VOLTAGE_CTL2 (at 0x14f41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO16_MODE_CTL2"
      sgroup "LDO16_MODE_CTL2 (at 0x14f45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO16_EN_CTL"
      sgroup "LDO16_EN_CTL (at 0x14f46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO16_PD_CTL"
      sgroup "LDO16_PD_CTL (at 0x14f48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO16_CURRENT_LIM_CTL"
      sgroup "LDO16_CURRENT_LIM_CTL (at 0x14f4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO16_SOFT_START_CTL"
      sgroup "LDO16_SOFT_START_CTL (at 0x14f4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO16_CONFIG_CTL"
      sgroup "LDO16_CONFIG_CTL (at 0x14f52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL1"
      sgroup "LDO16_LL_VOLTAGE_CTL1 (at 0x14f68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_LL_VOLTAGE_CTL2"
      sgroup "LDO16_LL_VOLTAGE_CTL2 (at 0x14f69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL1"
      sgroup "LDO16_UL_VOLTAGE_CTL1 (at 0x14f6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO16_UL_VOLTAGE_CTL2"
      sgroup "LDO16_UL_VOLTAGE_CTL2 (at 0x14f6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804f6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4f6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO16_SEC_ACCESS"
      sgroup "LDO16_SEC_ACCESS (at 0x14fd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO16_PERPH_RESET_CTL1"
      sgroup "LDO16_PERPH_RESET_CTL1 (at 0x14fd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO16_PERPH_RESET_CTL2"
      sgroup "LDO16_PERPH_RESET_CTL2 (at 0x14fd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO16_PERPH_RESET_CTL3"
      sgroup "LDO16_PERPH_RESET_CTL3 (at 0x14fda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO16_PERPH_RESET_CTL4"
      sgroup "LDO16_PERPH_RESET_CTL4 (at 0x14fdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO16_INT_TEST1"
      sgroup "LDO16_INT_TEST1 (at 0x14fe0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO16_INT_TEST_VAL"
      sgroup "LDO16_INT_TEST_VAL (at 0x14fe1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO16_TEST1"
      sgroup "LDO16_TEST1 (at 0x14fe2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO16_TEST2"
      sgroup "LDO16_TEST2 (at 0x14fe3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804fe30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4fe30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO16_TRIM_NUM"
      sgroup "LDO16_TRIM_NUM (at 0x14ff0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804ff00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ff00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO16_TRIM_CTRL"
      sgroup "LDO16_TRIM_CTRL (at 0x14ff1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        set &access:&cmd_addr %l 0x804ff10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ff10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO17"
  tree "LDO17"
    tree "LDO17_REVISION1"
      sgroup "LDO17_REVISION1 (at 0x15000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO17_REVISION2"
      sgroup "LDO17_REVISION2 (at 0x15001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO17_REVISION3"
      sgroup "LDO17_REVISION3 (at 0x15002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO17_REVISION4"
      sgroup "LDO17_REVISION4 (at 0x15003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO17_PERPH_TYPE"
      sgroup "LDO17_PERPH_TYPE (at 0x15004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO17_PERPH_SUBTYPE"
      sgroup "LDO17_PERPH_SUBTYPE (at 0x15005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO17_STATUS1"
      sgroup "LDO17_STATUS1 (at 0x15008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO17_STATUS2"
      sgroup "LDO17_STATUS2 (at 0x15009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO17_STATUS3"
      sgroup "LDO17_STATUS3 (at 0x1500a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80500a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x500a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO17_INT_RT_STS"
      sgroup "LDO17_INT_RT_STS (at 0x15010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO17_INT_SET_TYPE"
      sgroup "LDO17_INT_SET_TYPE (at 0x15011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO17_INT_POLARITY_HIGH"
      sgroup "LDO17_INT_POLARITY_HIGH (at 0x15012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO17_INT_POLARITY_LOW"
      sgroup "LDO17_INT_POLARITY_LOW (at 0x15013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO17_INT_LATCHED_CLR"
      sgroup "LDO17_INT_LATCHED_CLR (at 0x15014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO17_INT_EN_SET"
      sgroup "LDO17_INT_EN_SET (at 0x15015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO17_INT_EN_CLR"
      sgroup "LDO17_INT_EN_CLR (at 0x15016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO17_INT_LATCHED_STS"
      sgroup "LDO17_INT_LATCHED_STS (at 0x15018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO17_INT_PENDING_STS"
      sgroup "LDO17_INT_PENDING_STS (at 0x15019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO17_INT_MID_SEL"
      sgroup "LDO17_INT_MID_SEL (at 0x1501a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80501a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x501a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO17_INT_PRIORITY"
      sgroup "LDO17_INT_PRIORITY (at 0x1501b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80501b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x501b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO17_VOLTAGE_CTL1"
      sgroup "LDO17_VOLTAGE_CTL1 (at 0x15040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO17_VOLTAGE_CTL2"
      sgroup "LDO17_VOLTAGE_CTL2 (at 0x15041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO17_MODE_CTL2"
      sgroup "LDO17_MODE_CTL2 (at 0x15045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO17_EN_CTL"
      sgroup "LDO17_EN_CTL (at 0x15046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO17_PD_CTL"
      sgroup "LDO17_PD_CTL (at 0x15048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO17_CURRENT_LIM_CTL"
      sgroup "LDO17_CURRENT_LIM_CTL (at 0x1504a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO17_SOFT_START_CTL"
      sgroup "LDO17_SOFT_START_CTL (at 0x1504c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO17_CONFIG_CTL"
      sgroup "LDO17_CONFIG_CTL (at 0x15052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO17_LL_VOLTAGE_CTL1"
      sgroup "LDO17_LL_VOLTAGE_CTL1 (at 0x15068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO17_LL_VOLTAGE_CTL2"
      sgroup "LDO17_LL_VOLTAGE_CTL2 (at 0x15069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO17_UL_VOLTAGE_CTL1"
      sgroup "LDO17_UL_VOLTAGE_CTL1 (at 0x1506a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80506a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x506a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO17_UL_VOLTAGE_CTL2"
      sgroup "LDO17_UL_VOLTAGE_CTL2 (at 0x1506b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80506b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x506b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO17_SEC_ACCESS"
      sgroup "LDO17_SEC_ACCESS (at 0x150d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO17_PERPH_RESET_CTL1"
      sgroup "LDO17_PERPH_RESET_CTL1 (at 0x150d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO17_PERPH_RESET_CTL2"
      sgroup "LDO17_PERPH_RESET_CTL2 (at 0x150d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO17_PERPH_RESET_CTL3"
      sgroup "LDO17_PERPH_RESET_CTL3 (at 0x150da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO17_PERPH_RESET_CTL4"
      sgroup "LDO17_PERPH_RESET_CTL4 (at 0x150db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO17_INT_TEST1"
      sgroup "LDO17_INT_TEST1 (at 0x150e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO17_INT_TEST_VAL"
      sgroup "LDO17_INT_TEST_VAL (at 0x150e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO17_TEST1"
      sgroup "LDO17_TEST1 (at 0x150e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO17_TEST2"
      sgroup "LDO17_TEST2 (at 0x150e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO17_TRIM_NUM"
      sgroup "LDO17_TRIM_NUM (at 0x150f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO17_TRIM_CTRL"
      sgroup "LDO17_TRIM_CTRL (at 0x150f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO18"
  tree "LDO18"
    tree "LDO18_REVISION1"
      sgroup "LDO18_REVISION1 (at 0x15100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO18_REVISION2"
      sgroup "LDO18_REVISION2 (at 0x15101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO18_REVISION3"
      sgroup "LDO18_REVISION3 (at 0x15102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO18_REVISION4"
      sgroup "LDO18_REVISION4 (at 0x15103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO18_PERPH_TYPE"
      sgroup "LDO18_PERPH_TYPE (at 0x15104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO18_PERPH_SUBTYPE"
      sgroup "LDO18_PERPH_SUBTYPE (at 0x15105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO18_STATUS1"
      sgroup "LDO18_STATUS1 (at 0x15108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO18_STATUS2"
      sgroup "LDO18_STATUS2 (at 0x15109)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO18_STATUS3"
      sgroup "LDO18_STATUS3 (at 0x1510a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80510a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x510a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO18_INT_RT_STS"
      sgroup "LDO18_INT_RT_STS (at 0x15110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO18_INT_SET_TYPE"
      sgroup "LDO18_INT_SET_TYPE (at 0x15111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO18_INT_POLARITY_HIGH"
      sgroup "LDO18_INT_POLARITY_HIGH (at 0x15112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO18_INT_POLARITY_LOW"
      sgroup "LDO18_INT_POLARITY_LOW (at 0x15113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO18_INT_LATCHED_CLR"
      sgroup "LDO18_INT_LATCHED_CLR (at 0x15114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO18_INT_EN_SET"
      sgroup "LDO18_INT_EN_SET (at 0x15115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO18_INT_EN_CLR"
      sgroup "LDO18_INT_EN_CLR (at 0x15116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO18_INT_LATCHED_STS"
      sgroup "LDO18_INT_LATCHED_STS (at 0x15118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO18_INT_PENDING_STS"
      sgroup "LDO18_INT_PENDING_STS (at 0x15119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO18_INT_MID_SEL"
      sgroup "LDO18_INT_MID_SEL (at 0x1511a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80511a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x511a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO18_INT_PRIORITY"
      sgroup "LDO18_INT_PRIORITY (at 0x1511b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80511b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x511b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO18_VOLTAGE_CTL1"
      sgroup "LDO18_VOLTAGE_CTL1 (at 0x15140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO18_VOLTAGE_CTL2"
      sgroup "LDO18_VOLTAGE_CTL2 (at 0x15141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO18_MODE_CTL2"
      sgroup "LDO18_MODE_CTL2 (at 0x15145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO18_EN_CTL"
      sgroup "LDO18_EN_CTL (at 0x15146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO18_PD_CTL"
      sgroup "LDO18_PD_CTL (at 0x15148)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO18_CURRENT_LIM_CTL"
      sgroup "LDO18_CURRENT_LIM_CTL (at 0x1514a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80514a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x514a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO18_SOFT_START_CTL"
      sgroup "LDO18_SOFT_START_CTL (at 0x1514c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80514c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x514c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO18_CONFIG_CTL"
      sgroup "LDO18_CONFIG_CTL (at 0x15152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO18_LL_VOLTAGE_CTL1"
      sgroup "LDO18_LL_VOLTAGE_CTL1 (at 0x15168)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO18_LL_VOLTAGE_CTL2"
      sgroup "LDO18_LL_VOLTAGE_CTL2 (at 0x15169)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO18_UL_VOLTAGE_CTL1"
      sgroup "LDO18_UL_VOLTAGE_CTL1 (at 0x1516a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80516a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x516a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO18_UL_VOLTAGE_CTL2"
      sgroup "LDO18_UL_VOLTAGE_CTL2 (at 0x1516b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x80516b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x516b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO18_SEC_ACCESS"
      sgroup "LDO18_SEC_ACCESS (at 0x151d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO18_PERPH_RESET_CTL1"
      sgroup "LDO18_PERPH_RESET_CTL1 (at 0x151d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO18_PERPH_RESET_CTL2"
      sgroup "LDO18_PERPH_RESET_CTL2 (at 0x151d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO18_PERPH_RESET_CTL3"
      sgroup "LDO18_PERPH_RESET_CTL3 (at 0x151da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO18_PERPH_RESET_CTL4"
      sgroup "LDO18_PERPH_RESET_CTL4 (at 0x151db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO18_INT_TEST1"
      sgroup "LDO18_INT_TEST1 (at 0x151e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO18_INT_TEST_VAL"
      sgroup "LDO18_INT_TEST_VAL (at 0x151e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO18_TEST1"
      sgroup "LDO18_TEST1 (at 0x151e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO18_TEST2"
      sgroup "LDO18_TEST2 (at 0x151e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO18_TRIM_NUM"
      sgroup "LDO18_TRIM_NUM (at 0x151f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO18_TRIM_CTRL"
      sgroup "LDO18_TRIM_CTRL (at 0x151f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        set &access:&cmd_addr %l 0x8051f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x51f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO19"
  tree "LDO19"
    tree "LDO19_REVISION1"
      sgroup "LDO19_REVISION1 (at 0x15200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO19_REVISION2"
      sgroup "LDO19_REVISION2 (at 0x15201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO19_REVISION3"
      sgroup "LDO19_REVISION3 (at 0x15202)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO19_REVISION4"
      sgroup "LDO19_REVISION4 (at 0x15203)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO19_PERPH_TYPE"
      sgroup "LDO19_PERPH_TYPE (at 0x15204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO19_PERPH_SUBTYPE"
      sgroup "LDO19_PERPH_SUBTYPE (at 0x15205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO19_STATUS1"
      sgroup "LDO19_STATUS1 (at 0x15208)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO19_STATUS2"
      sgroup "LDO19_STATUS2 (at 0x15209)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO19_STATUS3"
      sgroup "LDO19_STATUS3 (at 0x1520a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x80520a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x520a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO19_INT_RT_STS"
      sgroup "LDO19_INT_RT_STS (at 0x15210)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO19_INT_SET_TYPE"
      sgroup "LDO19_INT_SET_TYPE (at 0x15211)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO19_INT_POLARITY_HIGH"
      sgroup "LDO19_INT_POLARITY_HIGH (at 0x15212)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO19_INT_POLARITY_LOW"
      sgroup "LDO19_INT_POLARITY_LOW (at 0x15213)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO19_INT_LATCHED_CLR"
      sgroup "LDO19_INT_LATCHED_CLR (at 0x15214)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO19_INT_EN_SET"
      sgroup "LDO19_INT_EN_SET (at 0x15215)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO19_INT_EN_CLR"
      sgroup "LDO19_INT_EN_CLR (at 0x15216)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO19_INT_LATCHED_STS"
      sgroup "LDO19_INT_LATCHED_STS (at 0x15218)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO19_INT_PENDING_STS"
      sgroup "LDO19_INT_PENDING_STS (at 0x15219)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO19_INT_MID_SEL"
      sgroup "LDO19_INT_MID_SEL (at 0x1521a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x80521a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x521a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO19_INT_PRIORITY"
      sgroup "LDO19_INT_PRIORITY (at 0x1521b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x80521b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x521b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO19_VOLTAGE_CTL1"
      sgroup "LDO19_VOLTAGE_CTL1 (at 0x15240)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO19_VOLTAGE_CTL2"
      sgroup "LDO19_VOLTAGE_CTL2 (at 0x15241)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO19_MODE_CTL2"
      sgroup "LDO19_MODE_CTL2 (at 0x15245)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO19_EN_CTL"
      sgroup "LDO19_EN_CTL (at 0x15246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO19_PD_CTL"
      sgroup "LDO19_PD_CTL (at 0x15248)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO19_CURRENT_LIM_CTL"
      sgroup "LDO19_CURRENT_LIM_CTL (at 0x1524a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x80524a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x524a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO19_SOFT_START_CTL"
      sgroup "LDO19_SOFT_START_CTL (at 0x1524c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x80524c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x524c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO19_CONFIG_CTL"
      sgroup "LDO19_CONFIG_CTL (at 0x15252)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO19_LL_VOLTAGE_CTL1"
      sgroup "LDO19_LL_VOLTAGE_CTL1 (at 0x15268)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO19_LL_VOLTAGE_CTL2"
      sgroup "LDO19_LL_VOLTAGE_CTL2 (at 0x15269)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO19_UL_VOLTAGE_CTL1"
      sgroup "LDO19_UL_VOLTAGE_CTL1 (at 0x1526a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x80526a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x526a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO19_UL_VOLTAGE_CTL2"
      sgroup "LDO19_UL_VOLTAGE_CTL2 (at 0x1526b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x80526b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x526b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO19_SEC_ACCESS"
      sgroup "LDO19_SEC_ACCESS (at 0x152d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO19_PERPH_RESET_CTL1"
      sgroup "LDO19_PERPH_RESET_CTL1 (at 0x152d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO19_PERPH_RESET_CTL2"
      sgroup "LDO19_PERPH_RESET_CTL2 (at 0x152d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO19_PERPH_RESET_CTL3"
      sgroup "LDO19_PERPH_RESET_CTL3 (at 0x152da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO19_PERPH_RESET_CTL4"
      sgroup "LDO19_PERPH_RESET_CTL4 (at 0x152db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO19_INT_TEST1"
      sgroup "LDO19_INT_TEST1 (at 0x152e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO19_INT_TEST_VAL"
      sgroup "LDO19_INT_TEST_VAL (at 0x152e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO19_TEST1"
      sgroup "LDO19_TEST1 (at 0x152e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO19_TEST2"
      sgroup "LDO19_TEST2 (at 0x152e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO19_TRIM_NUM"
      sgroup "LDO19_TRIM_NUM (at 0x152f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO19_TRIM_CTRL"
      sgroup "LDO19_TRIM_CTRL (at 0x152f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        set &access:&cmd_addr %l 0x8052f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x52f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO2"
  tree "LDO2"
    tree "LDO2_REVISION1"
      sgroup "LDO2_REVISION1 (at 0x14100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO2_REVISION2"
      sgroup "LDO2_REVISION2 (at 0x14101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO2_REVISION3"
      sgroup "LDO2_REVISION3 (at 0x14102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO2_REVISION4"
      sgroup "LDO2_REVISION4 (at 0x14103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO2_PERPH_TYPE"
      sgroup "LDO2_PERPH_TYPE (at 0x14104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO2_PERPH_SUBTYPE"
      sgroup "LDO2_PERPH_SUBTYPE (at 0x14105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO2_STATUS1"
      sgroup "LDO2_STATUS1 (at 0x14108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "LDO2_STATUS2"
      sgroup "LDO2_STATUS2 (at 0x14109)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO2_STATUS3"
      sgroup "LDO2_STATUS3 (at 0x1410a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80410a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x410a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO2_INT_RT_STS"
      sgroup "LDO2_INT_RT_STS (at 0x14110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO2_INT_SET_TYPE"
      sgroup "LDO2_INT_SET_TYPE (at 0x14111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO2_INT_POLARITY_HIGH"
      sgroup "LDO2_INT_POLARITY_HIGH (at 0x14112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO2_INT_POLARITY_LOW"
      sgroup "LDO2_INT_POLARITY_LOW (at 0x14113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO2_INT_LATCHED_CLR"
      sgroup "LDO2_INT_LATCHED_CLR (at 0x14114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO2_INT_EN_SET"
      sgroup "LDO2_INT_EN_SET (at 0x14115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO2_INT_EN_CLR"
      sgroup "LDO2_INT_EN_CLR (at 0x14116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO2_INT_LATCHED_STS"
      sgroup "LDO2_INT_LATCHED_STS (at 0x14118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO2_INT_PENDING_STS"
      sgroup "LDO2_INT_PENDING_STS (at 0x14119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO2_INT_MID_SEL"
      sgroup "LDO2_INT_MID_SEL (at 0x1411a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO2_INT_PRIORITY"
      sgroup "LDO2_INT_PRIORITY (at 0x1411b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO2_VOLTAGE_CTL1"
      sgroup "LDO2_VOLTAGE_CTL1 (at 0x14140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_VOLTAGE_CTL2"
      sgroup "LDO2_VOLTAGE_CTL2 (at 0x14141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO2_MODE_CTL2"
      sgroup "LDO2_MODE_CTL2 (at 0x14145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO2_EN_CTL"
      sgroup "LDO2_EN_CTL (at 0x14146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO2_PD_CTL"
      sgroup "LDO2_PD_CTL (at 0x14148)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO2_CURRENT_LIM_CTL"
      sgroup "LDO2_CURRENT_LIM_CTL (at 0x1414a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80414a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x414a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO2_SOFT_START_CTL"
      sgroup "LDO2_SOFT_START_CTL (at 0x1414c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80414c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x414c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO2_CONFIG_CTL"
      sgroup "LDO2_CONFIG_CTL (at 0x14152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO2_VS_CTL"
      sgroup "LDO2_VS_CTL (at 0x14161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL1"
      sgroup "LDO2_LL_VOLTAGE_CTL1 (at 0x14168)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_LL_VOLTAGE_CTL2"
      sgroup "LDO2_LL_VOLTAGE_CTL2 (at 0x14169)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL1"
      sgroup "LDO2_UL_VOLTAGE_CTL1 (at 0x1416a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80416a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x416a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO2_UL_VOLTAGE_CTL2"
      sgroup "LDO2_UL_VOLTAGE_CTL2 (at 0x1416b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80416b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x416b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO2_SEC_ACCESS"
      sgroup "LDO2_SEC_ACCESS (at 0x141d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO2_PERPH_RESET_CTL1"
      sgroup "LDO2_PERPH_RESET_CTL1 (at 0x141d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO2_PERPH_RESET_CTL2"
      sgroup "LDO2_PERPH_RESET_CTL2 (at 0x141d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO2_PERPH_RESET_CTL3"
      sgroup "LDO2_PERPH_RESET_CTL3 (at 0x141da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO2_PERPH_RESET_CTL4"
      sgroup "LDO2_PERPH_RESET_CTL4 (at 0x141db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO2_INT_TEST1"
      sgroup "LDO2_INT_TEST1 (at 0x141e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO2_INT_TEST_VAL"
      sgroup "LDO2_INT_TEST_VAL (at 0x141e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO2_TEST1"
      sgroup "LDO2_TEST1 (at 0x141e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO2_TEST2"
      sgroup "LDO2_TEST2 (at 0x141e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO2_TRIM_NUM"
      sgroup "LDO2_TRIM_NUM (at 0x141f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO2_TRIM_CTRL"
      sgroup "LDO2_TRIM_CTRL (at 0x141f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO20"
  tree "LDO20"
    tree "LDO20_REVISION1"
      sgroup "LDO20_REVISION1 (at 0x15300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO20_REVISION2"
      sgroup "LDO20_REVISION2 (at 0x15301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO20_REVISION3"
      sgroup "LDO20_REVISION3 (at 0x15302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO20_REVISION4"
      sgroup "LDO20_REVISION4 (at 0x15303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO20_PERPH_TYPE"
      sgroup "LDO20_PERPH_TYPE (at 0x15304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO20_PERPH_SUBTYPE"
      sgroup "LDO20_PERPH_SUBTYPE (at 0x15305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO20_STATUS1"
      sgroup "LDO20_STATUS1 (at 0x15308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO20_STATUS2"
      sgroup "LDO20_STATUS2 (at 0x15309)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO20_STATUS3"
      sgroup "LDO20_STATUS3 (at 0x1530a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x80530a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x530a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO20_INT_RT_STS"
      sgroup "LDO20_INT_RT_STS (at 0x15310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO20_INT_SET_TYPE"
      sgroup "LDO20_INT_SET_TYPE (at 0x15311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO20_INT_POLARITY_HIGH"
      sgroup "LDO20_INT_POLARITY_HIGH (at 0x15312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO20_INT_POLARITY_LOW"
      sgroup "LDO20_INT_POLARITY_LOW (at 0x15313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO20_INT_LATCHED_CLR"
      sgroup "LDO20_INT_LATCHED_CLR (at 0x15314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO20_INT_EN_SET"
      sgroup "LDO20_INT_EN_SET (at 0x15315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO20_INT_EN_CLR"
      sgroup "LDO20_INT_EN_CLR (at 0x15316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO20_INT_LATCHED_STS"
      sgroup "LDO20_INT_LATCHED_STS (at 0x15318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO20_INT_PENDING_STS"
      sgroup "LDO20_INT_PENDING_STS (at 0x15319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO20_INT_MID_SEL"
      sgroup "LDO20_INT_MID_SEL (at 0x1531a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x80531a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x531a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO20_INT_PRIORITY"
      sgroup "LDO20_INT_PRIORITY (at 0x1531b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x80531b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x531b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO20_VOLTAGE_CTL1"
      sgroup "LDO20_VOLTAGE_CTL1 (at 0x15340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO20_VOLTAGE_CTL2"
      sgroup "LDO20_VOLTAGE_CTL2 (at 0x15341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO20_MODE_CTL2"
      sgroup "LDO20_MODE_CTL2 (at 0x15345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO20_EN_CTL"
      sgroup "LDO20_EN_CTL (at 0x15346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO20_PD_CTL"
      sgroup "LDO20_PD_CTL (at 0x15348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO20_CURRENT_LIM_CTL"
      sgroup "LDO20_CURRENT_LIM_CTL (at 0x1534a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x80534a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x534a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO20_SOFT_START_CTL"
      sgroup "LDO20_SOFT_START_CTL (at 0x1534c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x80534c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x534c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO20_CONFIG_CTL"
      sgroup "LDO20_CONFIG_CTL (at 0x15352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO20_LL_VOLTAGE_CTL1"
      sgroup "LDO20_LL_VOLTAGE_CTL1 (at 0x15368)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO20_LL_VOLTAGE_CTL2"
      sgroup "LDO20_LL_VOLTAGE_CTL2 (at 0x15369)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO20_UL_VOLTAGE_CTL1"
      sgroup "LDO20_UL_VOLTAGE_CTL1 (at 0x1536a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x80536a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x536a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO20_UL_VOLTAGE_CTL2"
      sgroup "LDO20_UL_VOLTAGE_CTL2 (at 0x1536b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x80536b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x536b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO20_SEC_ACCESS"
      sgroup "LDO20_SEC_ACCESS (at 0x153d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO20_PERPH_RESET_CTL1"
      sgroup "LDO20_PERPH_RESET_CTL1 (at 0x153d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO20_PERPH_RESET_CTL2"
      sgroup "LDO20_PERPH_RESET_CTL2 (at 0x153d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO20_PERPH_RESET_CTL3"
      sgroup "LDO20_PERPH_RESET_CTL3 (at 0x153da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO20_PERPH_RESET_CTL4"
      sgroup "LDO20_PERPH_RESET_CTL4 (at 0x153db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO20_INT_TEST1"
      sgroup "LDO20_INT_TEST1 (at 0x153e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO20_INT_TEST_VAL"
      sgroup "LDO20_INT_TEST_VAL (at 0x153e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO20_TEST1"
      sgroup "LDO20_TEST1 (at 0x153e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO20_TEST2"
      sgroup "LDO20_TEST2 (at 0x153e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO20_TRIM_NUM"
      sgroup "LDO20_TRIM_NUM (at 0x153f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO20_TRIM_CTRL"
      sgroup "LDO20_TRIM_CTRL (at 0x153f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        set &access:&cmd_addr %l 0x8053f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x53f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO21"
  tree "LDO21"
    tree "LDO21_REVISION1"
      sgroup "LDO21_REVISION1 (at 0x15400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO21_REVISION2"
      sgroup "LDO21_REVISION2 (at 0x15401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO21_REVISION3"
      sgroup "LDO21_REVISION3 (at 0x15402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO21_REVISION4"
      sgroup "LDO21_REVISION4 (at 0x15403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO21_PERPH_TYPE"
      sgroup "LDO21_PERPH_TYPE (at 0x15404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO21_PERPH_SUBTYPE"
      sgroup "LDO21_PERPH_SUBTYPE (at 0x15405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO21_STATUS1"
      sgroup "LDO21_STATUS1 (at 0x15408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO21_STATUS2"
      sgroup "LDO21_STATUS2 (at 0x15409)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO21_STATUS3"
      sgroup "LDO21_STATUS3 (at 0x1540a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80540a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x540a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO21_INT_RT_STS"
      sgroup "LDO21_INT_RT_STS (at 0x15410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO21_INT_SET_TYPE"
      sgroup "LDO21_INT_SET_TYPE (at 0x15411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO21_INT_POLARITY_HIGH"
      sgroup "LDO21_INT_POLARITY_HIGH (at 0x15412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO21_INT_POLARITY_LOW"
      sgroup "LDO21_INT_POLARITY_LOW (at 0x15413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO21_INT_LATCHED_CLR"
      sgroup "LDO21_INT_LATCHED_CLR (at 0x15414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO21_INT_EN_SET"
      sgroup "LDO21_INT_EN_SET (at 0x15415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO21_INT_EN_CLR"
      sgroup "LDO21_INT_EN_CLR (at 0x15416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO21_INT_LATCHED_STS"
      sgroup "LDO21_INT_LATCHED_STS (at 0x15418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO21_INT_PENDING_STS"
      sgroup "LDO21_INT_PENDING_STS (at 0x15419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO21_INT_MID_SEL"
      sgroup "LDO21_INT_MID_SEL (at 0x1541a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80541a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x541a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO21_INT_PRIORITY"
      sgroup "LDO21_INT_PRIORITY (at 0x1541b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80541b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x541b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO21_VOLTAGE_CTL1"
      sgroup "LDO21_VOLTAGE_CTL1 (at 0x15440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO21_VOLTAGE_CTL2"
      sgroup "LDO21_VOLTAGE_CTL2 (at 0x15441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO21_MODE_CTL2"
      sgroup "LDO21_MODE_CTL2 (at 0x15445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO21_EN_CTL"
      sgroup "LDO21_EN_CTL (at 0x15446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO21_PD_CTL"
      sgroup "LDO21_PD_CTL (at 0x15448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO21_CURRENT_LIM_CTL"
      sgroup "LDO21_CURRENT_LIM_CTL (at 0x1544a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80544a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x544a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO21_SOFT_START_CTL"
      sgroup "LDO21_SOFT_START_CTL (at 0x1544c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80544c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x544c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO21_CONFIG_CTL"
      sgroup "LDO21_CONFIG_CTL (at 0x15452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO21_LL_VOLTAGE_CTL1"
      sgroup "LDO21_LL_VOLTAGE_CTL1 (at 0x15468)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO21_LL_VOLTAGE_CTL2"
      sgroup "LDO21_LL_VOLTAGE_CTL2 (at 0x15469)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO21_UL_VOLTAGE_CTL1"
      sgroup "LDO21_UL_VOLTAGE_CTL1 (at 0x1546a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80546a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x546a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO21_UL_VOLTAGE_CTL2"
      sgroup "LDO21_UL_VOLTAGE_CTL2 (at 0x1546b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80546b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x546b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO21_SEC_ACCESS"
      sgroup "LDO21_SEC_ACCESS (at 0x154d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO21_PERPH_RESET_CTL1"
      sgroup "LDO21_PERPH_RESET_CTL1 (at 0x154d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO21_PERPH_RESET_CTL2"
      sgroup "LDO21_PERPH_RESET_CTL2 (at 0x154d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO21_PERPH_RESET_CTL3"
      sgroup "LDO21_PERPH_RESET_CTL3 (at 0x154da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO21_PERPH_RESET_CTL4"
      sgroup "LDO21_PERPH_RESET_CTL4 (at 0x154db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO21_INT_TEST1"
      sgroup "LDO21_INT_TEST1 (at 0x154e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO21_INT_TEST_VAL"
      sgroup "LDO21_INT_TEST_VAL (at 0x154e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO21_TEST1"
      sgroup "LDO21_TEST1 (at 0x154e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO21_TEST2"
      sgroup "LDO21_TEST2 (at 0x154e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO21_TRIM_NUM"
      sgroup "LDO21_TRIM_NUM (at 0x154f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO21_TRIM_CTRL"
      sgroup "LDO21_TRIM_CTRL (at 0x154f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO22"
  tree "LDO22"
    tree "LDO22_REVISION1"
      sgroup "LDO22_REVISION1 (at 0x15500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO22_REVISION2"
      sgroup "LDO22_REVISION2 (at 0x15501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO22_REVISION3"
      sgroup "LDO22_REVISION3 (at 0x15502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO22_REVISION4"
      sgroup "LDO22_REVISION4 (at 0x15503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO22_PERPH_TYPE"
      sgroup "LDO22_PERPH_TYPE (at 0x15504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO22_PERPH_SUBTYPE"
      sgroup "LDO22_PERPH_SUBTYPE (at 0x15505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO22_STATUS1"
      sgroup "LDO22_STATUS1 (at 0x15508)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO22_STATUS2"
      sgroup "LDO22_STATUS2 (at 0x15509)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO22_STATUS3"
      sgroup "LDO22_STATUS3 (at 0x1550a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80550a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x550a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO22_INT_RT_STS"
      sgroup "LDO22_INT_RT_STS (at 0x15510)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO22_INT_SET_TYPE"
      sgroup "LDO22_INT_SET_TYPE (at 0x15511)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO22_INT_POLARITY_HIGH"
      sgroup "LDO22_INT_POLARITY_HIGH (at 0x15512)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO22_INT_POLARITY_LOW"
      sgroup "LDO22_INT_POLARITY_LOW (at 0x15513)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO22_INT_LATCHED_CLR"
      sgroup "LDO22_INT_LATCHED_CLR (at 0x15514)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO22_INT_EN_SET"
      sgroup "LDO22_INT_EN_SET (at 0x15515)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO22_INT_EN_CLR"
      sgroup "LDO22_INT_EN_CLR (at 0x15516)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO22_INT_LATCHED_STS"
      sgroup "LDO22_INT_LATCHED_STS (at 0x15518)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO22_INT_PENDING_STS"
      sgroup "LDO22_INT_PENDING_STS (at 0x15519)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO22_INT_MID_SEL"
      sgroup "LDO22_INT_MID_SEL (at 0x1551a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80551a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x551a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO22_INT_PRIORITY"
      sgroup "LDO22_INT_PRIORITY (at 0x1551b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80551b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x551b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO22_VOLTAGE_CTL1"
      sgroup "LDO22_VOLTAGE_CTL1 (at 0x15540)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO22_VOLTAGE_CTL2"
      sgroup "LDO22_VOLTAGE_CTL2 (at 0x15541)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO22_MODE_CTL2"
      sgroup "LDO22_MODE_CTL2 (at 0x15545)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO22_EN_CTL"
      sgroup "LDO22_EN_CTL (at 0x15546)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO22_PD_CTL"
      sgroup "LDO22_PD_CTL (at 0x15548)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO22_CURRENT_LIM_CTL"
      sgroup "LDO22_CURRENT_LIM_CTL (at 0x1554a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80554a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x554a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO22_SOFT_START_CTL"
      sgroup "LDO22_SOFT_START_CTL (at 0x1554c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80554c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x554c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO22_CONFIG_CTL"
      sgroup "LDO22_CONFIG_CTL (at 0x15552)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO22_LL_VOLTAGE_CTL1"
      sgroup "LDO22_LL_VOLTAGE_CTL1 (at 0x15568)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO22_LL_VOLTAGE_CTL2"
      sgroup "LDO22_LL_VOLTAGE_CTL2 (at 0x15569)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO22_UL_VOLTAGE_CTL1"
      sgroup "LDO22_UL_VOLTAGE_CTL1 (at 0x1556a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80556a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x556a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO22_UL_VOLTAGE_CTL2"
      sgroup "LDO22_UL_VOLTAGE_CTL2 (at 0x1556b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80556b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x556b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO22_SEC_ACCESS"
      sgroup "LDO22_SEC_ACCESS (at 0x155d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO22_PERPH_RESET_CTL1"
      sgroup "LDO22_PERPH_RESET_CTL1 (at 0x155d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO22_PERPH_RESET_CTL2"
      sgroup "LDO22_PERPH_RESET_CTL2 (at 0x155d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO22_PERPH_RESET_CTL3"
      sgroup "LDO22_PERPH_RESET_CTL3 (at 0x155da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO22_PERPH_RESET_CTL4"
      sgroup "LDO22_PERPH_RESET_CTL4 (at 0x155db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO22_INT_TEST1"
      sgroup "LDO22_INT_TEST1 (at 0x155e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO22_INT_TEST_VAL"
      sgroup "LDO22_INT_TEST_VAL (at 0x155e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO22_TEST1"
      sgroup "LDO22_TEST1 (at 0x155e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO22_TEST2"
      sgroup "LDO22_TEST2 (at 0x155e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO22_TRIM_NUM"
      sgroup "LDO22_TRIM_NUM (at 0x155f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO22_TRIM_CTRL"
      sgroup "LDO22_TRIM_CTRL (at 0x155f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO23"
  tree "LDO23"
    tree "LDO23_REVISION1"
      sgroup "LDO23_REVISION1 (at 0x15600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO23_REVISION2"
      sgroup "LDO23_REVISION2 (at 0x15601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO23_REVISION3"
      sgroup "LDO23_REVISION3 (at 0x15602)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO23_REVISION4"
      sgroup "LDO23_REVISION4 (at 0x15603)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO23_PERPH_TYPE"
      sgroup "LDO23_PERPH_TYPE (at 0x15604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO23_PERPH_SUBTYPE"
      sgroup "LDO23_PERPH_SUBTYPE (at 0x15605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO23_STATUS1"
      sgroup "LDO23_STATUS1 (at 0x15608)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO23_STATUS2"
      sgroup "LDO23_STATUS2 (at 0x15609)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO23_STATUS3"
      sgroup "LDO23_STATUS3 (at 0x1560a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80560a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x560a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO23_INT_RT_STS"
      sgroup "LDO23_INT_RT_STS (at 0x15610)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO23_INT_SET_TYPE"
      sgroup "LDO23_INT_SET_TYPE (at 0x15611)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO23_INT_POLARITY_HIGH"
      sgroup "LDO23_INT_POLARITY_HIGH (at 0x15612)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO23_INT_POLARITY_LOW"
      sgroup "LDO23_INT_POLARITY_LOW (at 0x15613)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO23_INT_LATCHED_CLR"
      sgroup "LDO23_INT_LATCHED_CLR (at 0x15614)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO23_INT_EN_SET"
      sgroup "LDO23_INT_EN_SET (at 0x15615)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO23_INT_EN_CLR"
      sgroup "LDO23_INT_EN_CLR (at 0x15616)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO23_INT_LATCHED_STS"
      sgroup "LDO23_INT_LATCHED_STS (at 0x15618)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO23_INT_PENDING_STS"
      sgroup "LDO23_INT_PENDING_STS (at 0x15619)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO23_INT_MID_SEL"
      sgroup "LDO23_INT_MID_SEL (at 0x1561a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80561a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x561a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO23_INT_PRIORITY"
      sgroup "LDO23_INT_PRIORITY (at 0x1561b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80561b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x561b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO23_VOLTAGE_CTL1"
      sgroup "LDO23_VOLTAGE_CTL1 (at 0x15640)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO23_VOLTAGE_CTL2"
      sgroup "LDO23_VOLTAGE_CTL2 (at 0x15641)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO23_MODE_CTL2"
      sgroup "LDO23_MODE_CTL2 (at 0x15645)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO23_EN_CTL"
      sgroup "LDO23_EN_CTL (at 0x15646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO23_PD_CTL"
      sgroup "LDO23_PD_CTL (at 0x15648)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO23_CURRENT_LIM_CTL"
      sgroup "LDO23_CURRENT_LIM_CTL (at 0x1564a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80564a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x564a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO23_SOFT_START_CTL"
      sgroup "LDO23_SOFT_START_CTL (at 0x1564c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80564c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x564c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO23_CONFIG_CTL"
      sgroup "LDO23_CONFIG_CTL (at 0x15652)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO23_LL_VOLTAGE_CTL1"
      sgroup "LDO23_LL_VOLTAGE_CTL1 (at 0x15668)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO23_LL_VOLTAGE_CTL2"
      sgroup "LDO23_LL_VOLTAGE_CTL2 (at 0x15669)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO23_UL_VOLTAGE_CTL1"
      sgroup "LDO23_UL_VOLTAGE_CTL1 (at 0x1566a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80566a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x566a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO23_UL_VOLTAGE_CTL2"
      sgroup "LDO23_UL_VOLTAGE_CTL2 (at 0x1566b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80566b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x566b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO23_SEC_ACCESS"
      sgroup "LDO23_SEC_ACCESS (at 0x156d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO23_PERPH_RESET_CTL1"
      sgroup "LDO23_PERPH_RESET_CTL1 (at 0x156d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO23_PERPH_RESET_CTL2"
      sgroup "LDO23_PERPH_RESET_CTL2 (at 0x156d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO23_PERPH_RESET_CTL3"
      sgroup "LDO23_PERPH_RESET_CTL3 (at 0x156da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO23_PERPH_RESET_CTL4"
      sgroup "LDO23_PERPH_RESET_CTL4 (at 0x156db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO23_INT_TEST1"
      sgroup "LDO23_INT_TEST1 (at 0x156e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO23_INT_TEST_VAL"
      sgroup "LDO23_INT_TEST_VAL (at 0x156e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO23_TEST1"
      sgroup "LDO23_TEST1 (at 0x156e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO23_TEST2"
      sgroup "LDO23_TEST2 (at 0x156e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO23_TRIM_NUM"
      sgroup "LDO23_TRIM_NUM (at 0x156f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO23_TRIM_CTRL"
      sgroup "LDO23_TRIM_CTRL (at 0x156f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO24"
  tree "LDO24"
    tree "LDO24_REVISION1"
      sgroup "LDO24_REVISION1 (at 0x15700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO24_REVISION2"
      sgroup "LDO24_REVISION2 (at 0x15701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO24_REVISION3"
      sgroup "LDO24_REVISION3 (at 0x15702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO24_REVISION4"
      sgroup "LDO24_REVISION4 (at 0x15703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO24_PERPH_TYPE"
      sgroup "LDO24_PERPH_TYPE (at 0x15704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO24_PERPH_SUBTYPE"
      sgroup "LDO24_PERPH_SUBTYPE (at 0x15705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO24_STATUS1"
      sgroup "LDO24_STATUS1 (at 0x15708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "LDO24_STATUS2"
      sgroup "LDO24_STATUS2 (at 0x15709)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO24_STATUS3"
      sgroup "LDO24_STATUS3 (at 0x1570a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x80570a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x570a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO24_INT_RT_STS"
      sgroup "LDO24_INT_RT_STS (at 0x15710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO24_INT_SET_TYPE"
      sgroup "LDO24_INT_SET_TYPE (at 0x15711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO24_INT_POLARITY_HIGH"
      sgroup "LDO24_INT_POLARITY_HIGH (at 0x15712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO24_INT_POLARITY_LOW"
      sgroup "LDO24_INT_POLARITY_LOW (at 0x15713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO24_INT_LATCHED_CLR"
      sgroup "LDO24_INT_LATCHED_CLR (at 0x15714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO24_INT_EN_SET"
      sgroup "LDO24_INT_EN_SET (at 0x15715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO24_INT_EN_CLR"
      sgroup "LDO24_INT_EN_CLR (at 0x15716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO24_INT_LATCHED_STS"
      sgroup "LDO24_INT_LATCHED_STS (at 0x15718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO24_INT_PENDING_STS"
      sgroup "LDO24_INT_PENDING_STS (at 0x15719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO24_INT_MID_SEL"
      sgroup "LDO24_INT_MID_SEL (at 0x1571a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x80571a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x571a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO24_INT_PRIORITY"
      sgroup "LDO24_INT_PRIORITY (at 0x1571b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x80571b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x571b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO24_VOLTAGE_CTL1"
      sgroup "LDO24_VOLTAGE_CTL1 (at 0x15740)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO24_VOLTAGE_CTL2"
      sgroup "LDO24_VOLTAGE_CTL2 (at 0x15741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO24_MODE_CTL2"
      sgroup "LDO24_MODE_CTL2 (at 0x15745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO24_EN_CTL"
      sgroup "LDO24_EN_CTL (at 0x15746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO24_PD_CTL"
      sgroup "LDO24_PD_CTL (at 0x15748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO24_CURRENT_LIM_CTL"
      sgroup "LDO24_CURRENT_LIM_CTL (at 0x1574a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x80574a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x574a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO24_SOFT_START_CTL"
      sgroup "LDO24_SOFT_START_CTL (at 0x1574c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x80574c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x574c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO24_CONFIG_CTL"
      sgroup "LDO24_CONFIG_CTL (at 0x15752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO24_VS_CTL"
      sgroup "LDO24_VS_CTL (at 0x15761)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO24_LL_VOLTAGE_CTL1"
      sgroup "LDO24_LL_VOLTAGE_CTL1 (at 0x15768)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO24_LL_VOLTAGE_CTL2"
      sgroup "LDO24_LL_VOLTAGE_CTL2 (at 0x15769)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO24_UL_VOLTAGE_CTL1"
      sgroup "LDO24_UL_VOLTAGE_CTL1 (at 0x1576a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x80576a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x576a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO24_UL_VOLTAGE_CTL2"
      sgroup "LDO24_UL_VOLTAGE_CTL2 (at 0x1576b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x80576b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x576b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO24_SEC_ACCESS"
      sgroup "LDO24_SEC_ACCESS (at 0x157d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO24_PERPH_RESET_CTL1"
      sgroup "LDO24_PERPH_RESET_CTL1 (at 0x157d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO24_PERPH_RESET_CTL2"
      sgroup "LDO24_PERPH_RESET_CTL2 (at 0x157d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO24_PERPH_RESET_CTL3"
      sgroup "LDO24_PERPH_RESET_CTL3 (at 0x157da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO24_PERPH_RESET_CTL4"
      sgroup "LDO24_PERPH_RESET_CTL4 (at 0x157db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO24_INT_TEST1"
      sgroup "LDO24_INT_TEST1 (at 0x157e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO24_INT_TEST_VAL"
      sgroup "LDO24_INT_TEST_VAL (at 0x157e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO24_TEST1"
      sgroup "LDO24_TEST1 (at 0x157e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO24_TEST2"
      sgroup "LDO24_TEST2 (at 0x157e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO24_TRIM_NUM"
      sgroup "LDO24_TRIM_NUM (at 0x157f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO24_TRIM_CTRL"
      sgroup "LDO24_TRIM_CTRL (at 0x157f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        set &access:&cmd_addr %l 0x8057f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x57f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO25"
  tree "LDO25"
    tree "LDO25_REVISION1"
      sgroup "LDO25_REVISION1 (at 0x15800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO25_REVISION2"
      sgroup "LDO25_REVISION2 (at 0x15801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO25_REVISION3"
      sgroup "LDO25_REVISION3 (at 0x15802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO25_REVISION4"
      sgroup "LDO25_REVISION4 (at 0x15803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO25_PERPH_TYPE"
      sgroup "LDO25_PERPH_TYPE (at 0x15804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO25_PERPH_SUBTYPE"
      sgroup "LDO25_PERPH_SUBTYPE (at 0x15805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO25_STATUS1"
      sgroup "LDO25_STATUS1 (at 0x15808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO25_STATUS2"
      sgroup "LDO25_STATUS2 (at 0x15809)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO25_STATUS3"
      sgroup "LDO25_STATUS3 (at 0x1580a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80580a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x580a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO25_INT_RT_STS"
      sgroup "LDO25_INT_RT_STS (at 0x15810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO25_INT_SET_TYPE"
      sgroup "LDO25_INT_SET_TYPE (at 0x15811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO25_INT_POLARITY_HIGH"
      sgroup "LDO25_INT_POLARITY_HIGH (at 0x15812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO25_INT_POLARITY_LOW"
      sgroup "LDO25_INT_POLARITY_LOW (at 0x15813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO25_INT_LATCHED_CLR"
      sgroup "LDO25_INT_LATCHED_CLR (at 0x15814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO25_INT_EN_SET"
      sgroup "LDO25_INT_EN_SET (at 0x15815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO25_INT_EN_CLR"
      sgroup "LDO25_INT_EN_CLR (at 0x15816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO25_INT_LATCHED_STS"
      sgroup "LDO25_INT_LATCHED_STS (at 0x15818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO25_INT_PENDING_STS"
      sgroup "LDO25_INT_PENDING_STS (at 0x15819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO25_INT_MID_SEL"
      sgroup "LDO25_INT_MID_SEL (at 0x1581a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80581a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x581a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO25_INT_PRIORITY"
      sgroup "LDO25_INT_PRIORITY (at 0x1581b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80581b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x581b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO25_VOLTAGE_CTL1"
      sgroup "LDO25_VOLTAGE_CTL1 (at 0x15840)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO25_VOLTAGE_CTL2"
      sgroup "LDO25_VOLTAGE_CTL2 (at 0x15841)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO25_MODE_CTL2"
      sgroup "LDO25_MODE_CTL2 (at 0x15845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO25_EN_CTL"
      sgroup "LDO25_EN_CTL (at 0x15846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO25_PD_CTL"
      sgroup "LDO25_PD_CTL (at 0x15848)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO25_CURRENT_LIM_CTL"
      sgroup "LDO25_CURRENT_LIM_CTL (at 0x1584a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80584a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x584a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO25_SOFT_START_CTL"
      sgroup "LDO25_SOFT_START_CTL (at 0x1584c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80584c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x584c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO25_CONFIG_CTL"
      sgroup "LDO25_CONFIG_CTL (at 0x15852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO25_LL_VOLTAGE_CTL1"
      sgroup "LDO25_LL_VOLTAGE_CTL1 (at 0x15868)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO25_LL_VOLTAGE_CTL2"
      sgroup "LDO25_LL_VOLTAGE_CTL2 (at 0x15869)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO25_UL_VOLTAGE_CTL1"
      sgroup "LDO25_UL_VOLTAGE_CTL1 (at 0x1586a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80586a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x586a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO25_UL_VOLTAGE_CTL2"
      sgroup "LDO25_UL_VOLTAGE_CTL2 (at 0x1586b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80586b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x586b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO25_SEC_ACCESS"
      sgroup "LDO25_SEC_ACCESS (at 0x158d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO25_PERPH_RESET_CTL1"
      sgroup "LDO25_PERPH_RESET_CTL1 (at 0x158d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO25_PERPH_RESET_CTL2"
      sgroup "LDO25_PERPH_RESET_CTL2 (at 0x158d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO25_PERPH_RESET_CTL3"
      sgroup "LDO25_PERPH_RESET_CTL3 (at 0x158da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO25_PERPH_RESET_CTL4"
      sgroup "LDO25_PERPH_RESET_CTL4 (at 0x158db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO25_INT_TEST1"
      sgroup "LDO25_INT_TEST1 (at 0x158e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO25_INT_TEST_VAL"
      sgroup "LDO25_INT_TEST_VAL (at 0x158e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO25_TEST1"
      sgroup "LDO25_TEST1 (at 0x158e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO25_TEST2"
      sgroup "LDO25_TEST2 (at 0x158e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO25_TRIM_NUM"
      sgroup "LDO25_TRIM_NUM (at 0x158f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO25_TRIM_CTRL"
      sgroup "LDO25_TRIM_CTRL (at 0x158f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO26"
  tree "LDO26"
    tree "LDO26_REVISION1"
      sgroup "LDO26_REVISION1 (at 0x15900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO26_REVISION2"
      sgroup "LDO26_REVISION2 (at 0x15901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO26_REVISION3"
      sgroup "LDO26_REVISION3 (at 0x15902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO26_REVISION4"
      sgroup "LDO26_REVISION4 (at 0x15903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO26_PERPH_TYPE"
      sgroup "LDO26_PERPH_TYPE (at 0x15904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO26_PERPH_SUBTYPE"
      sgroup "LDO26_PERPH_SUBTYPE (at 0x15905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO26_STATUS1"
      sgroup "LDO26_STATUS1 (at 0x15908)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "LDO26_STATUS2"
      sgroup "LDO26_STATUS2 (at 0x15909)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO26_STATUS3"
      sgroup "LDO26_STATUS3 (at 0x1590a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80590a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x590a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO26_INT_RT_STS"
      sgroup "LDO26_INT_RT_STS (at 0x15910)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO26_INT_SET_TYPE"
      sgroup "LDO26_INT_SET_TYPE (at 0x15911)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO26_INT_POLARITY_HIGH"
      sgroup "LDO26_INT_POLARITY_HIGH (at 0x15912)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO26_INT_POLARITY_LOW"
      sgroup "LDO26_INT_POLARITY_LOW (at 0x15913)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO26_INT_LATCHED_CLR"
      sgroup "LDO26_INT_LATCHED_CLR (at 0x15914)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO26_INT_EN_SET"
      sgroup "LDO26_INT_EN_SET (at 0x15915)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO26_INT_EN_CLR"
      sgroup "LDO26_INT_EN_CLR (at 0x15916)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0, 1"
    tree.end
    tree "LDO26_INT_LATCHED_STS"
      sgroup "LDO26_INT_LATCHED_STS (at 0x15918)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "LDO26_INT_PENDING_STS"
      sgroup "LDO26_INT_PENDING_STS (at 0x15919)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0, 1"
    tree.end
    tree "LDO26_INT_MID_SEL"
      sgroup "LDO26_INT_MID_SEL (at 0x1591a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "LDO26_INT_PRIORITY"
      sgroup "LDO26_INT_PRIORITY (at 0x1591b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "LDO26_VOLTAGE_CTL1"
      sgroup "LDO26_VOLTAGE_CTL1 (at 0x15940)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RANGE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO26_VOLTAGE_CTL2"
      sgroup "LDO26_VOLTAGE_CTL2 (at 0x15941)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VSET                                     = "
    tree.end
    tree "LDO26_MODE_CTL2"
      sgroup "LDO26_MODE_CTL2 (at 0x15945)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BYPASS_ACT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BYPASS_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NPM_FOLLOW_HW_EN3                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   NPM_FOLLOW_HW_EN2                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FOLLOW_HW_EN1                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NPM_FOLLOW_HW_EN0                        = " "0, 1"
    tree.end
    tree "LDO26_EN_CTL"
      sgroup "LDO26_EN_CTL (at 0x15946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HW_EN3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HW_EN2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HW_EN1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN0                            = " "0, 1"
    tree.end
    tree "LDO26_PD_CTL"
      sgroup "LDO26_PD_CTL (at 0x15948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PULLDN_EN                                = " "0, 1"
    tree.end
    tree "LDO26_CURRENT_LIM_CTL"
      sgroup "LDO26_CURRENT_LIM_CTL (at 0x1594a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CURRENT_LIM_TESTMODE_EN                  = " "0, 1"
    tree.end
    tree "LDO26_SOFT_START_CTL"
      sgroup "LDO26_SOFT_START_CTL (at 0x1594c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START                               = " "0, 1"
    tree.end
    tree "LDO26_CONFIG_CTL"
      sgroup "LDO26_CONFIG_CTL (at 0x15952)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CLAMP_CTRL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CLAMP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CASCADE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACT_BYPASS_BUFF_EN                       = " "0, 1"
    tree.end
    tree "LDO26_VS_CTL"
      sgroup "LDO26_VS_CTL (at 0x15961)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO26_LL_VOLTAGE_CTL1"
      sgroup "LDO26_LL_VOLTAGE_CTL1 (at 0x15968)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO26_LL_VOLTAGE_CTL2"
      sgroup "LDO26_LL_VOLTAGE_CTL2 (at 0x15969)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LL_VSET                                  = "
    tree.end
    tree "LDO26_UL_VOLTAGE_CTL1"
      sgroup "LDO26_UL_VOLTAGE_CTL1 (at 0x1596a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80596a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x596a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UL_RANGE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO26_UL_VOLTAGE_CTL2"
      sgroup "LDO26_UL_VOLTAGE_CTL2 (at 0x1596b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80596b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x596b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   UL_VSET                                  = "
    tree.end
    tree "LDO26_SEC_ACCESS"
      sgroup "LDO26_SEC_ACCESS (at 0x159d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO26_PERPH_RESET_CTL1"
      sgroup "LDO26_PERPH_RESET_CTL1 (at 0x159d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "LDO26_PERPH_RESET_CTL2"
      sgroup "LDO26_PERPH_RESET_CTL2 (at 0x159d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LDO26_PERPH_RESET_CTL3"
      sgroup "LDO26_PERPH_RESET_CTL3 (at 0x159da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LDO26_PERPH_RESET_CTL4"
      sgroup "LDO26_PERPH_RESET_CTL4 (at 0x159db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "LDO26_INT_TEST1"
      sgroup "LDO26_INT_TEST1 (at 0x159e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "LDO26_INT_TEST_VAL"
      sgroup "LDO26_INT_TEST_VAL (at 0x159e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0, 1"
    tree.end
    tree "LDO26_TEST1"
      sgroup "LDO26_TEST1 (at 0x159e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO26_TEST2"
      sgroup "LDO26_TEST2 (at 0x159e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "LDO26_TRIM_NUM"
      sgroup "LDO26_TRIM_NUM (at 0x159f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO26_TRIM_CTRL"
      sgroup "LDO26_TRIM_CTRL (at 0x159f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO27"
  tree "LDO27"
    tree "LDO27_REVISION1"
      sgroup "LDO27_REVISION1 (at 0x15a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO27_REVISION2"
      sgroup "LDO27_REVISION2 (at 0x15a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO27_REVISION3"
      sgroup "LDO27_REVISION3 (at 0x15a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO27_REVISION4"
      sgroup "LDO27_REVISION4 (at 0x15a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO27_PERPH_TYPE"
      sgroup "LDO27_PERPH_TYPE (at 0x15a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO27_PERPH_SUBTYPE"
      sgroup "LDO27_PERPH_SUBTYPE (at 0x15a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO27_STATUS1"
      sgroup "LDO27_STATUS1 (at 0x15a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS_DETECTED                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE_DETECTED                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "LDO27_STATUS2"
      sgroup "LDO27_STATUS2 (at 0x15a09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFTSTART_DONE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVER_CURRENT_DETECTED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_RANGE_EXT                            = " "0, 1"
    tree.end
    tree "LDO27_STATUS3"
      sgroup "LDO27_STATUS3 (at 0x15a0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LDO_RANGE_SEL                            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   LDO_VSET                                 = "
    tree.end
    tree "LDO27_INT_RT_STS"
      sgroup "LDO27_INT_RT_STS (at 0x15a10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0, 1"
    tree.end
    tree "LDO27_INT_SET_TYPE"
      sgroup "LDO27_INT_SET_TYPE (at 0x15a11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0, 1"
    tree.end
    tree "LDO27_INT_POLARITY_HIGH"
      sgroup "LDO27_INT_POLARITY_HIGH (at 0x15a12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0, 1"
    tree.end
    tree "LDO27_INT_POLARITY_LOW"
      sgroup "LDO27_INT_POLARITY_LOW (at 0x15a13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0, 1"
    tree.end
    tree "LDO27_INT_LATCHED_CLR"
      sgroup "LDO27_INT_LATCHED_CLR (at 0x15a14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LDO27_INT_EN_SET"
      sgroup "LDO27_INT_EN_SET (at 0x15a15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERROR_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0, 1"
    tree.end
    tree "LDO27_INT_EN_CLR"
