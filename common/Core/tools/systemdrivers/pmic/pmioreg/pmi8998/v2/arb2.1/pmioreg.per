      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR4_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR4_BYTE3 (at 0x185e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80185e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x185e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR5_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR5_BYTE1 (at 0x185f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80185f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x185f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR5_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR5_BYTE2 (at 0x1860)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR5_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR5_BYTE3 (at 0x1861)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR6_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR6_BYTE1 (at 0x1862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR6_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR6_BYTE2 (at 0x1863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR6_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR6_BYTE3 (at 0x1864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR1_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR1_BYTE1 (at 0x1865)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR1_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR1_BYTE2 (at 0x1866)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR1_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR1_BYTE3 (at 0x1867)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR2_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR2_BYTE1 (at 0x1868)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR2_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR2_BYTE2 (at 0x1869)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR2_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR2_BYTE3 (at 0x186a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80186a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x186a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR3_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR3_BYTE1 (at 0x186b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80186b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x186b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR3_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR3_BYTE2 (at 0x186c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80186c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x186c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR3_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR3_BYTE3 (at 0x186d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80186d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x186d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR4_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR4_BYTE1 (at 0x186e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80186e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x186e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR4_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR4_BYTE2 (at 0x186f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80186f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x186f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR4_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR4_BYTE3 (at 0x1870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR5_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR5_BYTE1 (at 0x1871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR5_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR5_BYTE2 (at 0x1872)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR5_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR5_BYTE3 (at 0x1873)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR6_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR6_BYTE1 (at 0x1874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR6_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR6_BYTE2 (at 0x1875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR6_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR6_BYTE3 (at 0x1876)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR7_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR7_BYTE1 (at 0x1877)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR7_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR7_BYTE2 (at 0x1878)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_MISC_HDR7_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_MISC_HDR7_BYTE3 (at 0x1879)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_END_TRIM_COPY_SUBROUTINE"
      sgroup "SCHG8998_OTP_HDR_END_TRIM_COPY_SUBROUTINE (at 0x187a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
  tree.end
tree.end
tree "SCHG8998_USB"
  tree "SCHG8998_USB"
    tree "SCHG8998_USB_PERPH_TYPE"
      sgroup "SCHG8998_USB_PERPH_TYPE (at 0x1304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SCHG8998_USB_PERPH_SUBTYPE"
      sgroup "SCHG8998_USB_PERPH_SUBTYPE (at 0x1305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SCHG8998_USB_SEC_ACCESS"
      sgroup "SCHG8998_USB_SEC_ACCESS (at 0x13d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SCHG8998_USB_PERPH_RESET_CTL2"
      sgroup "SCHG8998_USB_PERPH_RESET_CTL2 (at 0x13d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SCHG8998_USB_PERPH_RESET_CTL3"
      sgroup "SCHG8998_USB_PERPH_RESET_CTL3 (at 0x13da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SCHG8998_USB_PERPH_RESET_CTL4"
      sgroup "SCHG8998_USB_PERPH_RESET_CTL4 (at 0x13db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SCHG8998_USB_SPARE"
      sgroup "SCHG8998_USB_SPARE (at 0x13df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_USB_USBIN_INPUT_STATUS"
      sgroup "SCHG8998_USB_USBIN_INPUT_STATUS (at 0x1306)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USBIN_INPUT_STATUS_7                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_INPUT_STATUS_6                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_12V                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_9V_TO_12V                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_9V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_5V_TO_12V                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_5V_TO_9V                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_5V                                 = " "0, 1"
    tree.end
    tree "SCHG8998_USB_APSD_STATUS"
      sgroup "SCHG8998_USB_APSD_STATUS (at 0x1307)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   APSD_STATUS_7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HVDCP_CHECK_TIMEOUT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SLOW_PLUGIN_TIMEOUT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENUMERATION_DONE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VADP_CHANGE_DONE_AFTER_AUTH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   QC_AUTH_DONE_STATUS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   QC_CHARGER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   APSD_DTC_STATUS_DONE                     = " "0, 1"
    tree.end
    tree "SCHG8998_USB_APSD_RESULT_STATUS"
      sgroup "SCHG8998_USB_APSD_RESULT_STATUS (at 0x1308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICL_OVERRIDE_LATCH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QC_3P0                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QC_2P0                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FLOAT_CHARGER                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCP_CHARGER                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CDP_CHARGER                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_CHARGER                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SDP_CHARGER                              = " "0, 1"
    tree.end
    tree "SCHG8998_USB_QC_CHANGE_STATUS"
      sgroup "SCHG8998_USB_QC_CHANGE_STATUS (at 0x1309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QC_CHANGE_STATUS_7                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QC_CHANGE_STATUS_6                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QC_9V_TO_12V_REASON                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QC_5V_TO_9V_REASON                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_CONTINUOUS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   QC_12V                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   QC_9V                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   QC_5V                                    = " "0, 1"
    tree.end
    tree "SCHG8998_USB_QC_PULSE_COUNT_STATUS"
      sgroup "SCHG8998_USB_QC_PULSE_COUNT_STATUS (at 0x130a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QC_PULSE_COUNT_STATUS_7                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QC_PULSE_COUNT_STATUS_6                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   QC_PULSE_COUNT                           = "
    tree.end
    tree "SCHG8998_USB_TYPE_C_STATUS_1"
      sgroup "SCHG8998_USB_TYPE_C_STATUS_1 (at 0x130b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UFP_TYPEC_RDSTD                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UFP_TYPEC_RD1P5                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UFP_TYPEC_RD3P0                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UFP_TYPEC_FMB_255K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UFP_TYPEC_FMB_301K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UFP_TYPEC_FMB_523K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UFP_TYPEC_FMB_619K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UFP_TYPEC_OPEN_OPEN                      = " "0, 1"
    tree.end
    tree "SCHG8998_USB_TYPE_C_STATUS_2"
      sgroup "SCHG8998_USB_TYPE_C_STATUS_2 (at 0x130c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DFP_RA_OPEN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TIMER_STAGE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EXIT_UFP_MODE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EXIT_DFP_MODE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DFP_RD_OPEN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DFP_RD_RA_VCONN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DFP_RD_RD                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DFP_RA_RA                                = " "0, 1"
    tree.end
    tree "SCHG8998_USB_TYPE_C_STATUS_3"
      sgroup "SCHG8998_USB_TYPE_C_STATUS_3 (at 0x130d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_BANDGAP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   U_USB_GROUND_NOVBUS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   U_USB_FLOAT_NOVBUS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   U_USB_GROUND                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   U_USB_FMB1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   U_USB_FLOAT1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   U_USB_FMB2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   U_USB_FLOAT2                             = " "0, 1"
    tree.end
    tree "SCHG8998_USB_TYPE_C_STATUS_4"
      sgroup "SCHG8998_USB_TYPE_C_STATUS_4 (at 0x130e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UFP_DFP_MODE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPEC_VBUS_STATUS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_VBUS_ERROR_STATUS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPEC_DEBOUNCE_DONE_STATUS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TYPEC_UFP_AUDIO_ADAPT_STATUS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TYPEC_VCONN_OVERCURR_STATUS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CCOUT_OUT                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CCOUT_OUT_HIZ                            = " "0, 1"
    tree.end
    tree "SCHG8998_USB_TYPE_C_STATUS_5"
      sgroup "SCHG8998_USB_TYPE_C_STATUS_5 (at 0x130f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPEC_STATUS_7                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRY_SOURCE_FAILED                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRY_SINK_FAILED                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TIMER_STAGE_2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TYPEC_LEGACY_CABLE_STATUS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TYPEC_NONCOMP_LEGACY_CABLE_STATUS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TYPEC_TRYSOURCE_DETECT_STATUS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TYPEC_TRYSINK_DETECT_STATUS              = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_RT_STS"
      sgroup "SCHG8998_USB_INT_RT_STS (at 0x1310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_RT_STS    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_RT_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_RT_STS                    = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_SET_TYPE"
      sgroup "SCHG8998_USB_INT_SET_TYPE (at 0x1311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_TYPE      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_TYPE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_TYPE                      = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_POLARITY_HIGH"
      sgroup "SCHG8998_USB_INT_POLARITY_HIGH (at 0x1312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_HIGH      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_HIGH                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_HIGH                      = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_POLARITY_LOW"
      sgroup "SCHG8998_USB_INT_POLARITY_LOW (at 0x1313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_LOW       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_LOW                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_LOW                       = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_LATCHED_CLR"
      sgroup "SCHG8998_USB_INT_LATCHED_CLR (at 0x1314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_LATCHED_CLR = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_LATCHED_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_EN_SET"
      sgroup "SCHG8998_USB_INT_EN_SET (at 0x1315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_EN_SET    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_EN_SET               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_EN_SET                    = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_EN_CLR"
      sgroup "SCHG8998_USB_INT_EN_CLR (at 0x1316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_EN_CLR    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGEL_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_EN_CLR                    = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_LATCHED_STS"
      sgroup "SCHG8998_USB_INT_LATCHED_STS (at 0x1318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_LATCHED_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_LATCHED_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_LATCHED_STS               = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_PENDING_STS"
      sgroup "SCHG8998_USB_INT_PENDING_STS (at 0x1319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_PENDING_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_PENDING_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_PENDING_STS               = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_MID_SEL"
      sgroup "SCHG8998_USB_INT_MID_SEL (at 0x131a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_USB_INT_PRIORITY"
      sgroup "SCHG8998_USB_INT_PRIORITY (at 0x131b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_TEST1"
      sgroup "SCHG8998_USB_INT_TEST1 (at 0x13e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SCHG8998_USB_INT_TEST_VAL"
      sgroup "SCHG8998_USB_INT_TEST_VAL (at 0x13e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_VAL       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_VAL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_VAL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_VASHDN_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_VAL                       = " "0, 1"
    tree.end
    tree "SCHG8998_USB_CMD_IL"
      sgroup "SCHG8998_USB_CMD_IL (at 0x1340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_2_SYS_FET_DIS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_SUSPEND                            = " "0, 1"
    tree.end
    tree "SCHG8998_USB_CMD_APSD"
      sgroup "SCHG8998_USB_CMD_APSD (at 0x1341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ICL_OVERRIDE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   APSD_RERUN                               = " "0, 1"
    tree.end
    tree "SCHG8998_USB_CMD_HVDCP_2"
      sgroup "SCHG8998_USB_CMD_HVDCP_2 (at 0x1343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_AICL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_12V                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FORCE_9V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_5V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IDLE                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SINGLE_DECREMENT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SINGLE_INCREMENT                         = " "0, 1"
    tree.end
    tree "SCHG8998_USB_TYPE_C_CFG"
      sgroup "SCHG8998_USB_TYPE_C_CFG (at 0x1358)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   APSD_START_ON_CC                         = " "0 (APSD_START_AFTER_VBUS_DEGLITCH),1 (APSD_START_AFTER_VBUS_AND_CC_DEGLITCH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WAIT_FOR_APSD                            = " "0 (APSD_NO_WAIT),1 (APSD_WAIT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FACTORY_MODE_DETECTION_EN                = " "0 (TYPEC_FACTORY_MODE_NOT_DETECTABLE),1 (TYPEC_FACTORY_MODE_DETECTABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FACTORY_MODE_ICL_3A_4A                   = " "0 (RID_TYPEC_FACTORY_MODE_ICL_3A),1 (RID_TYPEC_FACTORY_MODE_ICL_4A)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FACTORY_MODE_DIS_CHGING_CFG              = " "0 (RID_TYPEC_FACTORY_MODE_NORMAL_CHG_CONTROL),1 (RID_TYPEC_FACTORY_MODE_DISABLE_CHARGING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SUSPEND_NON_COMPLIANT_CFG                = " "0 (NON_COMPLIANT_TYPEC_CHARGER_NORMAL_OPERATION),1 (NON_COMPLIANT_TYPEC_CHARGER_SUSPEND)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCONN_OC_CFG                             = " "0 (TYPEC_VCONN_OC_DIS_AND_WAIT_FOR_OPEN),1 (TYPEC_VCONN_OC_TERMINATE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TYPE_C_OR_U_USB                          = " "0 (TYPEC_CONNECTOR),1 (MICRO_USB_CONNECTOR)"
    tree.end
    tree "SCHG8998_USB_TYPE_C_CFG_2"
      sgroup "SCHG8998_USB_TYPE_C_CFG_2 (at 0x1359)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_DFP_CURRSRC_MODE                  = " "0 (TYPEC_DFP_CURRSRC_LOCK_TCCDEBOUNCE),1 (TYPEC_DFP_CURRSRC_LOCK_TPDDEBOUNCE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DFP_CC_1P4V_OR_1P6V_CHICKEN_BIT          = " "0 (DFP_CC_1P4V_CHICKEN_BIT),1 (DFP_CC_1P6V_CHICKEN_BIT)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VCONN_SOFTSTART_CFG                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_TRY_SOURCE_MODE                       = " "0 (TYPEC_TRYSOURCE_DISABLED),1 (TYPEC_TRYSOURCE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB_FACTORY_MODE_ENABLE                  = " "0 (U_USB_FACTORY_MODE_DISABLED),1 (U_USB_FACTORY_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TYPE_C_UFP_MODE                          = " "0 (TYPEC_UFP_CRUDE_SENSOR_METHOD),1 (TYPEC_UFP_CONSERVATIVE_METHOD)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_80UA_180UA_CUR_SOURCE                 = " "0 (TYPEC_80UA_CURRENT_SOURCE),1 (TYPEC_180UA_CURRENT_SOURCE)"
    tree.end
    tree "SCHG8998_USB_TYPE_C_CFG_3"
      sgroup "SCHG8998_USB_TYPE_C_CFG_3 (at 0x135a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80135a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x135a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TVBUS_DEBOUNCE                           = " "0 (TVBUS_DEBOUNCE_275MS),1 (TVBUS_DEBOUNCE_500MS)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPEC_LEGACY_CABLE_INT_EN                = " "0 (TYPEC_LEGACY_CABLE_INT_DIS),1 (TYPEC_LEGACY_CABLE_INT_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_NONCOMPLIANT_LEGACY_CABLE_INT_EN   = " "0 (TYPEC_NONCOMP_LEGACY_CABLE_INT_DIS),1 (TYPEC_NONCOMP_LEGACY_CABLE_INT_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPEC_TRYSOURCE_DETECT_INT_EN            = " "0 (TYPEC_TRYSOURCE_INT_DIS),1 (TYPEC_TRYSOURCE_INT_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TYPEC_TRYSINK_DETECT_INT_EN              = " "0 (TYPEC_TRYSINK_INT_DIS),1 (TYPEC_TRYSINK_INT_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_TRY_SINK_MODE                         = " "0 (TYPEC_TRYSINK_DISABLED),1 (TYPEC_TRYSINK_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_LEGACY_CABLE_DETECTION                = " "0 (DIS_LEGACY_CABLE_DETECTION),1 (EN_LEGACY_CABLE_DETECTION)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALLOW_PD_DURING_UFP_TCCDB                = " "0 (PD_RESETS_TCCDB),1 (PD_NOT_RESETS_TCCDB)"
    tree.end
    tree "SCHG8998_USB_HVDCP_PULSE_COUNT_MAX"
      sgroup "SCHG8998_USB_HVDCP_PULSE_COUNT_MAX (at 0x135b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80135b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x135b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   HVDCP_PULSE_COUNT_MAX_QC2P0              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HVDCP_PULSE_COUNT_MAX_QC3P0              = "
    tree.end
    tree "SCHG8998_USB_USBIN_ADAPTER_ALLOW_CFG"
      sgroup "SCHG8998_USB_USBIN_ADAPTER_ALLOW_CFG (at 0x1360)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   USBIN_ADAPTER_ALLOW                      = "
    tree.end
    tree "SCHG8998_USB_USBIN_OPTIONS_1_CFG"
      sgroup "SCHG8998_USB_USBIN_OPTIONS_1_CFG (at 0x1362)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CABLE_R_SEL                              = " "0 (CABLE_RESISTANCE_LESS_THAN_400_OHMS),1 (CABLE_RESISTANCE_GREATER_THAN_400_OHMS)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HVDCP_AUTH_ALG_EN_CFG                    = " "0 (HVDCP_AUTH_DIS),1 (HVDCP_AUTH_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HVDCP_AUTONOMOUS_MODE_EN_CFG             = " "0 (AUTO_INC_BY_COMMAND),1 (AUTO_INC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_PRIORITY                           = " "0 (DCIN_PRIORITY),1 (USBIN_PRIORITY)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AUTO_SRC_DETECT                          = " "0 (AUTO_SRC_DETECT_DISABLED),1 (AUTO_SRC_DETECT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HVDCP_EN                                 = " "0 (HVDCP_DISABLE),1 (HVDCP_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIMER_STAGE_CHICKEN_BIT                  = " "0 (TIMER_STAGE_CHICKEN_BIT_0),1 (TIMER_STAGE_CHICKEN_BIT_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VADP_TAPER_TIMER_EN                      = " "0, 1"
    tree.end
    tree "SCHG8998_USB_USBIN_OPTIONS_2_CFG"
      sgroup "SCHG8998_USB_USBIN_OPTIONS_2_CFG (at 0x1363)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_RST_EUD_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SWITCHER_START_CFG                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCD_TIMEOUT_SEL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCD_CURRENT_SEL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SLOW_PLUGIN_TIMER_EN_CFG                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLOAT_DIS_CHGING_CFG                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SUSPEND_FLOAT_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_FLOAT_SDP_CFG                      = " "0, 1"
    tree.end
    tree "SCHG8998_USB_TAPER_TIMER_SEL_CFG"
      sgroup "SCHG8998_USB_TAPER_TIMER_SEL_CFG (at 0x1364)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPEC_SPARE_CFG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPEC_VBUS_1V_VS_3P6V_THRESH             = " "0 (TYPEC_VBUS_1V_THRESHOLD),1 (TYPEC_VBUS_3P6V_THRESHOLD)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_DRP_DFP_TIME_CFG                   = " "0 (TYPEC_DRP_DFP_TIME_REDUCED),1 (TYPEC_DRP_DFP_TIME_NOT_REDUCED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HVDCP_DIS_NON_COMP_CFG                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FM_START_DEBOUNCE                        = " "0 (FM_START_DEBOUNCE_120MS),1 (FM_START_DEBOUNCE_500MS),2 (FM_START_DEBOUNCE_800MS),3 (FM_START_DEBOUNCE_1500MS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TAPER_TIMER_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_USB_USBIN_LOAD_CFG"
      sgroup "SCHG8998_USB_USBIN_LOAD_CFG (at 0x1365)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USBIN_OV_CH_LOAD_OPTION                  = " "0 (DO_NOT_DISABLE_USBIN_PATH_ON_DCIN_OV),1 (DISABLE_USBIN_PATH_ON_DCIN_OV)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENABLE_AICL_RERUN_QC_INC                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USE_BC_ICL_CFG                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ICL_OVERRIDE_AFTER_APSD                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   USBIN_AICL_STEP_TIMING_SEL               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USBIN_IN_COLLAPSE_GF_SEL                 = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_USB_USBIN_ICL_OPTIONS"
      sgroup "SCHG8998_USB_USBIN_ICL_OPTIONS (at 0x1366)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_USB3P0_SEL                           = " "0 (USB_2P0_SEL),1 (USB_3P0_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51_MODE                               = " "0 (USB_100_MODE),1 (USB_500_MODE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_MODE_CHG                           = " "0 (USB_100_OR_500_MODE),1 (USB_HIGH_CURRENT_MODE)"
    tree.end
    tree "SCHG8998_USB_TYPE_C_INTRPT_ENB"
      sgroup "SCHG8998_USB_TYPE_C_INTRPT_ENB (at 0x1367)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPEC_CCOUT_DETACH_INT_EN                = " "0 (TYPEC_CCOUT_DETACH_INT_DISABLE),1 (TYPEC_CCOUT_DETACH_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPEC_CCOUT_ATTACH_INT_EN                = " "0 (TYPEC_CCOUT_ATTACH_INT_DISABLE),1 (TYPEC_CCOUT_ATTACH_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_VBUS_ERROR_INT_EN                  = " "0 (TYPEC_VBUS_ERROR_INT_DISABLE),1 (TYPEC_VBUS_ERROR_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPEC_UFP_AUDIOADAPT_INT_EN              = " "0 (TYPEC_AUDIOADAPTER_UFP_INT_DISABLE),1 (TYPEC_AUDIOADAPTER_UFP_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TYPEC_DEBOUNCE_DONE_INT_EN               = " "0 (TYPEC_TCCDEBOUNCE_DONE_INT_DISABLE),1 (TYPEC_TCCDEBOUNCE_DONE_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TYPEC_CCSTATE_CHANGE_INT_EN              = " "0 (TYPEC_CCSTATE_CHANGE_INT_DISABLE),1 (TYPEC_CCSTATE_CHANGE_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TYPEC_VBUS_DEASSERT_INT_EN               = " "0 (TYPEC_VBUS_DEASSERT_INT_DISABLE),1 (TYPEC_VBUS_DEASSERT_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TYPEC_VBUS_ASSERT_INT_EN                 = " "0 (TYPEC_VBUS_ASSERT_INT_DISABLE),1 (TYPEC_VBUS_ASSERT_INT_ENABLE)"
    tree.end
    tree "SCHG8998_USB_TYPE_C_INTRPT_ENB_SOFTWARE_CTRL"
      sgroup "SCHG8998_USB_TYPE_C_INTRPT_ENB_SOFTWARE_CTRL (at 0x1368)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EXIT_SNK_BASED_ON_CC                     = " "0 (EXIT_SNK_BASED_ON_CC_DIS),1 (EXIT_SNK_BASED_ON_CC_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VCONN_EN_ORIENTATION                     = " "0 (TYPEC_VCONN_EN_SW_CC1),1 (TYPEC_VCONN_EN_SW_CC2)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_VCONN_OVERCURR_INT_EN              = " "0 (TYPEC_VCONN_OC_INT_DISABLE),1 (TYPEC_VCONN_OC_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCONN_EN_SRC                             = " "0 (TYPEC_VCONN_EN_SRC_HW),1 (TYPEC_VCONN_EN_SRC_SW)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCONN_EN_VALUE                           = " "0 (TYPEC_VCONN_DISABLE_SW),1 (TYPEC_VCONN_ENABLE_SW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SNK_EN_CMD                               = " "0 (TYPEC_SNK_EN_CMD_DISABLED),1 (TYPEC_SNK_EN_CMD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SRC_EN_CMD                               = " "0 (TYPEC_SRC_EN_CMD_DISABLED),1 (TYPEC_SRC_EN_CMD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TYPEC_DISABLE_CMD                        = " "0 (TYPEC_DISABLE_CMD_DISABLED),1 (TYPEC_DISABLE_CMD_ENABLED)"
    tree.end
    tree "SCHG8998_USB_USBIN_SOURCE_CHANGE_INTRPT_ENB"
      sgroup "SCHG8998_USB_USBIN_SOURCE_CHANGE_INTRPT_ENB (at 0x1369)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HVDCP_TIMEOUT_IRQ_EN_CFG                 = " "0 (HVDCP_TIMEOUT_INT_DISABLE),1 (HVDCP_TIMEOUT_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SLOW_IRQ_EN_CFG                          = " "0 (SLOW_PLUGIN_INT_DISABLE),1 (SLOW_PLUGIN_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENUMERATION_IRQ_EN_CFG                   = " "0 (ENUM_INT_DISABLE),1 (ENUM_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VADP_IRQ_EN_CFG                          = " "0 (ADAPTER_VOLT_CHANGE_INT_DISABLE),1 (ADAPTER_VOLT_CHANGE_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTH_IRQ_EN_CFG                          = " "0 (AUTHENTICATION_ALG_INT_DISABLE),1 (AUTHENTICATION_ALG_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HVDCP_IRQ_EN_CFG                         = " "0 (HVDCP_DETECTION_INT_DISABLE),1 (HVDCP_DETECTION_INT_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   APSD_IRQ_EN_CFG                          = " "0 (APSD_COMPLETE_INT_DISABLE),1 (APSD_COMPLETE_INT_ENABLE)"
    tree.end
    tree "SCHG8998_USB_USBIN_CURRENT_LIMIT_CFG"
      sgroup "SCHG8998_USB_USBIN_CURRENT_LIMIT_CFG (at 0x1370)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USBIN_CURRENT_LIMIT                      = "
    tree.end
    tree "SCHG8998_USB_USBIN_AICL_OPTIONS_CFG"
      sgroup "SCHG8998_USB_USBIN_AICL_OPTIONS_CFG (at 0x1380)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SUSPEND_ON_COLLAPSE_USBIN                = " "0 (USBIN_DOES_NOT_SUSPEND_ON_COLLAPSE),1 (USBIN_SUSPENDS_ON_COLLAPSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_AICL_HDC_EN                        = " "0 (USBIN_AICL_HDC_DISABLED),1 (USBIN_AICL_HDC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_AICL_START_AT_MAX                  = " "0 (USBIN_AICL_DOES_NOT_START_AT_MAX),1 (USBIN_AICL_STARTS_AT_MAX)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_AICL_RERUN_EN                      = " "0 (USBIN_AICL_RERUN_DISABLED),1 (USBIN_AICL_RERUN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_AICL_ADC_EN                        = " "0 (USBIN_AICL_ADC_DISABLED),1 (USBIN_AICL_ADC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_AICL_EN                            = " "0 (USBIN_AICL_DISABLED),1 (USBIN_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_HV_COLLAPSE_RESPONSE               = " "0 (USBIN_COLLAPSE_HV_FET_ON),1 (USBIN_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_LV_COLLAPSE_RESPONSE               = " "0 (USBIN_COLLAPSE_LV_FET_ON),1 (USBIN_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SCHG8998_USB_USBIN_5V_AICL_THRESHOLD_CFG"
      sgroup "SCHG8998_USB_USBIN_5V_AICL_THRESHOLD_CFG (at 0x1381)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   USBIN_5V_AICL_THRESHOLD_CFG              = " "0 (USBIN_5V_AICL_THRESHOLD_4P0V),1 (USBIN_5V_AICL_THRESHOLD_4P1V),2 (USBIN_5V_AICL_THRESHOLD_4P2V),3 (USBIN_5V_AICL_THRESHOLD_4P3V),4 (USBIN_5V_AICL_THRESHOLD_4P4V),5 (USBIN_5V_AICL_THRESHOLD_4P5V),6 (USBIN_5V_AICL_THRESHOLD_4P6V),7 (USBIN_5V_AICL_THRESHOLD_4P7V)"
    tree.end
    tree "SCHG8998_USB_USBIN_9V_AICL_THRESHOLD_CFG"
      sgroup "SCHG8998_USB_USBIN_9V_AICL_THRESHOLD_CFG (at 0x1382)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   USBIN_9V_AICL_THRESHOLD_CFG              = " "0 (USBIN_9V_AICL_THRESHOLD_7P2V),1 (USBIN_9V_AICL_THRESHOLD_7P4V),2 (USBIN_9V_AICL_THRESHOLD_7P6V),3 (USBIN_9V_AICL_THRESHOLD_7P8V),4 (USBIN_9V_AICL_THRESHOLD_8P0V),5 (USBIN_9V_AICL_THRESHOLD_8P2V),6 (USBIN_9V_AICL_THRESHOLD_8P4V),7 (USBIN_9V_AICL_THRESHOLD_8P6V)"
    tree.end
    tree "SCHG8998_USB_USBIN_12V_AICL_THRESHOLD_CFG"
      sgroup "SCHG8998_USB_USBIN_12V_AICL_THRESHOLD_CFG (at 0x1383)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   USBIN_12V_AICL_THRESHOLD_CFG             = " "0 (USBIN_12V_AICL_THRESHOLD_10P2V),1 (USBIN_12V_AICL_THRESHOLD_10P4V),2 (USBIN_12V_AICL_THRESHOLD_10P6V),3 (USBIN_12V_AICL_THRESHOLD_10P8V),4 (USBIN_12V_AICL_THRESHOLD_11P0V),5 (USBIN_12V_AICL_THRESHOLD_11P2V),6 (USBIN_12V_AICL_THRESHOLD_11P4V),7 (USBIN_12V_AICL_THRESHOLD_11P6V)"
    tree.end
    tree "SCHG8998_USB_USBIN_CONT_AICL_THRESHOLD_CFG"
      sgroup "SCHG8998_USB_USBIN_CONT_AICL_THRESHOLD_CFG (at 0x1384)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   USBIN_CONT_AICL_THRESHOLD_CFG            = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_7_0"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_7_0 (at 0x13e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_7_0                         = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_15_8"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_15_8 (at 0x13e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_15_8                        = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_23_16"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_23_16 (at 0x13e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_23_16                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_31_24"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_31_24 (at 0x13e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_31_24                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_39_32"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_39_32 (at 0x13e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_39_32                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_47_40"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_47_40 (at 0x13e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_47_40                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_55_48"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_55_48 (at 0x13e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_55_48                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_63_56"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_63_56 (at 0x13e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_63_56                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_71_64"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_71_64 (at 0x13ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_71_64                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_79_72"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_79_72 (at 0x13eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_79_72                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_87_80"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_87_80 (at 0x13ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_87_80                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_95_88"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_95_88 (at 0x13ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_95_88                       = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_103_96"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_103_96 (at 0x13ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_103_96                      = "
    tree.end
    tree "SCHG8998_USB_CHG_OUT_TEST_111_104"
      sgroup "SCHG8998_USB_CHG_OUT_TEST_111_104 (at 0x13ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_111_104                     = "
    tree.end
    tree "SCHG8998_USB_TRIM_NUM"
      sgroup "SCHG8998_USB_TRIM_NUM (at 0x13f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_DCIN_HC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_DCIN_HC (at 0x13f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SCPATH_INPUT_CS_OFFSET_DCIN_HC        = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_DCIN_MC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_DCIN_MC (at 0x13f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SCPATH_INPUT_CS_OFFSET_DCIN_MC        = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_USBIN_HC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_USBIN_HC (at 0x13f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SCPATH_INPUT_CS_OFFSET_USBIN_HC       = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_USBIN_MC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_USBIN_MC (at 0x13f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SCPATH_INPUT_CS_OFFSET_USBIN_MC       = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_USBIN_LC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_USBIN_LC (at 0x13f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SCPATH_INPUT_CS_OFFSET_USBIN_LC       = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_OTG"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_OFFSET_OTG (at 0x13f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SCPATH_INPUT_CS_OFFSET_OTG            = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_DCIN_HC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_DCIN_HC (at 0x13f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SCPATH_INPUT_CS_GAIN_DCIN_HC          = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_DCIN_MC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_DCIN_MC (at 0x13f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SCPATH_INPUT_CS_GAIN_DCIN_MC          = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_USBIN_HC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_USBIN_HC (at 0x13f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SCPATH_INPUT_CS_GAIN_USBIN_HC         = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_USBIN_MC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_USBIN_MC (at 0x13fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SCPATH_INPUT_CS_GAIN_USBIN_MC         = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_USBIN_LC"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_USBIN_LC (at 0x13fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SCPATH_INPUT_CS_GAIN_USBIN_LC         = "
    tree.end
    tree "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_OTG"
      sgroup "SCHG8998_USB_TR_SCPATH_INPUT_CS_GAIN_OTG (at 0x13fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SCPATH_INPUT_CS_GAIN_OTG              = "
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      sgroup "SPMI_SSC_DETECT_CFG (at 0x641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SAMPLE_EDGE_0"
      sgroup "SPMI_SAMPLE_EDGE_0 (at 0x645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USE_RISING_EDGE                          = " "0 (FALLING_EDGE_SCL),1 (RISING_EDGE_SCL)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SPMI_ATE_MODE_SEL_0"
      sgroup "SPMI_ATE_MODE_SEL_0 (at 0x6e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DISABLE_GLITCH_FILTER                    = " "0, 1"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_PERPH_SUBTYPE"
      sgroup "SPMI_OPTIONS_PERPH_SUBTYPE (at 0x20605)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_I2C_SID_0"
      sgroup "SPMI_OPTIONS_I2C_SID_0 (at 0x20648)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   I2C_SID_MSB                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SPMI_OPTIONS_MODE_EN_0"
      sgroup "SPMI_OPTIONS_MODE_EN_0 (at 0x20649)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   I2C_MODE                                 = " "0 (SPMI_MODE_ON),1 (I2C_MODE_ON)"
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      sgroup "TEMP_ALARM_REVISION1 (at 0x2400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      sgroup "TEMP_ALARM_REVISION2 (at 0x2401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      sgroup "TEMP_ALARM_REVISION3 (at 0x2402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      sgroup "TEMP_ALARM_REVISION4 (at 0x2403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      sgroup "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      sgroup "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      sgroup "TEMP_ALARM_STATUS1 (at 0x2408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   TEMP_ALARM_FSM_STATE                     = " "0 (STATE_0),1 (STATE_1A),2 (STATE_1B),3 (STATE_2A),4 (STATE_2B),5 (STATE_3),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      sgroup "TEMP_ALARM_INT_RT_STS (at 0x2410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      sgroup "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      sgroup "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      sgroup "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      sgroup "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      sgroup "TEMP_ALARM_INT_EN_SET (at 0x2415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      sgroup "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      sgroup "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      sgroup "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      sgroup "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      sgroup "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_ST3_OVERRIDE),1 (OVERTEMP_ST3_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_ST2_OVERRIDE),1 (OVERTEMP_ST2_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TEMP_ALARM_CLK_RATE                      = " "0 (TEMP_ALARM_CLK_RATE_0),1 (TEMP_ALARM_CLK_RATE_1),2 (TEMP_ALARM_CLK_RATE_2),3 (TEMP_ALARM_CLK_RATE_3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      sgroup "TEMP_ALARM_EN_CTL1 (at 0x2446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (FOLLOW_HW_TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      sgroup "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      sgroup "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      sgroup "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      sgroup "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
  tree.end
tree.end
tree "TRI_LED"
  tree "TRI_LED"
    tree "TRI_LED_REVISION1"
      sgroup "TRI_LED_REVISION1 (at 0x1d000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRI_LED_REVISION2"
      sgroup "TRI_LED_REVISION2 (at 0x1d001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRI_LED_REVISION3"
      sgroup "TRI_LED_REVISION3 (at 0x1d002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRI_LED_REVISION4"
      sgroup "TRI_LED_REVISION4 (at 0x1d003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRI_LED_PERPH_TYPE"
      sgroup "TRI_LED_PERPH_TYPE (at 0x1d004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRI_LED_PERPH_SUBTYPE"
      sgroup "TRI_LED_PERPH_SUBTYPE (at 0x1d005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRI_LED_DROPOUT_DET_STATUS"
      sgroup "TRI_LED_DROPOUT_DET_STATUS (at 0x1d008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DROPOUT_DET_R                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DROPOUT_DET_G                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_B                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
    tree.end
    tree "TRI_LED_DROPOUT_DET_STATUS_CLR"
      sgroup "TRI_LED_DROPOUT_DET_STATUS_CLR (at 0x1d009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STATUS_CLR                               = " "0 (NO_CLR),1 (CLR_STS)"
    tree.end
    tree "TRI_LED_INT_RT_STS"
      sgroup "TRI_LED_INT_RT_STS (at 0x1d010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_RT_STS                       = " "0, 1"
    tree.end
    tree "TRI_LED_INT_SET_TYPE"
      sgroup "TRI_LED_INT_SET_TYPE (at 0x1d011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TRI_LED_INT_POLARITY_HIGH"
      sgroup "TRI_LED_INT_POLARITY_HIGH (at 0x1d012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TRI_LED_INT_POLARITY_LOW"
      sgroup "TRI_LED_INT_POLARITY_LOW (at 0x1d013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TRI_LED_INT_LATCHED_CLR"
      sgroup "TRI_LED_INT_LATCHED_CLR (at 0x1d014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "TRI_LED_INT_EN_SET"
      sgroup "TRI_LED_INT_EN_SET (at 0x1d015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TRI_LED_INT_EN_CLR"
      sgroup "TRI_LED_INT_EN_CLR (at 0x1d016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TRI_LED_INT_LATCHED_STS"
      sgroup "TRI_LED_INT_LATCHED_STS (at 0x1d018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TRI_LED_INT_PENDING_STS"
      sgroup "TRI_LED_INT_PENDING_STS (at 0x1d019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TRI_LED_INT_MID_SEL"
      sgroup "TRI_LED_INT_MID_SEL (at 0x1d01a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TRI_LED_INT_PRIORITY"
      sgroup "TRI_LED_INT_PRIORITY (at 0x1d01b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "TRI_LED_LED_SRC_SEL"
      sgroup "TRI_LED_LED_SRC_SEL (at 0x1d045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED_SRC_SEL                              = " "0 (SRC_GND),1 (SRC_VINRGB_VBOOST),2 (reserved),3 (SRC_VSYS)"
    tree.end
    tree "TRI_LED_EN_CTL"
      sgroup "TRI_LED_EN_CTL (at 0x1d046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RED_EN                                   = " "0 (RED_DIS),1 (RED_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GREEN_EN                                 = " "0 (GREEN_DIS),1 (GREEN_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BLUE_EN                                  = " "0 (BLUE_DIS),1 (BLUE_EN)"
    tree.end
    tree "TRI_LED_EN_CTL_ATC"
      sgroup "TRI_LED_EN_CTL_ATC (at 0x1d047)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RED_ATC_EN                               = " "0 (RED_ATC_DISABLE),1 (RED_ATC_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GREEN_ATC_EN                             = " "0 (GREEN_ATC_DISABLE),1 (GREEN_ATC_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BLUE_ATC_EN                              = " "0 (BLUE_ATC_DISABLE),1 (BLUE_ATC_ENABLE)"
    tree.end
    tree "TRI_LED_DROPOUT_DET"
      sgroup "TRI_LED_DROPOUT_DET (at 0x1d050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DROPOUT_DET                           = " "0 (DET_DIS),1 (DET_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DET_DEBOUNCE                             = " "0 (NO_DEBOUNCE),1 (DEBOUNCE_10US),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   DET_SEL                                  = " "0 (VIN_RGB),1 (RED),2 (GREEN),3 (BLUE)"
    tree.end
    tree "TRI_LED_SEC_ACCESS"
      sgroup "TRI_LED_SEC_ACCESS (at 0x1d0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL1"
      sgroup "TRI_LED_PERPH_RESET_CTL1 (at 0x1d0d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL2"
      sgroup "TRI_LED_PERPH_RESET_CTL2 (at 0x1d0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL3"
      sgroup "TRI_LED_PERPH_RESET_CTL3 (at 0x1d0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL4"
      sgroup "TRI_LED_PERPH_RESET_CTL4 (at 0x1d0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRI_LED_INT_TEST1"
      sgroup "TRI_LED_INT_TEST1 (at 0x1d0e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (NO_REPLACE),1 (INV_TEST_VAL)"
    tree.end
    tree "TRI_LED_INT_TEST_VAL"
      sgroup "TRI_LED_INT_TEST_VAL (at 0x1d0e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TRI_LED_TEST1"
      sgroup "TRI_LED_TEST1 (at 0x1d0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CLOSE_LOOP_TEST_EN                       = " "0 (CL_TEST_DIS),1 (BLUE),2 (GREEN),3 (RED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OPEN_LOOP_CAL_EN                         = " "0 (OL_CAL_DTEST2_DIS),1 (OL_CAL_DTEST2_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_MODE_EN                            = " "0 (ATEST_DTEST2_DIS),1 (ATEST_DTEST2_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_SEL                                  = " "0 (LPG_PWM),1 (DTEST1)"
    tree.end
    tree "TRI_LED_TRIM_NUM"
      sgroup "TRI_LED_TRIM_NUM (at 0x1d0f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TRI_LED_R_8MA_CURRENT_TRIM"
      sgroup "TRI_LED_R_8MA_CURRENT_TRIM (at 0x1d0f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   R_8MA_CURRENT_TRIM                       = "
    tree.end
    tree "TRI_LED_G_8MA_CURRENT_TRIM"
      sgroup "TRI_LED_G_8MA_CURRENT_TRIM (at 0x1d0f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   G_8MA_CURRENT_TRIM                       = "
    tree.end
    tree "TRI_LED_B_8MA_CURRENT_TRIM"
      sgroup "TRI_LED_B_8MA_CURRENT_TRIM (at 0x1d0f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   B_8MA_CURRENT_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "USB_PD_PHY"
  tree "USB_PD_PHY"
    tree "USB_PD_PHY_REVISION1"
      sgroup "USB_PD_PHY_REVISION1 (at 0x1700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "USB_PD_PHY_REVISION2"
      sgroup "USB_PD_PHY_REVISION2 (at 0x1701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "USB_PD_PHY_REVISION3"
      sgroup "USB_PD_PHY_REVISION3 (at 0x1702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "USB_PD_PHY_REVISION4"
      sgroup "USB_PD_PHY_REVISION4 (at 0x1703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "USB_PD_PHY_PERPH_TYPE"
      sgroup "USB_PD_PHY_PERPH_TYPE (at 0x1704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "USB_PD_PHY_PERPH_SUBTYPE"
      sgroup "USB_PD_PHY_PERPH_SUBTYPE (at 0x1705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "USB_PD_PHY_INT_RT_STS"
      sgroup "USB_PD_PHY_INT_RT_STS (at 0x1710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_RT_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_RT_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_RT_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_RT_STS                       = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_SET_TYPE"
      sgroup "USB_PD_PHY_INT_SET_TYPE (at 0x1711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_TYPE             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_TYPE                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_TYPE                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_TYPE                         = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_POLARITY_HIGH"
      sgroup "USB_PD_PHY_INT_POLARITY_HIGH (at 0x1712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_HIGH             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_HIGH                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_HIGH                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_HIGH                         = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_POLARITY_LOW"
      sgroup "USB_PD_PHY_INT_POLARITY_LOW (at 0x1713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_LOW              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_LOW                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_LOW                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_LOW                          = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_LATCHED_CLR"
      sgroup "USB_PD_PHY_INT_LATCHED_CLR (at 0x1714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_LATCHED_CLR      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_EN_SET"
      sgroup "USB_PD_PHY_INT_EN_SET (at 0x1715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_EN_SET           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_EN_SET              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_EN_SET              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_EN_SET                       = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_EN_CLR"
      sgroup "USB_PD_PHY_INT_EN_CLR (at 0x1716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_EN_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_EN_CLR                       = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_LATCHED_STS"
      sgroup "USB_PD_PHY_INT_LATCHED_STS (at 0x1718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_LATCHED_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_LATCHED_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_LATCHED_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_LATCHED_STS                  = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_PENDING_STS"
      sgroup "USB_PD_PHY_INT_PENDING_STS (at 0x1719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED_PENDING_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED_PENDING_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED_PENDING_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT_PENDING_STS                  = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_MID_SEL"
      sgroup "USB_PD_PHY_INT_MID_SEL (at 0x171a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "USB_PD_PHY_INT_PRIORITY"
      sgroup "USB_PD_PHY_INT_PRIORITY (at 0x171b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "USB_PD_PHY_MSG_CONFIG"
      sgroup "USB_PD_PHY_MSG_CONFIG (at 0x1740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PORT_DATA_ROLE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PORT_POWER_ROLE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SPEC_REV                                 = " "0, 1, 2, 3"
    tree.end
    tree "USB_PD_PHY_TX_SIZE"
      sgroup "USB_PD_PHY_TX_SIZE (at 0x1742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TX_SIZE                                  = "
    tree.end
    tree "USB_PD_PHY_TX_CONTROL"
      sgroup "USB_PD_PHY_TX_CONTROL (at 0x1744)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TX_RETRY_COUNT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   TX_FRAME_TYPE                            = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEND_SIGNAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_MESSAGE                             = " "0, 1"
    tree.end
    tree "USB_PD_PHY_EN_CONTROL"
      sgroup "USB_PD_PHY_EN_CONTROL (at 0x1746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE                                   = " "0 (PDPHY_DISABLED),1 (PDPHY_ENABLED)"
    tree.end
    tree "USB_PD_PHY_RX_SIZE"
      sgroup "USB_PD_PHY_RX_SIZE (at 0x1748)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RX_SIZE                                  = "
    tree.end
    tree "USB_PD_PHY_RX_STATUS"
      sgroup "USB_PD_PHY_RX_STATUS (at 0x174a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   RX_MSG_MISSED                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_FRAME_TYPE                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "USB_PD_PHY_RX_ACKNOWLEDGE"
      sgroup "USB_PD_PHY_RX_ACKNOWLEDGE (at 0x174b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RX_BUFFER_TOKEN                          = " "0, 1"
    tree.end
    tree "USB_PD_PHY_FRAME_FILTER"
      sgroup "USB_PD_PHY_FRAME_FILTER (at 0x174c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_CABLE_RESET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_HARD_RESET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_SOPII_DEBUG                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_SOPI_DEBUG                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_SOPII                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SOPI                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_SOP                                   = " "0, 1"
    tree.end
    tree "USB_PD_PHY_BIST_MODE"
      sgroup "USB_PD_PHY_BIST_MODE (at 0x174e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BIST_ENABLE                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BIST_MODE                                = "
    tree.end
    tree "USB_PD_PHY_FR_SWAP_CTRL"
      sgroup "USB_PD_PHY_FR_SWAP_CTRL (at 0x1750)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FRS_RX_EN                                = " "0, 1"
    tree.end
    tree "USB_PD_PHY_TIMER_CTRL"
      sgroup "USB_PD_PHY_TIMER_CTRL (at 0x1758)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TIMER_MODE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TIMER_CLK_SEL                            = " "0, 1, 2, 3"
    tree.end
    tree "USB_PD_PHY_TIMER_DATA_HIGH"
      sgroup "USB_PD_PHY_TIMER_DATA_HIGH (at 0x175a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA_HIGH                          = "
    tree.end
    tree "USB_PD_PHY_TIMER_DATA_LOW"
      sgroup "USB_PD_PHY_TIMER_DATA_LOW (at 0x175b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA_LOW                           = "
    tree.end
    tree "USB_PD_PHY_TX_BUFFER_n"
      sgroup "USB_PD_PHY_TX_BUFFER_n (at 0x1760)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "USB_PD_PHY_RX_BUFFER_n"
      sgroup "USB_PD_PHY_RX_BUFFER_n (at 0x1780)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "USB_PD_PHY_SEC_ACCESS"
      sgroup "USB_PD_PHY_SEC_ACCESS (at 0x17d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "USB_PD_PHY_PERPH_RESET_CTL1"
      sgroup "USB_PD_PHY_PERPH_RESET_CTL1 (at 0x17d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "USB_PD_PHY_PERPH_RESET_CTL2"
      sgroup "USB_PD_PHY_PERPH_RESET_CTL2 (at 0x17d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "USB_PD_PHY_PERPH_RESET_CTL3"
      sgroup "USB_PD_PHY_PERPH_RESET_CTL3 (at 0x17da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "USB_PD_PHY_PERPH_RESET_CTL4"
      sgroup "USB_PD_PHY_PERPH_RESET_CTL4 (at 0x17db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_TEST1"
      sgroup "USB_PD_PHY_INT_TEST1 (at 0x17e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "USB_PD_PHY_INT_TEST_VAL"
      sgroup "USB_PD_PHY_INT_TEST_VAL (at 0x17e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FR_SWAP_SIGNAL_RECEIVED                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MESSAGE_RX_DISCARDED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MESSAGE_TX_DISCARDED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MESSAGE_TX_FAILED                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MESSAGE_RECEIVED                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MESSAGE_SENT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SIGNAL_RECEIVED                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SIGNAL_SENT                              = " "0, 1"
    tree.end
    tree "USB_PD_PHY_TEST_CTRL"
      sgroup "USB_PD_PHY_TEST_CTRL (at 0x17e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_TX_LOOPBACK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DISCONNECT_CC_BUFFERS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TX_OUTPUT_OVERRIDE_EN                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TX_OUTPUT_OVERRIDE_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST_VREF                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_BANDGAP                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_BIAS_CURRENT                       = " "0, 1"
    tree.end
    tree "USB_PD_PHY_TEST_CTRL2"
      sgroup "USB_PD_PHY_TEST_CTRL2 (at 0x17e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALLOW_BFSK_BIST_MODES                    = " "0, 1"
    tree.end
    tree "USB_PD_PHY_FORCE_ON"
      sgroup "USB_PD_PHY_FORCE_ON (at 0x17e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_FR_SWAP_ON                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FORCE_CR_ON                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_VR_ON                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_BG_ON                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_TX_ON                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_RX_ON                              = " "0, 1"
    tree.end
    tree "USB_PD_PHY_DTEST_BUS"
      sgroup "USB_PD_PHY_DTEST_BUS (at 0x17e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SELECT                                   = "
    tree.end
    tree "USB_PD_PHY_STATUS_TEST_BUS"
      sgroup "USB_PD_PHY_STATUS_TEST_BUS (at 0x17ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SELECT                                   = "
    tree.end
    tree "USB_PD_PHY_DEBUG_STATUS"
      sgroup "USB_PD_PHY_DEBUG_STATUS (at 0x17eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS_BUS                               = "
    tree.end
    tree "USB_PD_PHY_TRIM_NUM"
      sgroup "USB_PD_PHY_TRIM_NUM (at 0x17f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "USB_PD_PHY_TRIM_1"
      sgroup "USB_PD_PHY_TRIM_1 (at 0x17f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_BANDGAP                             = "
    tree.end
    tree "USB_PD_PHY_TRIM_2"
      sgroup "USB_PD_PHY_TRIM_2 (at 0x17f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_IREF                                = "
    tree.end
    tree "USB_PD_PHY_TRIM_3"
      sgroup "USB_PD_PHY_TRIM_3 (at 0x17f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_TXSLOPE                             = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "VDDGEN"
  tree "VDDGEN"
    tree "VDDGEN_REVISION1"
      sgroup "VDDGEN_REVISION1 (at 0x3c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VDDGEN_REVISION2"
      sgroup "VDDGEN_REVISION2 (at 0x3c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VDDGEN_REVISION3"
      sgroup "VDDGEN_REVISION3 (at 0x3c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VDDGEN_REVISION4"
      sgroup "VDDGEN_REVISION4 (at 0x3c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VDDGEN_PERPH_TYPE"
      sgroup "VDDGEN_PERPH_TYPE (at 0x3c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VDDGEN_PERPH_SUBTYPE"
      sgroup "VDDGEN_PERPH_SUBTYPE (at 0x3c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VDDGEN_STATUS1"
      sgroup "VDDGEN_STATUS1 (at 0x3c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_RB                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AVDD_ENABLE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PVDD_RB                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HPM_OK                                   = " "0, 1"
    tree.end
    tree "VDDGEN_AUTO_TRIM_STATUS"
      sgroup "VDDGEN_AUTO_TRIM_STATUS (at 0x3c0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIM_COMP                                = " "0, 1"
    tree.end
    tree "VDDGEN_ONE_REG_CTL"
      sgroup "VDDGEN_ONE_REG_CTL (at 0x3c42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   MODE_CTRL                                = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REF_OVR                                  = " "0 (AUTO),1 (FORCE_MINI_BG)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   CORE_LEVEL_DVDD_SRC_CTRL                 = " "0 (DVDD_SRC_FROM_LDO),1 (DVDD_SRC_FROM_SMPS),2 (DVDD_SRC_FROM_DVDDREG),3 (DVDD_SRC_FROM_DVDDREG1)"
    tree.end
    tree "VDDGEN_SEC_ACCESS"
      sgroup "VDDGEN_SEC_ACCESS (at 0x3cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VDDGEN_PERPH_RESET_CTL2"
      sgroup "VDDGEN_PERPH_RESET_CTL2 (at 0x3cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VDDGEN_PERPH_RESET_CTL3"
      sgroup "VDDGEN_PERPH_RESET_CTL3 (at 0x3cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VDDGEN_PERPH_RESET_CTL4"
      sgroup "VDDGEN_PERPH_RESET_CTL4 (at 0x3cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "VDDGEN_TEST1"
      sgroup "VDDGEN_TEST1 (at 0x3ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "VDDGEN_ATEST_SEL_TEST"
      sgroup "VDDGEN_ATEST_SEL_TEST (at 0x3ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   NOT_USED                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST2_DVDD_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST1_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_VBG_BUFF                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_VBOB_SW_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST2_VPH_SW_EN                         = " "0, 1"
    tree.end
    tree "VDDGEN_VMAX_SEL_TEST"
      sgroup "VDDGEN_VMAX_SEL_TEST (at 0x3ce4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VMAX_SEL                                 = "
    tree.end
    tree "VDDGEN_AVDD_RB_CTL"
      sgroup "VDDGEN_AVDD_RB_CTL (at 0x3ce5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SLEEP_B                           = " "0, 1"
    tree.end
    tree "VDDGEN_AVDD_DVDD_STABILITY_CTL"
      sgroup "VDDGEN_AVDD_DVDD_STABILITY_CTL (at 0x3ce6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RZ_HPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   RZ_LPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "VDDGEN_AUTO_TRIM_CNTL"
      sgroup "VDDGEN_AUTO_TRIM_CNTL (at 0x3ce7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AUTO_TRIM_MODE                           = " "0 (reserved),1 (NON_AUTOTRIM),2 (MINIBG_AUTOTRIM),3 (AVDD_AUTOTRIM)"
    tree.end
    tree "VDDGEN_DTEST_SEL"
      sgroup "VDDGEN_DTEST_SEL (at 0x3ce8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VDDGEN_ONE_REG_FB_CTL"
      sgroup "VDDGEN_ONE_REG_FB_CTL (at 0x3ce9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FEEDBACK_CTRL                            = " "0 (AUTO),1 (LPM),2 (HPM1),3 (HPM2)"
    tree.end
    tree "VDDGEN_TRIM_NUM"
      sgroup "VDDGEN_TRIM_NUM (at 0x3cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "VDDGEN_MINI_BG_TRIM"
      sgroup "VDDGEN_MINI_BG_TRIM (at 0x3cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MINI_BG_TRIM                             = "
    tree.end
    tree "VDDGEN_AVDD_REG_TRIM"
      sgroup "VDDGEN_AVDD_REG_TRIM (at 0x3cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
  tree.end
tree.end
tree "WLED1_CTRL"
  tree "WLED1_CTRL"
    tree "WLED1_CTRL_REVISION1"
      sgroup "WLED1_CTRL_REVISION1 (at 0x1d800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION2"
      sgroup "WLED1_CTRL_REVISION2 (at 0x1d801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION3"
      sgroup "WLED1_CTRL_REVISION3 (at 0x1d802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_CTRL_REVISION4"
      sgroup "WLED1_CTRL_REVISION4 (at 0x1d803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_CTRL_PERPH_TYPE"
      sgroup "WLED1_CTRL_PERPH_TYPE (at 0x1d804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_CTRL_PERPH_SUBTYPE"
      sgroup "WLED1_CTRL_PERPH_SUBTYPE (at 0x1d805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_CTRL_FAULT_STATUS"
      sgroup "WLED1_CTRL_FAULT_STATUS (at 0x1d808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT                               = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_RT_STS"
      sgroup "WLED1_CTRL_INT_RT_STS (at 0x1d810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_RT_STS                        = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_SET_TYPE"
      sgroup "WLED1_CTRL_INT_SET_TYPE (at 0x1d811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TYPE                          = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_POLARITY_HIGH"
      sgroup "WLED1_CTRL_INT_POLARITY_HIGH (at 0x1d812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_HIGH                          = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_POLARITY_LOW"
      sgroup "WLED1_CTRL_INT_POLARITY_LOW (at 0x1d813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LOW                           = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_LATCHED_CLR"
      sgroup "WLED1_CTRL_INT_LATCHED_CLR (at 0x1d814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_EN_SET"
      sgroup "WLED1_CTRL_INT_EN_SET (at 0x1d815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_SET                        = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_EN_CLR"
      sgroup "WLED1_CTRL_INT_EN_CLR (at 0x1d816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_LATCHED_STS"
      sgroup "WLED1_CTRL_INT_LATCHED_STS (at 0x1d818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_PENDING_STS"
      sgroup "WLED1_CTRL_INT_PENDING_STS (at 0x1d819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_PENDING_STS                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_MID_SEL"
      sgroup "WLED1_CTRL_INT_MID_SEL (at 0x1d81a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d81a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_INT_PRIORITY"
      sgroup "WLED1_CTRL_INT_PRIORITY (at 0x1d81b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d81b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "WLED1_CTRL_EN_AMOLED"
      sgroup "WLED1_CTRL_EN_AMOLED (at 0x1d844)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_AMOLED                                = " "0, 1"
    tree.end
    tree "WLED1_CTRL_EXT_PIN_CTL"
      sgroup "WLED1_CTRL_EXT_PIN_CTL (at 0x1d845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_OLED                                  = " "0, 1"
    tree.end
    tree "WLED1_CTRL_MODULE_ENABLE"
      sgroup "WLED1_CTRL_MODULE_ENABLE (at 0x1d846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0, 1"
    tree.end
    tree "WLED1_CTRL_HDR_ADP_CTL"
      sgroup "WLED1_CTRL_HDR_ADP_CTL (at 0x1d847)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_HDR_ADP_DLY_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HDR_ADP_DLY                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_FEEDBACK_CONTROL"
      sgroup "WLED1_CTRL_FEEDBACK_CONTROL (at 0x1d848)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FEEDBACK_CONTROL                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_HDR_ADIM_HDIM"
      sgroup "WLED1_CTRL_HDR_ADIM_HDIM (at 0x1d849)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_ADIM_HDIM                           = "
    tree.end
    tree "WLED1_CTRL_HDR_DDIM"
      sgroup "WLED1_CTRL_HDR_DDIM (at 0x1d84a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_DDIM                                = "
    tree.end
    tree "WLED1_CTRL_BOOST_MIN_ON_OFF_CTL"
      sgroup "WLED1_CTRL_BOOST_MIN_ON_OFF_CTL (at 0x1d84b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BOOST_MIN_ON_TIME                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BOOST_MAX_DUTY_CYCLE                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_SWITCHING_FREQUENCY"
      sgroup "WLED1_CTRL_SWITCHING_FREQUENCY (at 0x1d84c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SWITCHING_FREQ                           = "
    tree.end
    tree "WLED1_CTRL_WLED_OVP"
      sgroup "WLED1_CTRL_WLED_OVP (at 0x1d84d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WLED_OVP                                 = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_WLED_ILIM"
      sgroup "WLED1_CTRL_WLED_ILIM (at 0x1d84e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WLED_ILIM                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_AMOLED_VOUT"
      sgroup "WLED1_CTRL_AMOLED_VOUT (at 0x1d84f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d84f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SEL_SPMI                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_AVDD_PGM                            = "
    tree.end
    tree "WLED1_CTRL_CURRENT_SENSE_RATIO"
      sgroup "WLED1_CTRL_CURRENT_SENSE_RATIO (at 0x1d850)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_RATIO                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SLOPE_COMP_ADJ"
      sgroup "WLED1_CTRL_SLOPE_COMP_ADJ (at 0x1d851)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SLOPE_OFFSET_I_CTRL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_I_CTRL                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_BIAS_GEN_WARMUP_DELAY"
      sgroup "WLED1_CTRL_BIAS_GEN_WARMUP_DELAY (at 0x1d852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BIAS_GEN_WARMUP_DELAY                    = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_SOFTSTART_RAMP_DELAY"
      sgroup "WLED1_CTRL_SOFTSTART_RAMP_DELAY (at 0x1d853)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   AVDD_SOFT_START                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SOFTSTART_RAMP_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_SW_SLEW_RATE_CONTROL"
      sgroup "WLED1_CTRL_SW_SLEW_RATE_CONTROL (at 0x1d854)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SW_SLEW_RATE_CONTROL                     = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_GAIN"
      sgroup "WLED1_CTRL_VLOOP_COMP_GAIN (at 0x1d855)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_RF                                  = "
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_GM"
      sgroup "WLED1_CTRL_VLOOP_COMP_GM (at 0x1d856)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_AUTO_GM                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   AUTO_GM_THRESHOLD                        = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_GM                                  = "
    tree.end
    tree "WLED1_CTRL_VLOOP_COMP_ZERO"
      sgroup "WLED1_CTRL_VLOOP_COMP_ZERO (at 0x1d857)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_RA                                  = "
    tree.end
    tree "WLED1_CTRL_EN_HW_BL_REDN"
      sgroup "WLED1_CTRL_EN_HW_BL_REDN (at 0x1d859)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_HW_BL_REDN                            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_EN_PSM"
      sgroup "WLED1_CTRL_EN_PSM (at 0x1d85a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PSM                                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PSM_CTRL"
      sgroup "WLED1_CTRL_PSM_CTRL (at 0x1d85b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERWRITE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PSM_HYS_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VREF_PSM                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_CTRL_LCD_AUTO_PFM"
      sgroup "WLED1_CTRL_LCD_AUTO_PFM (at 0x1d85c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_AUTO_PFM                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AUTO_PFM_THRESHOLD                       = "
    tree.end
    tree "WLED1_CTRL_WLED_PFM"
      sgroup "WLED1_CTRL_WLED_PFM (at 0x1d85d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_HYS_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_ILIM                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_TOFF                                 = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_WLED_SHORT_PROTECT"
      sgroup "WLED1_CTRL_WLED_SHORT_PROTECT (at 0x1d85e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SC                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PRECHG_VTH_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DBNC_PRECHG                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_DSCHGR                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DBNC_SHORT                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_CTL                                   = " "0, 1"
    tree.end
    tree "WLED1_CTRL_SWIRE_AVDD_DEFAULT"
      sgroup "WLED1_CTRL_SWIRE_AVDD_DEFAULT (at 0x1d85f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d85f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd85f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SWIRE_AVDD_DEFAULT                       = "
    tree.end
    tree "WLED1_CTRL_FAST_PRECHARGE"
      sgroup "WLED1_CTRL_FAST_PRECHARGE (at 0x1d860)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_FAST_PRECHG                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PRECHG_PULSE_PERIOD                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRECHG_PULSE_TON                         = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_CTRL_SEC_ACCESS"
      sgroup "WLED1_CTRL_SEC_ACCESS (at 0x1d8d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL1"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL1 (at 0x1d8d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL2"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL2 (at 0x1d8d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL3"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL3 (at 0x1d8da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_PERPH_RESET_CTL4"
      sgroup "WLED1_CTRL_PERPH_RESET_CTL4 (at 0x1d8db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_TEST1"
      sgroup "WLED1_CTRL_INT_TEST1 (at 0x1d8e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "WLED1_CTRL_INT_TEST_VAL"
      sgroup "WLED1_CTRL_INT_TEST_VAL (at 0x1d8e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_FAULT_TEST_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP_FAULT_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_FAULT_TEST_VAL                      = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST1"
      sgroup "WLED1_CTRL_TEST1 (at 0x1d8e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DTEST                                    = "
    tree.end
    tree "WLED1_CTRL_TEST2"
      sgroup "WLED1_CTRL_TEST2 (at 0x1d8e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST                                    = "
    tree.end
    tree "WLED1_CTRL_TEST3"
      sgroup "WLED1_CTRL_TEST3 (at 0x1d8e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDSON_TM                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   T_ERRAMP_OUT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVP_EN_MASK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SLOPE_COMP_EN_MASK                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_REF_EN_MASK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIM_EN_MASK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ERRAMP_EN_MASK                           = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST4"
      sgroup "WLED1_CTRL_TEST4 (at 0x1d8e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SH_FOR_MIN_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEBOUNCE_BYPASS_ILIM                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_SH_FOR_SS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_CLAMP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEBOUNCE_BYPASS_OVP                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_SLEEP_CLK_REQUEST                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SOFT_START                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENB_IIND_UP                              = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST5"
      sgroup "WLED1_CTRL_TEST5 (at 0x1d8e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VPH_PWR_OK_DEB                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WAIT_VPH_PWR_OK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_HDR_CTRL                              = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TEST6"
      sgroup "WLED1_CTRL_TEST6 (at 0x1d8e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   FUTURE_USE2                              = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENB_HDR_CTRL_FOR_VREF                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BLOCK_EN_FOLLOW_AUTO_PFM_COMP            = " "0, 1"
    tree.end
    tree "WLED1_CTRL_TRIM_NUM"
      sgroup "WLED1_CTRL_TRIM_NUM (at 0x1d8f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_CTRL_TRIM_ILIM"
      sgroup "WLED1_CTRL_TRIM_ILIM (at 0x1d8f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_ILIM                                = "
    tree.end
    tree "WLED1_CTRL_AMOLED_VOUT_TRIM"
      sgroup "WLED1_CTRL_AMOLED_VOUT_TRIM (at 0x1d8f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   AVDD_TRIM                                = "
    tree.end
    tree "WLED1_CTRL_WLED_OVP_TRIM"
      sgroup "WLED1_CTRL_WLED_OVP_TRIM (at 0x1d8f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OVP_REF_TRIM                             = "
    tree.end
    tree "WLED1_CTRL_WLED_REF_TRIM"
      sgroup "WLED1_CTRL_WLED_REF_TRIM (at 0x1d8f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        set &access:&cmd_addr %l 0x80d8f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd8f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_WLED_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "WLED1_SINK"
  tree "WLED1_SINK"
    tree "WLED1_SINK_REVISION1"
      sgroup "WLED1_SINK_REVISION1 (at 0x1d900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION2"
      sgroup "WLED1_SINK_REVISION2 (at 0x1d901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION3"
      sgroup "WLED1_SINK_REVISION3 (at 0x1d902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "WLED1_SINK_REVISION4"
      sgroup "WLED1_SINK_REVISION4 (at 0x1d903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "WLED1_SINK_PERPH_TYPE"
      sgroup "WLED1_SINK_PERPH_TYPE (at 0x1d904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "WLED1_SINK_PERPH_SUBTYPE"
      sgroup "WLED1_SINK_PERPH_SUBTYPE (at 0x1d905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "WLED1_SINK_CURRENT_SINK_EN"
      sgroup "WLED1_SINK_CURRENT_SINK_EN (at 0x1d946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_SINK4                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_CURRENT_SINK3                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_CURRENT_SINK2                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_CURRENT_SINK1                         = " "0, 1"
    tree.end
    tree "WLED1_SINK_ILED_SYNC_BIT"
      sgroup "WLED1_SINK_ILED_SYNC_BIT (at 0x1d947)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYNC_LED4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SYNC_LED3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_LED2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_LED1                                = " "0, 1"
    tree.end
    tree "WLED1_SINK_DIG_DIM_CLK_SEL"
      sgroup "WLED1_SINK_DIG_DIM_CLK_SEL (at 0x1d948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIG_DIM_CLK_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_SINK_MODULATION_SCHEME"
      sgroup "WLED1_SINK_MODULATION_SCHEME (at 0x1d94a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   MODULATOR_CLOCK_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PHASE_STAGGERING                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   ACCUMULATOR_CLOCK_SEL                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HYBRID_DIMMING                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INTERNAL_MOD_RESOLUTION                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIMMING_METHOD                           = " "0, 1"
    tree.end
    tree "WLED1_SINK_HYBRID_DIMMING_TRESH"
      sgroup "WLED1_SINK_HYBRID_DIMMING_TRESH (at 0x1d94b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   HYBRID_DIM_THRESH                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_WLED_BAN"
      sgroup "WLED1_SINK_WLED_BAN (at 0x1d94c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAN_RECOVERY_MODE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAN_FASTRECOVERY_ACCRES                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   BAN_CLIP                                 = "
    tree.end
    tree "WLED1_SINK_WLED_BAN_TIMER"
      sgroup "WLED1_SINK_WLED_BAN_TIMER (at 0x1d94d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   BAN_RECOVERY_STEP                        = "
    tree.end
    tree "WLED1_SINK_WLED_BAN_STATUS"
      sgroup "WLED1_SINK_WLED_BAN_STATUS (at 0x1d94e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CS4_BAN_STATE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CS3_BAN_STATE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CS2_BAN_STATE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CS1_BAN_STATE                            = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_SINK_WLED_ACCUM_STATUS"
      sgroup "WLED1_SINK_WLED_ACCUM_STATUS (at 0x1d94f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d94f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd94f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CS1_ACCUM_MSB                            = "
    tree.end
    tree "WLED1_SINK_LED1_MODULATOR_EN"
      sgroup "WLED1_SINK_LED1_MODULATOR_EN (at 0x1d950)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED1_IDAC_SYNC_DELAY (at 0x1d951)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED1_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED1_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED1_FULL_SCALE_CURRENT (at 0x1d952)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED1_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED1_MODULATOR_SRC_SEL (at 0x1d953)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_CABC_EN"
      sgroup "WLED1_SINK_LED1_CABC_EN (at 0x1d956)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED1_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED1_BRIGHTNESS_SETTING_LSB (at 0x1d957)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED1_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED1_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED1_BRIGHTNESS_SETTING_MSB (at 0x1d958)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED1_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED2_MODULATOR_EN"
      sgroup "WLED1_SINK_LED2_MODULATOR_EN (at 0x1d960)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED2_IDAC_SYNC_DELAY (at 0x1d961)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED2_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED2_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED2_FULL_SCALE_CURRENT (at 0x1d962)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED2_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED2_MODULATOR_SRC_SEL (at 0x1d963)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED2_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_CABC_EN"
      sgroup "WLED1_SINK_LED2_CABC_EN (at 0x1d966)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED2_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED2_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED2_BRIGHTNESS_SETTING_LSB (at 0x1d967)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED2_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED2_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED2_BRIGHTNESS_SETTING_MSB (at 0x1d968)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED3_MODULATOR_EN"
      sgroup "WLED1_SINK_LED3_MODULATOR_EN (at 0x1d970)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED3_IDAC_SYNC_DELAY (at 0x1d971)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED3_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED3_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED3_FULL_SCALE_CURRENT (at 0x1d972)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED3_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED3_MODULATOR_SRC_SEL (at 0x1d973)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED3_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_CABC_EN"
      sgroup "WLED1_SINK_LED3_CABC_EN (at 0x1d976)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED3_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED3_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED3_BRIGHTNESS_SETTING_LSB (at 0x1d977)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED3_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED3_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED3_BRIGHTNESS_SETTING_MSB (at 0x1d978)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED3_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_LED4_MODULATOR_EN"
      sgroup "WLED1_SINK_LED4_MODULATOR_EN (at 0x1d980)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED4_EN_MODULATOR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_GATEDRV                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_IDAC_SYNC_DELAY"
      sgroup "WLED1_SINK_LED4_IDAC_SYNC_DELAY (at 0x1d981)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LED4_IDAC_SYNC_DELAY                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "WLED1_SINK_LED4_FULL_SCALE_CURRENT"
      sgroup "WLED1_SINK_LED4_FULL_SCALE_CURRENT (at 0x1d982)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED4_FULL_SCALE_CURRENT                  = "
    tree.end
    tree "WLED1_SINK_LED4_MODULATOR_SRC_SEL"
      sgroup "WLED1_SINK_LED4_MODULATOR_SRC_SEL (at 0x1d983)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED4_MODULATOR_SRC_SEL                   = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_CABC_EN"
      sgroup "WLED1_SINK_LED4_CABC_EN (at 0x1d986)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED4_CABC_EN                             = " "0, 1"
    tree.end
    tree "WLED1_SINK_LED4_BRIGHTNESS_SETTING_LSB"
      sgroup "WLED1_SINK_LED4_BRIGHTNESS_SETTING_LSB (at 0x1d987)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LED4_BRIGHTNESS_SETTING_LSB              = "
    tree.end
    tree "WLED1_SINK_LED4_BRIGHTNESS_SETTING_MSB"
      sgroup "WLED1_SINK_LED4_BRIGHTNESS_SETTING_MSB (at 0x1d988)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED4_BRIGHTNESS_SETTING_MSB              = "
    tree.end
    tree "WLED1_SINK_SEC_ACCESS"
      sgroup "WLED1_SINK_SEC_ACCESS (at 0x1d9d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL1"
      sgroup "WLED1_SINK_PERPH_RESET_CTL1 (at 0x1d9d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL2"
      sgroup "WLED1_SINK_PERPH_RESET_CTL2 (at 0x1d9d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL3"
      sgroup "WLED1_SINK_PERPH_RESET_CTL3 (at 0x1d9da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "WLED1_SINK_PERPH_RESET_CTL4"
      sgroup "WLED1_SINK_PERPH_RESET_CTL4 (at 0x1d9db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "WLED1_SINK_TEST5"
      sgroup "WLED1_SINK_TEST5 (at 0x1d9e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CS_TGATE_ATEST                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CS_GATE_DRV_THRESH                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CS_HVG_PULL_STR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CS_OTA_COMP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CS_FSTON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CS_FASTOTA                               = " "0, 1"
    tree.end
    tree "WLED1_SINK_MAN_CAL_CTL"
      sgroup "WLED1_SINK_MAN_CAL_CTL (at 0x1d9e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAN_CS_OTA_CAL_EN                        = " "0, 1"
    tree.end
    tree "WLED1_SINK_TEST6"
      sgroup "WLED1_SINK_TEST6 (at 0x1d9e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CHOP                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_BAN_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SW_BAN_FORCE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CHOP_TEST                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_CHOP_TEST_FREQ                       = " "0, 1, 2, 3"
    tree.end
    tree "WLED1_SINK_TEST7"
      sgroup "WLED1_SINK_TEST7 (at 0x1d9e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FUTURE_USE3                              = "
    tree.end
    tree "WLED1_SINK_TRIM_NUM"
      sgroup "WLED1_SINK_TRIM_NUM (at 0x1d9f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED1"
      sgroup "WLED1_SINK_TRIM_VREF_ILED1 (at 0x1d9f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED1                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED2"
      sgroup "WLED1_SINK_TRIM_VREF_ILED2 (at 0x1d9f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED2                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED3"
      sgroup "WLED1_SINK_TRIM_VREF_ILED3 (at 0x1d9f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED3                          = "
    tree.end
    tree "WLED1_SINK_TRIM_VREF_ILED4"
      sgroup "WLED1_SINK_TRIM_VREF_ILED4 (at 0x1d9f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_VREF_ILED4                          = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED1"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED1 (at 0x1d9f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED1                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED2"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED2 (at 0x1d9f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED2                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED3"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED3 (at 0x1d9f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED3                        = "
    tree.end
    tree "WLED1_SINK_TRIM_OFFSET_ILED4"
      sgroup "WLED1_SINK_TRIM_OFFSET_ILED4 (at 0x1d9f8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_OFFSET_ILED4                        = "
    tree.end
    tree "WLED1_SINK_KILL_SWITCH"
      sgroup "WLED1_SINK_KILL_SWITCH (at 0x1d9f9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        set &access:&cmd_addr %l 0x80d9f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd9f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   KILL_SWITCH                              = "
    tree.end
  tree.end
tree.end

